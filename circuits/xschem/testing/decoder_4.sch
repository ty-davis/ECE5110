v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1270 -60 1270 0 { }
N 1180 -60 1180 0 { }
N 1450 -60 1450 0 { }
N 1360 -60 1360 0 { }
N 1630 -60 1630 0 { }
N 1540 -60 1540 0 { }
N 1810 -60 1810 0 { }
N 1720 -60 1720 0 { }
N 1990 -60 1990 0 { }
N 1900 -60 1900 0 { }
N 2170 -60 2170 0 { }
N 2080 -60 2080 0 { }
N 1070 -60 1070 0 {lab=A0}
N 970 -40 970 -30 {lab=N_A0}
N 970 -30 980 -30 {lab=N_A0}
N 980 -30 980 0 {lab=N_A0}
N 890 -60 890 0 {lab=A1}
N 790 -40 790 -30 {lab=N_A1}
N 790 -30 800 -30 {lab=N_A1}
N 800 -30 800 0 {lab=N_A1}
N 710 -60 710 0 {lab=A2}
N 610 -40 610 -30 {lab=N_A2}
N 610 -30 620 -30 {lab=N_A2}
N 620 -30 620 0 {lab=N_A2}
N 530 -60 530 0 {lab=A3}
N 430 -40 430 -30 {lab=N_A3}
N 430 -30 440 -30 {lab=N_A3}
N 440 -30 440 0 {lab=N_A3}
N 350 -60 350 0 {lab=A4}
N 250 -40 250 -30 {lab=N_A4}
N 250 -30 260 -30 {lab=N_A4}
N 260 -30 260 0 {lab=N_A4}
N 170 -60 170 0 {lab=A5}
N 70 -40 70 -30 {lab=N_A5}
N 70 -30 80 -30 {lab=N_A5}
N 80 -30 80 0 {lab=N_A5}
N 2170 0 2170 80 {lab=N_A5}
N 2160 70 2250 70 {lab=word0}
N 2120 40 2130 40 {lab=GND}
N 2130 10 2130 40 {lab=GND}
N 2120 10 2130 10 {lab=GND}
N 2080 0 2080 40 {lab=A5}
N 2080 40 2080 80 {lab=A5}
N 2070 70 2120 70 {lab=word0}
N 2120 70 2160 70 {lab=word0}
N 1990 0 1990 80 {lab=N_A4}
N 1980 70 2070 70 {lab=word0}
N 1940 40 1950 40 {lab=GND}
N 1950 10 1950 40 {lab=GND}
N 1940 10 1950 10 {lab=GND}
N 1900 0 1900 40 {lab=A4}
N 1900 40 1900 80 {lab=A4}
N 1890 70 1940 70 {lab=word0}
N 1940 70 1980 70 {lab=word0}
N 1810 0 1810 80 {lab=N_A3}
N 1800 70 1890 70 {lab=word0}
N 1760 40 1770 40 {lab=GND}
N 1770 10 1770 40 {lab=GND}
N 1760 10 1770 10 {lab=GND}
N 1720 0 1720 40 {lab=A3}
N 1720 40 1720 80 {lab=A3}
N 1710 70 1760 70 {lab=word0}
N 1760 70 1800 70 {lab=word0}
N 1630 0 1630 80 {lab=N_A2}
N 1620 70 1710 70 {lab=word0}
N 1580 40 1590 40 {lab=GND}
N 1590 10 1590 40 {lab=GND}
N 1580 10 1590 10 {lab=GND}
N 1540 0 1540 40 {lab=A2}
N 1540 40 1540 80 {lab=A2}
N 1530 70 1580 70 {lab=word0}
N 1580 70 1620 70 {lab=word0}
N 1450 0 1450 80 {lab=N_A1}
N 1440 70 1530 70 {lab=word0}
N 1400 40 1410 40 {lab=GND}
N 1410 10 1410 40 {lab=GND}
N 1400 10 1410 10 {lab=GND}
N 1360 0 1360 40 {lab=A1}
N 1360 40 1360 80 {lab=A1}
N 1350 70 1400 70 {lab=word0}
N 1400 70 1440 70 {lab=word0}
N 1270 0 1270 80 {lab=N_A0}
N 1260 70 1350 70 {lab=word0}
N 1220 40 1230 40 {lab=GND}
N 1230 10 1230 40 {lab=GND}
N 1220 10 1230 10 {lab=GND}
N 1180 0 1180 40 {lab=A0}
N 1180 40 1180 80 {lab=A0}
N 1170 70 1220 70 {lab=word0}
N 1220 70 1260 70 {lab=word0}
N 1080 70 1170 70 { }
N 1030 30 1070 30 {lab=A6}
N 1030 70 1030 80 {lab=VDD}
N 1060 70 1080 70 {lab=word0}
N 990 70 1000 70 {lab=#net013}
N 1070 0 1070 30 {lab=A6}
N 1070 30 1070 80 {lab=A6}
N 980 0 980 80 {lab=N_A7}
N 900 70 990 70 {lab=#net013}
N 850 30 890 30 {lab=A7}
N 850 70 850 80 {lab=VDD}
N 880 70 900 70 {lab=#net013}
N 810 70 820 70 {lab=#net015}
N 890 0 890 30 {lab=A7}
N 890 30 890 80 {lab=A7}
N 800 0 800 80 {lab=N_A8}
N 720 70 810 70 {lab=#net015}
N 670 30 710 30 {lab=A8}
N 670 70 670 80 {lab=VDD}
N 700 70 720 70 {lab=#net015}
N 630 70 640 70 {lab=#net017}
N 710 0 710 30 {lab=A8}
N 710 30 710 80 {lab=A8}
N 620 0 620 80 {lab=N_A9}
N 540 70 630 70 {lab=#net017}
N 490 30 530 30 {lab=A9}
N 490 70 490 80 {lab=VDD}
N 520 70 540 70 {lab=#net017}
N 450 70 460 70 {lab=#net019}
N 530 0 530 30 {lab=A9}
N 530 30 530 80 {lab=A9}
N 440 0 440 80 {lab=N_A10}
N 360 70 450 70 {lab=#net019}
N 310 30 350 30 {lab=A10}
N 310 70 310 80 {lab=VDD}
N 340 70 360 70 {lab=#net019}
N 270 70 280 70 {lab=#net021}
N 350 0 350 30 {lab=A10}
N 350 30 350 80 {lab=A10}
N 260 0 260 80 {lab=N_A11}
N 180 70 270 70 {lab=#net021}
N 130 30 170 30 {lab=A11}
N 130 70 130 80 {lab=VDD}
N 160 70 180 70 {lab=#net021}
N 90 70 100 70 {lab=#net023}
N 170 0 170 30 {lab=A11}
N 170 30 170 80 {lab=A11}
N 80 0 80 80 {lab=N_A12}
N 0 70 90 70 {lab=#net023}
N 0 0 0 80 { }
N 2170 80 2170 160 {lab=N_A5}
N 2160 150 2250 150 {lab=word1}
N 2120 120 2130 120 {lab=GND}
N 2130 90 2130 120 {lab=GND}
N 2120 90 2130 90 {lab=GND}
N 2080 80 2080 120 {lab=A5}
N 2080 120 2080 160 {lab=A5}
N 2070 150 2120 150 {lab=word1}
N 2120 150 2160 150 {lab=word1}
N 1990 80 1990 160 {lab=N_A4}
N 1980 150 2070 150 {lab=word1}
N 1940 120 1950 120 {lab=GND}
N 1950 90 1950 120 {lab=GND}
N 1940 90 1950 90 {lab=GND}
N 1900 80 1900 120 {lab=A4}
N 1900 120 1900 160 {lab=A4}
N 1890 150 1940 150 {lab=word1}
N 1940 150 1980 150 {lab=word1}
N 1810 80 1810 160 {lab=N_A3}
N 1800 150 1890 150 {lab=word1}
N 1760 120 1770 120 {lab=GND}
N 1770 90 1770 120 {lab=GND}
N 1760 90 1770 90 {lab=GND}
N 1720 80 1720 120 {lab=A3}
N 1720 120 1720 160 {lab=A3}
N 1710 150 1760 150 {lab=word1}
N 1760 150 1800 150 {lab=word1}
N 1630 80 1630 160 {lab=N_A2}
N 1620 150 1710 150 {lab=word1}
N 1580 120 1590 120 {lab=GND}
N 1590 90 1590 120 {lab=GND}
N 1580 90 1590 90 {lab=GND}
N 1540 80 1540 120 {lab=A2}
N 1540 120 1540 160 {lab=A2}
N 1530 150 1580 150 {lab=word1}
N 1580 150 1620 150 {lab=word1}
N 1450 80 1450 160 {lab=N_A1}
N 1440 150 1530 150 {lab=word1}
N 1400 120 1410 120 {lab=GND}
N 1410 90 1410 120 {lab=GND}
N 1400 90 1410 90 {lab=GND}
N 1360 80 1360 120 {lab=A1}
N 1360 120 1360 160 {lab=A1}
N 1350 150 1400 150 {lab=word1}
N 1400 150 1440 150 {lab=word1}
N 1310 120 1320 120 {lab=GND}
N 1320 90 1320 120 {lab=GND}
N 1310 90 1320 90 {lab=GND}
N 1270 80 1270 120 {lab=N_A0}
N 1270 120 1270 160 {lab=N_A0}
N 1260 150 1310 150 {lab=word1}
N 1310 150 1350 150 {lab=word1}
N 1180 80 1180 160 {lab=A0}
N 1170 150 1260 150 {lab=word1}
N 1080 150 1170 150 { }
N 1070 80 1070 160 {lab=A6}
N 990 150 1080 150 {lab=word1}
N 940 110 980 110 {lab=N_A7}
N 940 150 940 160 {lab=VDD}
N 970 150 990 150 {lab=word1}
N 900 150 910 150 {lab=#net113}
N 980 80 980 110 {lab=N_A7}
N 980 110 980 160 {lab=N_A7}
N 850 110 890 110 {lab=A7}
N 850 150 850 160 {lab=VDD}
N 880 150 900 150 {lab=#net113}
N 810 150 820 150 {lab=#net115}
N 890 80 890 110 {lab=A7}
N 890 110 890 160 {lab=A7}
N 800 80 800 160 {lab=N_A8}
N 720 150 810 150 {lab=#net115}
N 670 110 710 110 {lab=A8}
N 670 150 670 160 {lab=VDD}
N 700 150 720 150 {lab=#net115}
N 630 150 640 150 {lab=#net117}
N 710 80 710 110 {lab=A8}
N 710 110 710 160 {lab=A8}
N 620 80 620 160 {lab=N_A9}
N 540 150 630 150 {lab=#net117}
N 490 110 530 110 {lab=A9}
N 490 150 490 160 {lab=VDD}
N 520 150 540 150 {lab=#net117}
N 450 150 460 150 {lab=#net119}
N 530 80 530 110 {lab=A9}
N 530 110 530 160 {lab=A9}
N 440 80 440 160 {lab=N_A10}
N 360 150 450 150 {lab=#net119}
N 310 110 350 110 {lab=A10}
N 310 150 310 160 {lab=VDD}
N 340 150 360 150 {lab=#net119}
N 270 150 280 150 {lab=#net121}
N 350 80 350 110 {lab=A10}
N 350 110 350 160 {lab=A10}
N 260 80 260 160 {lab=N_A11}
N 180 150 270 150 {lab=#net121}
N 130 110 170 110 {lab=A11}
N 130 150 130 160 {lab=VDD}
N 160 150 180 150 {lab=#net121}
N 90 150 100 150 {lab=#net123}
N 170 80 170 110 {lab=A11}
N 170 110 170 160 {lab=A11}
N 80 80 80 160 {lab=N_A12}
N 0 150 90 150 {lab=#net123}
N 0 80 0 160 { }
N 2170 160 2170 240 {lab=N_A5}
N 2160 230 2250 230 {lab=word2}
N 2120 200 2130 200 {lab=GND}
N 2130 170 2130 200 {lab=GND}
N 2120 170 2130 170 {lab=GND}
N 2080 160 2080 200 {lab=A5}
N 2080 200 2080 240 {lab=A5}
N 2070 230 2120 230 {lab=word2}
N 2120 230 2160 230 {lab=word2}
N 1990 160 1990 240 {lab=N_A4}
N 1980 230 2070 230 {lab=word2}
N 1940 200 1950 200 {lab=GND}
N 1950 170 1950 200 {lab=GND}
N 1940 170 1950 170 {lab=GND}
N 1900 160 1900 200 {lab=A4}
N 1900 200 1900 240 {lab=A4}
N 1890 230 1940 230 {lab=word2}
N 1940 230 1980 230 {lab=word2}
N 1810 160 1810 240 {lab=N_A3}
N 1800 230 1890 230 {lab=word2}
N 1760 200 1770 200 {lab=GND}
N 1770 170 1770 200 {lab=GND}
N 1760 170 1770 170 {lab=GND}
N 1720 160 1720 200 {lab=A3}
N 1720 200 1720 240 {lab=A3}
N 1710 230 1760 230 {lab=word2}
N 1760 230 1800 230 {lab=word2}
N 1630 160 1630 240 {lab=N_A2}
N 1620 230 1710 230 {lab=word2}
N 1580 200 1590 200 {lab=GND}
N 1590 170 1590 200 {lab=GND}
N 1580 170 1590 170 {lab=GND}
N 1540 160 1540 200 {lab=A2}
N 1540 200 1540 240 {lab=A2}
N 1530 230 1580 230 {lab=word2}
N 1580 230 1620 230 {lab=word2}
N 1490 200 1500 200 {lab=GND}
N 1500 170 1500 200 {lab=GND}
N 1490 170 1500 170 {lab=GND}
N 1450 160 1450 200 {lab=N_A1}
N 1450 200 1450 240 {lab=N_A1}
N 1440 230 1490 230 {lab=word2}
N 1490 230 1530 230 {lab=word2}
N 1360 160 1360 240 {lab=A1}
N 1350 230 1440 230 {lab=word2}
N 1270 160 1270 240 {lab=N_A0}
N 1260 230 1350 230 {lab=word2}
N 1220 200 1230 200 {lab=GND}
N 1230 170 1230 200 {lab=GND}
N 1220 170 1230 170 {lab=GND}
N 1180 160 1180 200 {lab=A0}
N 1180 200 1180 240 {lab=A0}
N 1170 230 1220 230 {lab=word2}
N 1220 230 1260 230 {lab=word2}
N 1080 230 1170 230 { }
N 1030 190 1070 190 {lab=A6}
N 1030 230 1030 240 {lab=VDD}
N 1060 230 1080 230 {lab=word2}
N 990 230 1000 230 {lab=#net213}
N 1070 160 1070 190 {lab=A6}
N 1070 190 1070 240 {lab=A6}
N 980 160 980 240 {lab=N_A7}
N 900 230 990 230 {lab=#net213}
N 890 160 890 240 {lab=A7}
N 810 230 900 230 {lab=#net213}
N 760 190 800 190 {lab=N_A8}
N 760 230 760 240 {lab=VDD}
N 790 230 810 230 {lab=#net213}
N 720 230 730 230 {lab=#net215}
N 800 160 800 190 {lab=N_A8}
N 800 190 800 240 {lab=N_A8}
N 670 190 710 190 {lab=A8}
N 670 230 670 240 {lab=VDD}
N 700 230 720 230 {lab=#net215}
N 630 230 640 230 {lab=#net217}
N 710 160 710 190 {lab=A8}
N 710 190 710 240 {lab=A8}
N 620 160 620 240 {lab=N_A9}
N 540 230 630 230 {lab=#net217}
N 490 190 530 190 {lab=A9}
N 490 230 490 240 {lab=VDD}
N 520 230 540 230 {lab=#net217}
N 450 230 460 230 {lab=#net219}
N 530 160 530 190 {lab=A9}
N 530 190 530 240 {lab=A9}
N 440 160 440 240 {lab=N_A10}
N 360 230 450 230 {lab=#net219}
N 310 190 350 190 {lab=A10}
N 310 230 310 240 {lab=VDD}
N 340 230 360 230 {lab=#net219}
N 270 230 280 230 {lab=#net221}
N 350 160 350 190 {lab=A10}
N 350 190 350 240 {lab=A10}
N 260 160 260 240 {lab=N_A11}
N 180 230 270 230 {lab=#net221}
N 130 190 170 190 {lab=A11}
N 130 230 130 240 {lab=VDD}
N 160 230 180 230 {lab=#net221}
N 90 230 100 230 {lab=#net223}
N 170 160 170 190 {lab=A11}
N 170 190 170 240 {lab=A11}
N 80 160 80 240 {lab=N_A12}
N 0 230 90 230 {lab=#net223}
N 0 160 0 240 { }
N 2170 240 2170 320 {lab=N_A5}
N 2160 310 2250 310 {lab=word3}
N 2120 280 2130 280 {lab=GND}
N 2130 250 2130 280 {lab=GND}
N 2120 250 2130 250 {lab=GND}
N 2080 240 2080 280 {lab=A5}
N 2080 280 2080 320 {lab=A5}
N 2070 310 2120 310 {lab=word3}
N 2120 310 2160 310 {lab=word3}
N 1990 240 1990 320 {lab=N_A4}
N 1980 310 2070 310 {lab=word3}
N 1940 280 1950 280 {lab=GND}
N 1950 250 1950 280 {lab=GND}
N 1940 250 1950 250 {lab=GND}
N 1900 240 1900 280 {lab=A4}
N 1900 280 1900 320 {lab=A4}
N 1890 310 1940 310 {lab=word3}
N 1940 310 1980 310 {lab=word3}
N 1810 240 1810 320 {lab=N_A3}
N 1800 310 1890 310 {lab=word3}
N 1760 280 1770 280 {lab=GND}
N 1770 250 1770 280 {lab=GND}
N 1760 250 1770 250 {lab=GND}
N 1720 240 1720 280 {lab=A3}
N 1720 280 1720 320 {lab=A3}
N 1710 310 1760 310 {lab=word3}
N 1760 310 1800 310 {lab=word3}
N 1630 240 1630 320 {lab=N_A2}
N 1620 310 1710 310 {lab=word3}
N 1580 280 1590 280 {lab=GND}
N 1590 250 1590 280 {lab=GND}
N 1580 250 1590 250 {lab=GND}
N 1540 240 1540 280 {lab=A2}
N 1540 280 1540 320 {lab=A2}
N 1530 310 1580 310 {lab=word3}
N 1580 310 1620 310 {lab=word3}
N 1490 280 1500 280 {lab=GND}
N 1500 250 1500 280 {lab=GND}
N 1490 250 1500 250 {lab=GND}
N 1450 240 1450 280 {lab=N_A1}
N 1450 280 1450 320 {lab=N_A1}
N 1440 310 1490 310 {lab=word3}
N 1490 310 1530 310 {lab=word3}
N 1360 240 1360 320 {lab=A1}
N 1350 310 1440 310 {lab=word3}
N 1310 280 1320 280 {lab=GND}
N 1320 250 1320 280 {lab=GND}
N 1310 250 1320 250 {lab=GND}
N 1270 240 1270 280 {lab=N_A0}
N 1270 280 1270 320 {lab=N_A0}
N 1260 310 1310 310 {lab=word3}
N 1310 310 1350 310 {lab=word3}
N 1180 240 1180 320 {lab=A0}
N 1170 310 1260 310 {lab=word3}
N 1080 310 1170 310 { }
N 1070 240 1070 320 {lab=A6}
N 990 310 1080 310 {lab=word3}
N 940 270 980 270 {lab=N_A7}
N 940 310 940 320 {lab=VDD}
N 970 310 990 310 {lab=word3}
N 900 310 910 310 {lab=#net313}
N 980 240 980 270 {lab=N_A7}
N 980 270 980 320 {lab=N_A7}
N 890 240 890 320 {lab=A7}
N 810 310 900 310 {lab=#net313}
N 760 270 800 270 {lab=N_A8}
N 760 310 760 320 {lab=VDD}
N 790 310 810 310 {lab=#net313}
N 720 310 730 310 {lab=#net315}
N 800 240 800 270 {lab=N_A8}
N 800 270 800 320 {lab=N_A8}
N 670 270 710 270 {lab=A8}
N 670 310 670 320 {lab=VDD}
N 700 310 720 310 {lab=#net315}
N 630 310 640 310 {lab=#net317}
N 710 240 710 270 {lab=A8}
N 710 270 710 320 {lab=A8}
N 620 240 620 320 {lab=N_A9}
N 540 310 630 310 {lab=#net317}
N 490 270 530 270 {lab=A9}
N 490 310 490 320 {lab=VDD}
N 520 310 540 310 {lab=#net317}
N 450 310 460 310 {lab=#net319}
N 530 240 530 270 {lab=A9}
N 530 270 530 320 {lab=A9}
N 440 240 440 320 {lab=N_A10}
N 360 310 450 310 {lab=#net319}
N 310 270 350 270 {lab=A10}
N 310 310 310 320 {lab=VDD}
N 340 310 360 310 {lab=#net319}
N 270 310 280 310 {lab=#net321}
N 350 240 350 270 {lab=A10}
N 350 270 350 320 {lab=A10}
N 260 240 260 320 {lab=N_A11}
N 180 310 270 310 {lab=#net321}
N 130 270 170 270 {lab=A11}
N 130 310 130 320 {lab=VDD}
N 160 310 180 310 {lab=#net321}
N 90 310 100 310 {lab=#net323}
N 170 240 170 270 {lab=A11}
N 170 270 170 320 {lab=A11}
N 80 240 80 320 {lab=N_A12}
N 0 310 90 310 {lab=#net323}
N 0 240 0 320 { }
N 2170 320 2170 400 {lab=N_A5}
N 2160 390 2250 390 {lab=word4}
N 2120 360 2130 360 {lab=GND}
N 2130 330 2130 360 {lab=GND}
N 2120 330 2130 330 {lab=GND}
N 2080 320 2080 360 {lab=A5}
N 2080 360 2080 400 {lab=A5}
N 2070 390 2120 390 {lab=word4}
N 2120 390 2160 390 {lab=word4}
N 1990 320 1990 400 {lab=N_A4}
N 1980 390 2070 390 {lab=word4}
N 1940 360 1950 360 {lab=GND}
N 1950 330 1950 360 {lab=GND}
N 1940 330 1950 330 {lab=GND}
N 1900 320 1900 360 {lab=A4}
N 1900 360 1900 400 {lab=A4}
N 1890 390 1940 390 {lab=word4}
N 1940 390 1980 390 {lab=word4}
N 1810 320 1810 400 {lab=N_A3}
N 1800 390 1890 390 {lab=word4}
N 1760 360 1770 360 {lab=GND}
N 1770 330 1770 360 {lab=GND}
N 1760 330 1770 330 {lab=GND}
N 1720 320 1720 360 {lab=A3}
N 1720 360 1720 400 {lab=A3}
N 1710 390 1760 390 {lab=word4}
N 1760 390 1800 390 {lab=word4}
N 1670 360 1680 360 {lab=GND}
N 1680 330 1680 360 {lab=GND}
N 1670 330 1680 330 {lab=GND}
N 1630 320 1630 360 {lab=N_A2}
N 1630 360 1630 400 {lab=N_A2}
N 1620 390 1670 390 {lab=word4}
N 1670 390 1710 390 {lab=word4}
N 1540 320 1540 400 {lab=A2}
N 1530 390 1620 390 {lab=word4}
N 1450 320 1450 400 {lab=N_A1}
N 1440 390 1530 390 {lab=word4}
N 1400 360 1410 360 {lab=GND}
N 1410 330 1410 360 {lab=GND}
N 1400 330 1410 330 {lab=GND}
N 1360 320 1360 360 {lab=A1}
N 1360 360 1360 400 {lab=A1}
N 1350 390 1400 390 {lab=word4}
N 1400 390 1440 390 {lab=word4}
N 1270 320 1270 400 {lab=N_A0}
N 1260 390 1350 390 {lab=word4}
N 1220 360 1230 360 {lab=GND}
N 1230 330 1230 360 {lab=GND}
N 1220 330 1230 330 {lab=GND}
N 1180 320 1180 360 {lab=A0}
N 1180 360 1180 400 {lab=A0}
N 1170 390 1220 390 {lab=word4}
N 1220 390 1260 390 {lab=word4}
N 1080 390 1170 390 { }
N 1030 350 1070 350 {lab=A6}
N 1030 390 1030 400 {lab=VDD}
N 1060 390 1080 390 {lab=word4}
N 990 390 1000 390 {lab=#net413}
N 1070 320 1070 350 {lab=A6}
N 1070 350 1070 400 {lab=A6}
N 980 320 980 400 {lab=N_A7}
N 900 390 990 390 {lab=#net413}
N 850 350 890 350 {lab=A7}
N 850 390 850 400 {lab=VDD}
N 880 390 900 390 {lab=#net413}
N 810 390 820 390 {lab=#net415}
N 890 320 890 350 {lab=A7}
N 890 350 890 400 {lab=A7}
N 800 320 800 400 {lab=N_A8}
N 720 390 810 390 {lab=#net415}
N 710 320 710 400 {lab=A8}
N 630 390 720 390 {lab=#net415}
N 580 350 620 350 {lab=N_A9}
N 580 390 580 400 {lab=VDD}
N 610 390 630 390 {lab=#net415}
N 540 390 550 390 {lab=#net417}
N 620 320 620 350 {lab=N_A9}
N 620 350 620 400 {lab=N_A9}
N 490 350 530 350 {lab=A9}
N 490 390 490 400 {lab=VDD}
N 520 390 540 390 {lab=#net417}
N 450 390 460 390 {lab=#net419}
N 530 320 530 350 {lab=A9}
N 530 350 530 400 {lab=A9}
N 440 320 440 400 {lab=N_A10}
N 360 390 450 390 {lab=#net419}
N 310 350 350 350 {lab=A10}
N 310 390 310 400 {lab=VDD}
N 340 390 360 390 {lab=#net419}
N 270 390 280 390 {lab=#net421}
N 350 320 350 350 {lab=A10}
N 350 350 350 400 {lab=A10}
N 260 320 260 400 {lab=N_A11}
N 180 390 270 390 {lab=#net421}
N 130 350 170 350 {lab=A11}
N 130 390 130 400 {lab=VDD}
N 160 390 180 390 {lab=#net421}
N 90 390 100 390 {lab=#net423}
N 170 320 170 350 {lab=A11}
N 170 350 170 400 {lab=A11}
N 80 320 80 400 {lab=N_A12}
N 0 390 90 390 {lab=#net423}
N 0 320 0 400 { }
N 2170 400 2170 480 {lab=N_A5}
N 2160 470 2250 470 {lab=word5}
N 2120 440 2130 440 {lab=GND}
N 2130 410 2130 440 {lab=GND}
N 2120 410 2130 410 {lab=GND}
N 2080 400 2080 440 {lab=A5}
N 2080 440 2080 480 {lab=A5}
N 2070 470 2120 470 {lab=word5}
N 2120 470 2160 470 {lab=word5}
N 1990 400 1990 480 {lab=N_A4}
N 1980 470 2070 470 {lab=word5}
N 1940 440 1950 440 {lab=GND}
N 1950 410 1950 440 {lab=GND}
N 1940 410 1950 410 {lab=GND}
N 1900 400 1900 440 {lab=A4}
N 1900 440 1900 480 {lab=A4}
N 1890 470 1940 470 {lab=word5}
N 1940 470 1980 470 {lab=word5}
N 1810 400 1810 480 {lab=N_A3}
N 1800 470 1890 470 {lab=word5}
N 1760 440 1770 440 {lab=GND}
N 1770 410 1770 440 {lab=GND}
N 1760 410 1770 410 {lab=GND}
N 1720 400 1720 440 {lab=A3}
N 1720 440 1720 480 {lab=A3}
N 1710 470 1760 470 {lab=word5}
N 1760 470 1800 470 {lab=word5}
N 1670 440 1680 440 {lab=GND}
N 1680 410 1680 440 {lab=GND}
N 1670 410 1680 410 {lab=GND}
N 1630 400 1630 440 {lab=N_A2}
N 1630 440 1630 480 {lab=N_A2}
N 1620 470 1670 470 {lab=word5}
N 1670 470 1710 470 {lab=word5}
N 1540 400 1540 480 {lab=A2}
N 1530 470 1620 470 {lab=word5}
N 1450 400 1450 480 {lab=N_A1}
N 1440 470 1530 470 {lab=word5}
N 1400 440 1410 440 {lab=GND}
N 1410 410 1410 440 {lab=GND}
N 1400 410 1410 410 {lab=GND}
N 1360 400 1360 440 {lab=A1}
N 1360 440 1360 480 {lab=A1}
N 1350 470 1400 470 {lab=word5}
N 1400 470 1440 470 {lab=word5}
N 1310 440 1320 440 {lab=GND}
N 1320 410 1320 440 {lab=GND}
N 1310 410 1320 410 {lab=GND}
N 1270 400 1270 440 {lab=N_A0}
N 1270 440 1270 480 {lab=N_A0}
N 1260 470 1310 470 {lab=word5}
N 1310 470 1350 470 {lab=word5}
N 1180 400 1180 480 {lab=A0}
N 1170 470 1260 470 {lab=word5}
N 1080 470 1170 470 { }
N 1070 400 1070 480 {lab=A6}
N 990 470 1080 470 {lab=word5}
N 940 430 980 430 {lab=N_A7}
N 940 470 940 480 {lab=VDD}
N 970 470 990 470 {lab=word5}
N 900 470 910 470 {lab=#net513}
N 980 400 980 430 {lab=N_A7}
N 980 430 980 480 {lab=N_A7}
N 850 430 890 430 {lab=A7}
N 850 470 850 480 {lab=VDD}
N 880 470 900 470 {lab=#net513}
N 810 470 820 470 {lab=#net515}
N 890 400 890 430 {lab=A7}
N 890 430 890 480 {lab=A7}
N 800 400 800 480 {lab=N_A8}
N 720 470 810 470 {lab=#net515}
N 710 400 710 480 {lab=A8}
N 630 470 720 470 {lab=#net515}
N 580 430 620 430 {lab=N_A9}
N 580 470 580 480 {lab=VDD}
N 610 470 630 470 {lab=#net515}
N 540 470 550 470 {lab=#net517}
N 620 400 620 430 {lab=N_A9}
N 620 430 620 480 {lab=N_A9}
N 490 430 530 430 {lab=A9}
N 490 470 490 480 {lab=VDD}
N 520 470 540 470 {lab=#net517}
N 450 470 460 470 {lab=#net519}
N 530 400 530 430 {lab=A9}
N 530 430 530 480 {lab=A9}
N 440 400 440 480 {lab=N_A10}
N 360 470 450 470 {lab=#net519}
N 310 430 350 430 {lab=A10}
N 310 470 310 480 {lab=VDD}
N 340 470 360 470 {lab=#net519}
N 270 470 280 470 {lab=#net521}
N 350 400 350 430 {lab=A10}
N 350 430 350 480 {lab=A10}
N 260 400 260 480 {lab=N_A11}
N 180 470 270 470 {lab=#net521}
N 130 430 170 430 {lab=A11}
N 130 470 130 480 {lab=VDD}
N 160 470 180 470 {lab=#net521}
N 90 470 100 470 {lab=#net523}
N 170 400 170 430 {lab=A11}
N 170 430 170 480 {lab=A11}
N 80 400 80 480 {lab=N_A12}
N 0 470 90 470 {lab=#net523}
N 0 400 0 480 { }
N 2170 480 2170 560 {lab=N_A5}
N 2160 550 2250 550 {lab=word6}
N 2120 520 2130 520 {lab=GND}
N 2130 490 2130 520 {lab=GND}
N 2120 490 2130 490 {lab=GND}
N 2080 480 2080 520 {lab=A5}
N 2080 520 2080 560 {lab=A5}
N 2070 550 2120 550 {lab=word6}
N 2120 550 2160 550 {lab=word6}
N 1990 480 1990 560 {lab=N_A4}
N 1980 550 2070 550 {lab=word6}
N 1940 520 1950 520 {lab=GND}
N 1950 490 1950 520 {lab=GND}
N 1940 490 1950 490 {lab=GND}
N 1900 480 1900 520 {lab=A4}
N 1900 520 1900 560 {lab=A4}
N 1890 550 1940 550 {lab=word6}
N 1940 550 1980 550 {lab=word6}
N 1810 480 1810 560 {lab=N_A3}
N 1800 550 1890 550 {lab=word6}
N 1760 520 1770 520 {lab=GND}
N 1770 490 1770 520 {lab=GND}
N 1760 490 1770 490 {lab=GND}
N 1720 480 1720 520 {lab=A3}
N 1720 520 1720 560 {lab=A3}
N 1710 550 1760 550 {lab=word6}
N 1760 550 1800 550 {lab=word6}
N 1670 520 1680 520 {lab=GND}
N 1680 490 1680 520 {lab=GND}
N 1670 490 1680 490 {lab=GND}
N 1630 480 1630 520 {lab=N_A2}
N 1630 520 1630 560 {lab=N_A2}
N 1620 550 1670 550 {lab=word6}
N 1670 550 1710 550 {lab=word6}
N 1540 480 1540 560 {lab=A2}
N 1530 550 1620 550 {lab=word6}
N 1490 520 1500 520 {lab=GND}
N 1500 490 1500 520 {lab=GND}
N 1490 490 1500 490 {lab=GND}
N 1450 480 1450 520 {lab=N_A1}
N 1450 520 1450 560 {lab=N_A1}
N 1440 550 1490 550 {lab=word6}
N 1490 550 1530 550 {lab=word6}
N 1360 480 1360 560 {lab=A1}
N 1350 550 1440 550 {lab=word6}
N 1270 480 1270 560 {lab=N_A0}
N 1260 550 1350 550 {lab=word6}
N 1220 520 1230 520 {lab=GND}
N 1230 490 1230 520 {lab=GND}
N 1220 490 1230 490 {lab=GND}
N 1180 480 1180 520 {lab=A0}
N 1180 520 1180 560 {lab=A0}
N 1170 550 1220 550 {lab=word6}
N 1220 550 1260 550 {lab=word6}
N 1080 550 1170 550 { }
N 1030 510 1070 510 {lab=A6}
N 1030 550 1030 560 {lab=VDD}
N 1060 550 1080 550 {lab=word6}
N 990 550 1000 550 {lab=#net613}
N 1070 480 1070 510 {lab=A6}
N 1070 510 1070 560 {lab=A6}
N 980 480 980 560 {lab=N_A7}
N 900 550 990 550 {lab=#net613}
N 890 480 890 560 {lab=A7}
N 810 550 900 550 {lab=#net613}
N 760 510 800 510 {lab=N_A8}
N 760 550 760 560 {lab=VDD}
N 790 550 810 550 {lab=#net613}
N 720 550 730 550 {lab=#net615}
N 800 480 800 510 {lab=N_A8}
N 800 510 800 560 {lab=N_A8}
N 710 480 710 560 {lab=A8}
N 630 550 720 550 {lab=#net615}
N 580 510 620 510 {lab=N_A9}
N 580 550 580 560 {lab=VDD}
N 610 550 630 550 {lab=#net615}
N 540 550 550 550 {lab=#net617}
N 620 480 620 510 {lab=N_A9}
N 620 510 620 560 {lab=N_A9}
N 490 510 530 510 {lab=A9}
N 490 550 490 560 {lab=VDD}
N 520 550 540 550 {lab=#net617}
N 450 550 460 550 {lab=#net619}
N 530 480 530 510 {lab=A9}
N 530 510 530 560 {lab=A9}
N 440 480 440 560 {lab=N_A10}
N 360 550 450 550 {lab=#net619}
N 310 510 350 510 {lab=A10}
N 310 550 310 560 {lab=VDD}
N 340 550 360 550 {lab=#net619}
N 270 550 280 550 {lab=#net621}
N 350 480 350 510 {lab=A10}
N 350 510 350 560 {lab=A10}
N 260 480 260 560 {lab=N_A11}
N 180 550 270 550 {lab=#net621}
N 130 510 170 510 {lab=A11}
N 130 550 130 560 {lab=VDD}
N 160 550 180 550 {lab=#net621}
N 90 550 100 550 {lab=#net623}
N 170 480 170 510 {lab=A11}
N 170 510 170 560 {lab=A11}
N 80 480 80 560 {lab=N_A12}
N 0 550 90 550 {lab=#net623}
N 0 480 0 560 { }
N 2170 560 2170 640 {lab=N_A5}
N 2160 630 2250 630 {lab=word7}
N 2120 600 2130 600 {lab=GND}
N 2130 570 2130 600 {lab=GND}
N 2120 570 2130 570 {lab=GND}
N 2080 560 2080 600 {lab=A5}
N 2080 600 2080 640 {lab=A5}
N 2070 630 2120 630 {lab=word7}
N 2120 630 2160 630 {lab=word7}
N 1990 560 1990 640 {lab=N_A4}
N 1980 630 2070 630 {lab=word7}
N 1940 600 1950 600 {lab=GND}
N 1950 570 1950 600 {lab=GND}
N 1940 570 1950 570 {lab=GND}
N 1900 560 1900 600 {lab=A4}
N 1900 600 1900 640 {lab=A4}
N 1890 630 1940 630 {lab=word7}
N 1940 630 1980 630 {lab=word7}
N 1810 560 1810 640 {lab=N_A3}
N 1800 630 1890 630 {lab=word7}
N 1760 600 1770 600 {lab=GND}
N 1770 570 1770 600 {lab=GND}
N 1760 570 1770 570 {lab=GND}
N 1720 560 1720 600 {lab=A3}
N 1720 600 1720 640 {lab=A3}
N 1710 630 1760 630 {lab=word7}
N 1760 630 1800 630 {lab=word7}
N 1670 600 1680 600 {lab=GND}
N 1680 570 1680 600 {lab=GND}
N 1670 570 1680 570 {lab=GND}
N 1630 560 1630 600 {lab=N_A2}
N 1630 600 1630 640 {lab=N_A2}
N 1620 630 1670 630 {lab=word7}
N 1670 630 1710 630 {lab=word7}
N 1540 560 1540 640 {lab=A2}
N 1530 630 1620 630 {lab=word7}
N 1490 600 1500 600 {lab=GND}
N 1500 570 1500 600 {lab=GND}
N 1490 570 1500 570 {lab=GND}
N 1450 560 1450 600 {lab=N_A1}
N 1450 600 1450 640 {lab=N_A1}
N 1440 630 1490 630 {lab=word7}
N 1490 630 1530 630 {lab=word7}
N 1360 560 1360 640 {lab=A1}
N 1350 630 1440 630 {lab=word7}
N 1310 600 1320 600 {lab=GND}
N 1320 570 1320 600 {lab=GND}
N 1310 570 1320 570 {lab=GND}
N 1270 560 1270 600 {lab=N_A0}
N 1270 600 1270 640 {lab=N_A0}
N 1260 630 1310 630 {lab=word7}
N 1310 630 1350 630 {lab=word7}
N 1180 560 1180 640 {lab=A0}
N 1170 630 1260 630 {lab=word7}
N 1080 630 1170 630 { }
N 1070 560 1070 640 {lab=A6}
N 990 630 1080 630 {lab=word7}
N 940 590 980 590 {lab=N_A7}
N 940 630 940 640 {lab=VDD}
N 970 630 990 630 {lab=word7}
N 900 630 910 630 {lab=#net713}
N 980 560 980 590 {lab=N_A7}
N 980 590 980 640 {lab=N_A7}
N 890 560 890 640 {lab=A7}
N 810 630 900 630 {lab=#net713}
N 760 590 800 590 {lab=N_A8}
N 760 630 760 640 {lab=VDD}
N 790 630 810 630 {lab=#net713}
N 720 630 730 630 {lab=#net715}
N 800 560 800 590 {lab=N_A8}
N 800 590 800 640 {lab=N_A8}
N 710 560 710 640 {lab=A8}
N 630 630 720 630 {lab=#net715}
N 580 590 620 590 {lab=N_A9}
N 580 630 580 640 {lab=VDD}
N 610 630 630 630 {lab=#net715}
N 540 630 550 630 {lab=#net717}
N 620 560 620 590 {lab=N_A9}
N 620 590 620 640 {lab=N_A9}
N 490 590 530 590 {lab=A9}
N 490 630 490 640 {lab=VDD}
N 520 630 540 630 {lab=#net717}
N 450 630 460 630 {lab=#net719}
N 530 560 530 590 {lab=A9}
N 530 590 530 640 {lab=A9}
N 440 560 440 640 {lab=N_A10}
N 360 630 450 630 {lab=#net719}
N 310 590 350 590 {lab=A10}
N 310 630 310 640 {lab=VDD}
N 340 630 360 630 {lab=#net719}
N 270 630 280 630 {lab=#net721}
N 350 560 350 590 {lab=A10}
N 350 590 350 640 {lab=A10}
N 260 560 260 640 {lab=N_A11}
N 180 630 270 630 {lab=#net721}
N 130 590 170 590 {lab=A11}
N 130 630 130 640 {lab=VDD}
N 160 630 180 630 {lab=#net721}
N 90 630 100 630 {lab=#net723}
N 170 560 170 590 {lab=A11}
N 170 590 170 640 {lab=A11}
N 80 560 80 640 {lab=N_A12}
N 0 630 90 630 {lab=#net723}
N 0 560 0 640 { }
N 2170 640 2170 720 {lab=N_A5}
N 2160 710 2250 710 {lab=word8}
N 2120 680 2130 680 {lab=GND}
N 2130 650 2130 680 {lab=GND}
N 2120 650 2130 650 {lab=GND}
N 2080 640 2080 680 {lab=A5}
N 2080 680 2080 720 {lab=A5}
N 2070 710 2120 710 {lab=word8}
N 2120 710 2160 710 {lab=word8}
N 1990 640 1990 720 {lab=N_A4}
N 1980 710 2070 710 {lab=word8}
N 1940 680 1950 680 {lab=GND}
N 1950 650 1950 680 {lab=GND}
N 1940 650 1950 650 {lab=GND}
N 1900 640 1900 680 {lab=A4}
N 1900 680 1900 720 {lab=A4}
N 1890 710 1940 710 {lab=word8}
N 1940 710 1980 710 {lab=word8}
N 1850 680 1860 680 {lab=GND}
N 1860 650 1860 680 {lab=GND}
N 1850 650 1860 650 {lab=GND}
N 1810 640 1810 680 {lab=N_A3}
N 1810 680 1810 720 {lab=N_A3}
N 1800 710 1850 710 {lab=word8}
N 1850 710 1890 710 {lab=word8}
N 1720 640 1720 720 {lab=A3}
N 1710 710 1800 710 {lab=word8}
N 1630 640 1630 720 {lab=N_A2}
N 1620 710 1710 710 {lab=word8}
N 1580 680 1590 680 {lab=GND}
N 1590 650 1590 680 {lab=GND}
N 1580 650 1590 650 {lab=GND}
N 1540 640 1540 680 {lab=A2}
N 1540 680 1540 720 {lab=A2}
N 1530 710 1580 710 {lab=word8}
N 1580 710 1620 710 {lab=word8}
N 1450 640 1450 720 {lab=N_A1}
N 1440 710 1530 710 {lab=word8}
N 1400 680 1410 680 {lab=GND}
N 1410 650 1410 680 {lab=GND}
N 1400 650 1410 650 {lab=GND}
N 1360 640 1360 680 {lab=A1}
N 1360 680 1360 720 {lab=A1}
N 1350 710 1400 710 {lab=word8}
N 1400 710 1440 710 {lab=word8}
N 1270 640 1270 720 {lab=N_A0}
N 1260 710 1350 710 {lab=word8}
N 1220 680 1230 680 {lab=GND}
N 1230 650 1230 680 {lab=GND}
N 1220 650 1230 650 {lab=GND}
N 1180 640 1180 680 {lab=A0}
N 1180 680 1180 720 {lab=A0}
N 1170 710 1220 710 {lab=word8}
N 1220 710 1260 710 {lab=word8}
N 1080 710 1170 710 { }
N 1030 670 1070 670 {lab=A6}
N 1030 710 1030 720 {lab=VDD}
N 1060 710 1080 710 {lab=word8}
N 990 710 1000 710 {lab=#net813}
N 1070 640 1070 670 {lab=A6}
N 1070 670 1070 720 {lab=A6}
N 980 640 980 720 {lab=N_A7}
N 900 710 990 710 {lab=#net813}
N 850 670 890 670 {lab=A7}
N 850 710 850 720 {lab=VDD}
N 880 710 900 710 {lab=#net813}
N 810 710 820 710 {lab=#net815}
N 890 640 890 670 {lab=A7}
N 890 670 890 720 {lab=A7}
N 800 640 800 720 {lab=N_A8}
N 720 710 810 710 {lab=#net815}
N 670 670 710 670 {lab=A8}
N 670 710 670 720 {lab=VDD}
N 700 710 720 710 {lab=#net815}
N 630 710 640 710 {lab=#net817}
N 710 640 710 670 {lab=A8}
N 710 670 710 720 {lab=A8}
N 620 640 620 720 {lab=N_A9}
N 540 710 630 710 {lab=#net817}
N 530 640 530 720 {lab=A9}
N 450 710 540 710 {lab=#net817}
N 400 670 440 670 {lab=N_A10}
N 400 710 400 720 {lab=VDD}
N 430 710 450 710 {lab=#net817}
N 360 710 370 710 {lab=#net819}
N 440 640 440 670 {lab=N_A10}
N 440 670 440 720 {lab=N_A10}
N 310 670 350 670 {lab=A10}
N 310 710 310 720 {lab=VDD}
N 340 710 360 710 {lab=#net819}
N 270 710 280 710 {lab=#net821}
N 350 640 350 670 {lab=A10}
N 350 670 350 720 {lab=A10}
N 260 640 260 720 {lab=N_A11}
N 180 710 270 710 {lab=#net821}
N 130 670 170 670 {lab=A11}
N 130 710 130 720 {lab=VDD}
N 160 710 180 710 {lab=#net821}
N 90 710 100 710 {lab=#net823}
N 170 640 170 670 {lab=A11}
N 170 670 170 720 {lab=A11}
N 80 640 80 720 {lab=N_A12}
N 0 710 90 710 {lab=#net823}
N 0 640 0 720 { }
N 2170 720 2170 800 {lab=N_A5}
N 2160 790 2250 790 {lab=word9}
N 2120 760 2130 760 {lab=GND}
N 2130 730 2130 760 {lab=GND}
N 2120 730 2130 730 {lab=GND}
N 2080 720 2080 760 {lab=A5}
N 2080 760 2080 800 {lab=A5}
N 2070 790 2120 790 {lab=word9}
N 2120 790 2160 790 {lab=word9}
N 1990 720 1990 800 {lab=N_A4}
N 1980 790 2070 790 {lab=word9}
N 1940 760 1950 760 {lab=GND}
N 1950 730 1950 760 {lab=GND}
N 1940 730 1950 730 {lab=GND}
N 1900 720 1900 760 {lab=A4}
N 1900 760 1900 800 {lab=A4}
N 1890 790 1940 790 {lab=word9}
N 1940 790 1980 790 {lab=word9}
N 1850 760 1860 760 {lab=GND}
N 1860 730 1860 760 {lab=GND}
N 1850 730 1860 730 {lab=GND}
N 1810 720 1810 760 {lab=N_A3}
N 1810 760 1810 800 {lab=N_A3}
N 1800 790 1850 790 {lab=word9}
N 1850 790 1890 790 {lab=word9}
N 1720 720 1720 800 {lab=A3}
N 1710 790 1800 790 {lab=word9}
N 1630 720 1630 800 {lab=N_A2}
N 1620 790 1710 790 {lab=word9}
N 1580 760 1590 760 {lab=GND}
N 1590 730 1590 760 {lab=GND}
N 1580 730 1590 730 {lab=GND}
N 1540 720 1540 760 {lab=A2}
N 1540 760 1540 800 {lab=A2}
N 1530 790 1580 790 {lab=word9}
N 1580 790 1620 790 {lab=word9}
N 1450 720 1450 800 {lab=N_A1}
N 1440 790 1530 790 {lab=word9}
N 1400 760 1410 760 {lab=GND}
N 1410 730 1410 760 {lab=GND}
N 1400 730 1410 730 {lab=GND}
N 1360 720 1360 760 {lab=A1}
N 1360 760 1360 800 {lab=A1}
N 1350 790 1400 790 {lab=word9}
N 1400 790 1440 790 {lab=word9}
N 1310 760 1320 760 {lab=GND}
N 1320 730 1320 760 {lab=GND}
N 1310 730 1320 730 {lab=GND}
N 1270 720 1270 760 {lab=N_A0}
N 1270 760 1270 800 {lab=N_A0}
N 1260 790 1310 790 {lab=word9}
N 1310 790 1350 790 {lab=word9}
N 1180 720 1180 800 {lab=A0}
N 1170 790 1260 790 {lab=word9}
N 1080 790 1170 790 { }
N 1070 720 1070 800 {lab=A6}
N 990 790 1080 790 {lab=word9}
N 940 750 980 750 {lab=N_A7}
N 940 790 940 800 {lab=VDD}
N 970 790 990 790 {lab=word9}
N 900 790 910 790 {lab=#net913}
N 980 720 980 750 {lab=N_A7}
N 980 750 980 800 {lab=N_A7}
N 850 750 890 750 {lab=A7}
N 850 790 850 800 {lab=VDD}
N 880 790 900 790 {lab=#net913}
N 810 790 820 790 {lab=#net915}
N 890 720 890 750 {lab=A7}
N 890 750 890 800 {lab=A7}
N 800 720 800 800 {lab=N_A8}
N 720 790 810 790 {lab=#net915}
N 670 750 710 750 {lab=A8}
N 670 790 670 800 {lab=VDD}
N 700 790 720 790 {lab=#net915}
N 630 790 640 790 {lab=#net917}
N 710 720 710 750 {lab=A8}
N 710 750 710 800 {lab=A8}
N 620 720 620 800 {lab=N_A9}
N 540 790 630 790 {lab=#net917}
N 530 720 530 800 {lab=A9}
N 450 790 540 790 {lab=#net917}
N 400 750 440 750 {lab=N_A10}
N 400 790 400 800 {lab=VDD}
N 430 790 450 790 {lab=#net917}
N 360 790 370 790 {lab=#net919}
N 440 720 440 750 {lab=N_A10}
N 440 750 440 800 {lab=N_A10}
N 310 750 350 750 {lab=A10}
N 310 790 310 800 {lab=VDD}
N 340 790 360 790 {lab=#net919}
N 270 790 280 790 {lab=#net921}
N 350 720 350 750 {lab=A10}
N 350 750 350 800 {lab=A10}
N 260 720 260 800 {lab=N_A11}
N 180 790 270 790 {lab=#net921}
N 130 750 170 750 {lab=A11}
N 130 790 130 800 {lab=VDD}
N 160 790 180 790 {lab=#net921}
N 90 790 100 790 {lab=#net923}
N 170 720 170 750 {lab=A11}
N 170 750 170 800 {lab=A11}
N 80 720 80 800 {lab=N_A12}
N 0 790 90 790 {lab=#net923}
N 0 720 0 800 { }
N 2170 800 2170 880 {lab=N_A5}
N 2160 870 2250 870 {lab=word10}
N 2120 840 2130 840 {lab=GND}
N 2130 810 2130 840 {lab=GND}
N 2120 810 2130 810 {lab=GND}
N 2080 800 2080 840 {lab=A5}
N 2080 840 2080 880 {lab=A5}
N 2070 870 2120 870 {lab=word10}
N 2120 870 2160 870 {lab=word10}
N 1990 800 1990 880 {lab=N_A4}
N 1980 870 2070 870 {lab=word10}
N 1940 840 1950 840 {lab=GND}
N 1950 810 1950 840 {lab=GND}
N 1940 810 1950 810 {lab=GND}
N 1900 800 1900 840 {lab=A4}
N 1900 840 1900 880 {lab=A4}
N 1890 870 1940 870 {lab=word10}
N 1940 870 1980 870 {lab=word10}
N 1850 840 1860 840 {lab=GND}
N 1860 810 1860 840 {lab=GND}
N 1850 810 1860 810 {lab=GND}
N 1810 800 1810 840 {lab=N_A3}
N 1810 840 1810 880 {lab=N_A3}
N 1800 870 1850 870 {lab=word10}
N 1850 870 1890 870 {lab=word10}
N 1720 800 1720 880 {lab=A3}
N 1710 870 1800 870 {lab=word10}
N 1630 800 1630 880 {lab=N_A2}
N 1620 870 1710 870 {lab=word10}
N 1580 840 1590 840 {lab=GND}
N 1590 810 1590 840 {lab=GND}
N 1580 810 1590 810 {lab=GND}
N 1540 800 1540 840 {lab=A2}
N 1540 840 1540 880 {lab=A2}
N 1530 870 1580 870 {lab=word10}
N 1580 870 1620 870 {lab=word10}
N 1490 840 1500 840 {lab=GND}
N 1500 810 1500 840 {lab=GND}
N 1490 810 1500 810 {lab=GND}
N 1450 800 1450 840 {lab=N_A1}
N 1450 840 1450 880 {lab=N_A1}
N 1440 870 1490 870 {lab=word10}
N 1490 870 1530 870 {lab=word10}
N 1360 800 1360 880 {lab=A1}
N 1350 870 1440 870 {lab=word10}
N 1270 800 1270 880 {lab=N_A0}
N 1260 870 1350 870 {lab=word10}
N 1220 840 1230 840 {lab=GND}
N 1230 810 1230 840 {lab=GND}
N 1220 810 1230 810 {lab=GND}
N 1180 800 1180 840 {lab=A0}
N 1180 840 1180 880 {lab=A0}
N 1170 870 1220 870 {lab=word10}
N 1220 870 1260 870 {lab=word10}
N 1080 870 1170 870 { }
N 1030 830 1070 830 {lab=A6}
N 1030 870 1030 880 {lab=VDD}
N 1060 870 1080 870 {lab=word10}
N 990 870 1000 870 {lab=#net1013}
N 1070 800 1070 830 {lab=A6}
N 1070 830 1070 880 {lab=A6}
N 980 800 980 880 {lab=N_A7}
N 900 870 990 870 {lab=#net1013}
N 890 800 890 880 {lab=A7}
N 810 870 900 870 {lab=#net1013}
N 760 830 800 830 {lab=N_A8}
N 760 870 760 880 {lab=VDD}
N 790 870 810 870 {lab=#net1013}
N 720 870 730 870 {lab=#net1015}
N 800 800 800 830 {lab=N_A8}
N 800 830 800 880 {lab=N_A8}
N 670 830 710 830 {lab=A8}
N 670 870 670 880 {lab=VDD}
N 700 870 720 870 {lab=#net1015}
N 630 870 640 870 {lab=#net1017}
N 710 800 710 830 {lab=A8}
N 710 830 710 880 {lab=A8}
N 620 800 620 880 {lab=N_A9}
N 540 870 630 870 {lab=#net1017}
N 530 800 530 880 {lab=A9}
N 450 870 540 870 {lab=#net1017}
N 400 830 440 830 {lab=N_A10}
N 400 870 400 880 {lab=VDD}
N 430 870 450 870 {lab=#net1017}
N 360 870 370 870 {lab=#net1019}
N 440 800 440 830 {lab=N_A10}
N 440 830 440 880 {lab=N_A10}
N 310 830 350 830 {lab=A10}
N 310 870 310 880 {lab=VDD}
N 340 870 360 870 {lab=#net1019}
N 270 870 280 870 {lab=#net1021}
N 350 800 350 830 {lab=A10}
N 350 830 350 880 {lab=A10}
N 260 800 260 880 {lab=N_A11}
N 180 870 270 870 {lab=#net1021}
N 130 830 170 830 {lab=A11}
N 130 870 130 880 {lab=VDD}
N 160 870 180 870 {lab=#net1021}
N 90 870 100 870 {lab=#net1023}
N 170 800 170 830 {lab=A11}
N 170 830 170 880 {lab=A11}
N 80 800 80 880 {lab=N_A12}
N 0 870 90 870 {lab=#net1023}
N 0 800 0 880 { }
N 2170 880 2170 960 {lab=N_A5}
N 2160 950 2250 950 {lab=word11}
N 2120 920 2130 920 {lab=GND}
N 2130 890 2130 920 {lab=GND}
N 2120 890 2130 890 {lab=GND}
N 2080 880 2080 920 {lab=A5}
N 2080 920 2080 960 {lab=A5}
N 2070 950 2120 950 {lab=word11}
N 2120 950 2160 950 {lab=word11}
N 1990 880 1990 960 {lab=N_A4}
N 1980 950 2070 950 {lab=word11}
N 1940 920 1950 920 {lab=GND}
N 1950 890 1950 920 {lab=GND}
N 1940 890 1950 890 {lab=GND}
N 1900 880 1900 920 {lab=A4}
N 1900 920 1900 960 {lab=A4}
N 1890 950 1940 950 {lab=word11}
N 1940 950 1980 950 {lab=word11}
N 1850 920 1860 920 {lab=GND}
N 1860 890 1860 920 {lab=GND}
N 1850 890 1860 890 {lab=GND}
N 1810 880 1810 920 {lab=N_A3}
N 1810 920 1810 960 {lab=N_A3}
N 1800 950 1850 950 {lab=word11}
N 1850 950 1890 950 {lab=word11}
N 1720 880 1720 960 {lab=A3}
N 1710 950 1800 950 {lab=word11}
N 1630 880 1630 960 {lab=N_A2}
N 1620 950 1710 950 {lab=word11}
N 1580 920 1590 920 {lab=GND}
N 1590 890 1590 920 {lab=GND}
N 1580 890 1590 890 {lab=GND}
N 1540 880 1540 920 {lab=A2}
N 1540 920 1540 960 {lab=A2}
N 1530 950 1580 950 {lab=word11}
N 1580 950 1620 950 {lab=word11}
N 1490 920 1500 920 {lab=GND}
N 1500 890 1500 920 {lab=GND}
N 1490 890 1500 890 {lab=GND}
N 1450 880 1450 920 {lab=N_A1}
N 1450 920 1450 960 {lab=N_A1}
N 1440 950 1490 950 {lab=word11}
N 1490 950 1530 950 {lab=word11}
N 1360 880 1360 960 {lab=A1}
N 1350 950 1440 950 {lab=word11}
N 1310 920 1320 920 {lab=GND}
N 1320 890 1320 920 {lab=GND}
N 1310 890 1320 890 {lab=GND}
N 1270 880 1270 920 {lab=N_A0}
N 1270 920 1270 960 {lab=N_A0}
N 1260 950 1310 950 {lab=word11}
N 1310 950 1350 950 {lab=word11}
N 1180 880 1180 960 {lab=A0}
N 1170 950 1260 950 {lab=word11}
N 1080 950 1170 950 { }
N 1070 880 1070 960 {lab=A6}
N 990 950 1080 950 {lab=word11}
N 940 910 980 910 {lab=N_A7}
N 940 950 940 960 {lab=VDD}
N 970 950 990 950 {lab=word11}
N 900 950 910 950 {lab=#net1113}
N 980 880 980 910 {lab=N_A7}
N 980 910 980 960 {lab=N_A7}
N 890 880 890 960 {lab=A7}
N 810 950 900 950 {lab=#net1113}
N 760 910 800 910 {lab=N_A8}
N 760 950 760 960 {lab=VDD}
N 790 950 810 950 {lab=#net1113}
N 720 950 730 950 {lab=#net1115}
N 800 880 800 910 {lab=N_A8}
N 800 910 800 960 {lab=N_A8}
N 670 910 710 910 {lab=A8}
N 670 950 670 960 {lab=VDD}
N 700 950 720 950 {lab=#net1115}
N 630 950 640 950 {lab=#net1117}
N 710 880 710 910 {lab=A8}
N 710 910 710 960 {lab=A8}
N 620 880 620 960 {lab=N_A9}
N 540 950 630 950 {lab=#net1117}
N 530 880 530 960 {lab=A9}
N 450 950 540 950 {lab=#net1117}
N 400 910 440 910 {lab=N_A10}
N 400 950 400 960 {lab=VDD}
N 430 950 450 950 {lab=#net1117}
N 360 950 370 950 {lab=#net1119}
N 440 880 440 910 {lab=N_A10}
N 440 910 440 960 {lab=N_A10}
N 310 910 350 910 {lab=A10}
N 310 950 310 960 {lab=VDD}
N 340 950 360 950 {lab=#net1119}
N 270 950 280 950 {lab=#net1121}
N 350 880 350 910 {lab=A10}
N 350 910 350 960 {lab=A10}
N 260 880 260 960 {lab=N_A11}
N 180 950 270 950 {lab=#net1121}
N 130 910 170 910 {lab=A11}
N 130 950 130 960 {lab=VDD}
N 160 950 180 950 {lab=#net1121}
N 90 950 100 950 {lab=#net1123}
N 170 880 170 910 {lab=A11}
N 170 910 170 960 {lab=A11}
N 80 880 80 960 {lab=N_A12}
N 0 950 90 950 {lab=#net1123}
N 0 880 0 960 { }
N 2170 960 2170 1040 {lab=N_A5}
N 2160 1030 2250 1030 {lab=word12}
N 2120 1000 2130 1000 {lab=GND}
N 2130 970 2130 1000 {lab=GND}
N 2120 970 2130 970 {lab=GND}
N 2080 960 2080 1000 {lab=A5}
N 2080 1000 2080 1040 {lab=A5}
N 2070 1030 2120 1030 {lab=word12}
N 2120 1030 2160 1030 {lab=word12}
N 1990 960 1990 1040 {lab=N_A4}
N 1980 1030 2070 1030 {lab=word12}
N 1940 1000 1950 1000 {lab=GND}
N 1950 970 1950 1000 {lab=GND}
N 1940 970 1950 970 {lab=GND}
N 1900 960 1900 1000 {lab=A4}
N 1900 1000 1900 1040 {lab=A4}
N 1890 1030 1940 1030 {lab=word12}
N 1940 1030 1980 1030 {lab=word12}
N 1850 1000 1860 1000 {lab=GND}
N 1860 970 1860 1000 {lab=GND}
N 1850 970 1860 970 {lab=GND}
N 1810 960 1810 1000 {lab=N_A3}
N 1810 1000 1810 1040 {lab=N_A3}
N 1800 1030 1850 1030 {lab=word12}
N 1850 1030 1890 1030 {lab=word12}
N 1720 960 1720 1040 {lab=A3}
N 1710 1030 1800 1030 {lab=word12}
N 1670 1000 1680 1000 {lab=GND}
N 1680 970 1680 1000 {lab=GND}
N 1670 970 1680 970 {lab=GND}
N 1630 960 1630 1000 {lab=N_A2}
N 1630 1000 1630 1040 {lab=N_A2}
N 1620 1030 1670 1030 {lab=word12}
N 1670 1030 1710 1030 {lab=word12}
N 1540 960 1540 1040 {lab=A2}
N 1530 1030 1620 1030 {lab=word12}
N 1450 960 1450 1040 {lab=N_A1}
N 1440 1030 1530 1030 {lab=word12}
N 1400 1000 1410 1000 {lab=GND}
N 1410 970 1410 1000 {lab=GND}
N 1400 970 1410 970 {lab=GND}
N 1360 960 1360 1000 {lab=A1}
N 1360 1000 1360 1040 {lab=A1}
N 1350 1030 1400 1030 {lab=word12}
N 1400 1030 1440 1030 {lab=word12}
N 1270 960 1270 1040 {lab=N_A0}
N 1260 1030 1350 1030 {lab=word12}
N 1220 1000 1230 1000 {lab=GND}
N 1230 970 1230 1000 {lab=GND}
N 1220 970 1230 970 {lab=GND}
N 1180 960 1180 1000 {lab=A0}
N 1180 1000 1180 1040 {lab=A0}
N 1170 1030 1220 1030 {lab=word12}
N 1220 1030 1260 1030 {lab=word12}
N 1080 1030 1170 1030 { }
N 1030 990 1070 990 {lab=A6}
N 1030 1030 1030 1040 {lab=VDD}
N 1060 1030 1080 1030 {lab=word12}
N 990 1030 1000 1030 {lab=#net1213}
N 1070 960 1070 990 {lab=A6}
N 1070 990 1070 1040 {lab=A6}
N 980 960 980 1040 {lab=N_A7}
N 900 1030 990 1030 {lab=#net1213}
N 850 990 890 990 {lab=A7}
N 850 1030 850 1040 {lab=VDD}
N 880 1030 900 1030 {lab=#net1213}
N 810 1030 820 1030 {lab=#net1215}
N 890 960 890 990 {lab=A7}
N 890 990 890 1040 {lab=A7}
N 800 960 800 1040 {lab=N_A8}
N 720 1030 810 1030 {lab=#net1215}
N 710 960 710 1040 {lab=A8}
N 630 1030 720 1030 {lab=#net1215}
N 580 990 620 990 {lab=N_A9}
N 580 1030 580 1040 {lab=VDD}
N 610 1030 630 1030 {lab=#net1215}
N 540 1030 550 1030 {lab=#net1217}
N 620 960 620 990 {lab=N_A9}
N 620 990 620 1040 {lab=N_A9}
N 530 960 530 1040 {lab=A9}
N 450 1030 540 1030 {lab=#net1217}
N 400 990 440 990 {lab=N_A10}
N 400 1030 400 1040 {lab=VDD}
N 430 1030 450 1030 {lab=#net1217}
N 360 1030 370 1030 {lab=#net1219}
N 440 960 440 990 {lab=N_A10}
N 440 990 440 1040 {lab=N_A10}
N 310 990 350 990 {lab=A10}
N 310 1030 310 1040 {lab=VDD}
N 340 1030 360 1030 {lab=#net1219}
N 270 1030 280 1030 {lab=#net1221}
N 350 960 350 990 {lab=A10}
N 350 990 350 1040 {lab=A10}
N 260 960 260 1040 {lab=N_A11}
N 180 1030 270 1030 {lab=#net1221}
N 130 990 170 990 {lab=A11}
N 130 1030 130 1040 {lab=VDD}
N 160 1030 180 1030 {lab=#net1221}
N 90 1030 100 1030 {lab=#net1223}
N 170 960 170 990 {lab=A11}
N 170 990 170 1040 {lab=A11}
N 80 960 80 1040 {lab=N_A12}
N 0 1030 90 1030 {lab=#net1223}
N 0 960 0 1040 { }
N 2170 1040 2170 1120 {lab=N_A5}
N 2160 1110 2250 1110 {lab=word13}
N 2120 1080 2130 1080 {lab=GND}
N 2130 1050 2130 1080 {lab=GND}
N 2120 1050 2130 1050 {lab=GND}
N 2080 1040 2080 1080 {lab=A5}
N 2080 1080 2080 1120 {lab=A5}
N 2070 1110 2120 1110 {lab=word13}
N 2120 1110 2160 1110 {lab=word13}
N 1990 1040 1990 1120 {lab=N_A4}
N 1980 1110 2070 1110 {lab=word13}
N 1940 1080 1950 1080 {lab=GND}
N 1950 1050 1950 1080 {lab=GND}
N 1940 1050 1950 1050 {lab=GND}
N 1900 1040 1900 1080 {lab=A4}
N 1900 1080 1900 1120 {lab=A4}
N 1890 1110 1940 1110 {lab=word13}
N 1940 1110 1980 1110 {lab=word13}
N 1850 1080 1860 1080 {lab=GND}
N 1860 1050 1860 1080 {lab=GND}
N 1850 1050 1860 1050 {lab=GND}
N 1810 1040 1810 1080 {lab=N_A3}
N 1810 1080 1810 1120 {lab=N_A3}
N 1800 1110 1850 1110 {lab=word13}
N 1850 1110 1890 1110 {lab=word13}
N 1720 1040 1720 1120 {lab=A3}
N 1710 1110 1800 1110 {lab=word13}
N 1670 1080 1680 1080 {lab=GND}
N 1680 1050 1680 1080 {lab=GND}
N 1670 1050 1680 1050 {lab=GND}
N 1630 1040 1630 1080 {lab=N_A2}
N 1630 1080 1630 1120 {lab=N_A2}
N 1620 1110 1670 1110 {lab=word13}
N 1670 1110 1710 1110 {lab=word13}
N 1540 1040 1540 1120 {lab=A2}
N 1530 1110 1620 1110 {lab=word13}
N 1450 1040 1450 1120 {lab=N_A1}
N 1440 1110 1530 1110 {lab=word13}
N 1400 1080 1410 1080 {lab=GND}
N 1410 1050 1410 1080 {lab=GND}
N 1400 1050 1410 1050 {lab=GND}
N 1360 1040 1360 1080 {lab=A1}
N 1360 1080 1360 1120 {lab=A1}
N 1350 1110 1400 1110 {lab=word13}
N 1400 1110 1440 1110 {lab=word13}
N 1310 1080 1320 1080 {lab=GND}
N 1320 1050 1320 1080 {lab=GND}
N 1310 1050 1320 1050 {lab=GND}
N 1270 1040 1270 1080 {lab=N_A0}
N 1270 1080 1270 1120 {lab=N_A0}
N 1260 1110 1310 1110 {lab=word13}
N 1310 1110 1350 1110 {lab=word13}
N 1180 1040 1180 1120 {lab=A0}
N 1170 1110 1260 1110 {lab=word13}
N 1080 1110 1170 1110 { }
N 1070 1040 1070 1120 {lab=A6}
N 990 1110 1080 1110 {lab=word13}
N 940 1070 980 1070 {lab=N_A7}
N 940 1110 940 1120 {lab=VDD}
N 970 1110 990 1110 {lab=word13}
N 900 1110 910 1110 {lab=#net1313}
N 980 1040 980 1070 {lab=N_A7}
N 980 1070 980 1120 {lab=N_A7}
N 850 1070 890 1070 {lab=A7}
N 850 1110 850 1120 {lab=VDD}
N 880 1110 900 1110 {lab=#net1313}
N 810 1110 820 1110 {lab=#net1315}
N 890 1040 890 1070 {lab=A7}
N 890 1070 890 1120 {lab=A7}
N 800 1040 800 1120 {lab=N_A8}
N 720 1110 810 1110 {lab=#net1315}
N 710 1040 710 1120 {lab=A8}
N 630 1110 720 1110 {lab=#net1315}
N 580 1070 620 1070 {lab=N_A9}
N 580 1110 580 1120 {lab=VDD}
N 610 1110 630 1110 {lab=#net1315}
N 540 1110 550 1110 {lab=#net1317}
N 620 1040 620 1070 {lab=N_A9}
N 620 1070 620 1120 {lab=N_A9}
N 530 1040 530 1120 {lab=A9}
N 450 1110 540 1110 {lab=#net1317}
N 400 1070 440 1070 {lab=N_A10}
N 400 1110 400 1120 {lab=VDD}
N 430 1110 450 1110 {lab=#net1317}
N 360 1110 370 1110 {lab=#net1319}
N 440 1040 440 1070 {lab=N_A10}
N 440 1070 440 1120 {lab=N_A10}
N 310 1070 350 1070 {lab=A10}
N 310 1110 310 1120 {lab=VDD}
N 340 1110 360 1110 {lab=#net1319}
N 270 1110 280 1110 {lab=#net1321}
N 350 1040 350 1070 {lab=A10}
N 350 1070 350 1120 {lab=A10}
N 260 1040 260 1120 {lab=N_A11}
N 180 1110 270 1110 {lab=#net1321}
N 130 1070 170 1070 {lab=A11}
N 130 1110 130 1120 {lab=VDD}
N 160 1110 180 1110 {lab=#net1321}
N 90 1110 100 1110 {lab=#net1323}
N 170 1040 170 1070 {lab=A11}
N 170 1070 170 1120 {lab=A11}
N 80 1040 80 1120 {lab=N_A12}
N 0 1110 90 1110 {lab=#net1323}
N 0 1040 0 1120 { }
N 2170 1120 2170 1200 {lab=N_A5}
N 2160 1190 2250 1190 {lab=word14}
N 2120 1160 2130 1160 {lab=GND}
N 2130 1130 2130 1160 {lab=GND}
N 2120 1130 2130 1130 {lab=GND}
N 2080 1120 2080 1160 {lab=A5}
N 2080 1160 2080 1200 {lab=A5}
N 2070 1190 2120 1190 {lab=word14}
N 2120 1190 2160 1190 {lab=word14}
N 1990 1120 1990 1200 {lab=N_A4}
N 1980 1190 2070 1190 {lab=word14}
N 1940 1160 1950 1160 {lab=GND}
N 1950 1130 1950 1160 {lab=GND}
N 1940 1130 1950 1130 {lab=GND}
N 1900 1120 1900 1160 {lab=A4}
N 1900 1160 1900 1200 {lab=A4}
N 1890 1190 1940 1190 {lab=word14}
N 1940 1190 1980 1190 {lab=word14}
N 1850 1160 1860 1160 {lab=GND}
N 1860 1130 1860 1160 {lab=GND}
N 1850 1130 1860 1130 {lab=GND}
N 1810 1120 1810 1160 {lab=N_A3}
N 1810 1160 1810 1200 {lab=N_A3}
N 1800 1190 1850 1190 {lab=word14}
N 1850 1190 1890 1190 {lab=word14}
N 1720 1120 1720 1200 {lab=A3}
N 1710 1190 1800 1190 {lab=word14}
N 1670 1160 1680 1160 {lab=GND}
N 1680 1130 1680 1160 {lab=GND}
N 1670 1130 1680 1130 {lab=GND}
N 1630 1120 1630 1160 {lab=N_A2}
N 1630 1160 1630 1200 {lab=N_A2}
N 1620 1190 1670 1190 {lab=word14}
N 1670 1190 1710 1190 {lab=word14}
N 1540 1120 1540 1200 {lab=A2}
N 1530 1190 1620 1190 {lab=word14}
N 1490 1160 1500 1160 {lab=GND}
N 1500 1130 1500 1160 {lab=GND}
N 1490 1130 1500 1130 {lab=GND}
N 1450 1120 1450 1160 {lab=N_A1}
N 1450 1160 1450 1200 {lab=N_A1}
N 1440 1190 1490 1190 {lab=word14}
N 1490 1190 1530 1190 {lab=word14}
N 1360 1120 1360 1200 {lab=A1}
N 1350 1190 1440 1190 {lab=word14}
N 1270 1120 1270 1200 {lab=N_A0}
N 1260 1190 1350 1190 {lab=word14}
N 1220 1160 1230 1160 {lab=GND}
N 1230 1130 1230 1160 {lab=GND}
N 1220 1130 1230 1130 {lab=GND}
N 1180 1120 1180 1160 {lab=A0}
N 1180 1160 1180 1200 {lab=A0}
N 1170 1190 1220 1190 {lab=word14}
N 1220 1190 1260 1190 {lab=word14}
N 1080 1190 1170 1190 { }
N 1030 1150 1070 1150 {lab=A6}
N 1030 1190 1030 1200 {lab=VDD}
N 1060 1190 1080 1190 {lab=word14}
N 990 1190 1000 1190 {lab=#net1413}
N 1070 1120 1070 1150 {lab=A6}
N 1070 1150 1070 1200 {lab=A6}
N 980 1120 980 1200 {lab=N_A7}
N 900 1190 990 1190 {lab=#net1413}
N 890 1120 890 1200 {lab=A7}
N 810 1190 900 1190 {lab=#net1413}
N 760 1150 800 1150 {lab=N_A8}
N 760 1190 760 1200 {lab=VDD}
N 790 1190 810 1190 {lab=#net1413}
N 720 1190 730 1190 {lab=#net1415}
N 800 1120 800 1150 {lab=N_A8}
N 800 1150 800 1200 {lab=N_A8}
N 710 1120 710 1200 {lab=A8}
N 630 1190 720 1190 {lab=#net1415}
N 580 1150 620 1150 {lab=N_A9}
N 580 1190 580 1200 {lab=VDD}
N 610 1190 630 1190 {lab=#net1415}
N 540 1190 550 1190 {lab=#net1417}
N 620 1120 620 1150 {lab=N_A9}
N 620 1150 620 1200 {lab=N_A9}
N 530 1120 530 1200 {lab=A9}
N 450 1190 540 1190 {lab=#net1417}
N 400 1150 440 1150 {lab=N_A10}
N 400 1190 400 1200 {lab=VDD}
N 430 1190 450 1190 {lab=#net1417}
N 360 1190 370 1190 {lab=#net1419}
N 440 1120 440 1150 {lab=N_A10}
N 440 1150 440 1200 {lab=N_A10}
N 310 1150 350 1150 {lab=A10}
N 310 1190 310 1200 {lab=VDD}
N 340 1190 360 1190 {lab=#net1419}
N 270 1190 280 1190 {lab=#net1421}
N 350 1120 350 1150 {lab=A10}
N 350 1150 350 1200 {lab=A10}
N 260 1120 260 1200 {lab=N_A11}
N 180 1190 270 1190 {lab=#net1421}
N 130 1150 170 1150 {lab=A11}
N 130 1190 130 1200 {lab=VDD}
N 160 1190 180 1190 {lab=#net1421}
N 90 1190 100 1190 {lab=#net1423}
N 170 1120 170 1150 {lab=A11}
N 170 1150 170 1200 {lab=A11}
N 80 1120 80 1200 {lab=N_A12}
N 0 1190 90 1190 {lab=#net1423}
N 0 1120 0 1200 { }
N 2170 1200 2170 1280 {lab=N_A5}
N 2160 1270 2250 1270 {lab=word15}
N 2120 1240 2130 1240 {lab=GND}
N 2130 1210 2130 1240 {lab=GND}
N 2120 1210 2130 1210 {lab=GND}
N 2080 1200 2080 1240 {lab=A5}
N 2080 1240 2080 1280 {lab=A5}
N 2070 1270 2120 1270 {lab=word15}
N 2120 1270 2160 1270 {lab=word15}
N 1990 1200 1990 1280 {lab=N_A4}
N 1980 1270 2070 1270 {lab=word15}
N 1940 1240 1950 1240 {lab=GND}
N 1950 1210 1950 1240 {lab=GND}
N 1940 1210 1950 1210 {lab=GND}
N 1900 1200 1900 1240 {lab=A4}
N 1900 1240 1900 1280 {lab=A4}
N 1890 1270 1940 1270 {lab=word15}
N 1940 1270 1980 1270 {lab=word15}
N 1850 1240 1860 1240 {lab=GND}
N 1860 1210 1860 1240 {lab=GND}
N 1850 1210 1860 1210 {lab=GND}
N 1810 1200 1810 1240 {lab=N_A3}
N 1810 1240 1810 1280 {lab=N_A3}
N 1800 1270 1850 1270 {lab=word15}
N 1850 1270 1890 1270 {lab=word15}
N 1720 1200 1720 1280 {lab=A3}
N 1710 1270 1800 1270 {lab=word15}
N 1670 1240 1680 1240 {lab=GND}
N 1680 1210 1680 1240 {lab=GND}
N 1670 1210 1680 1210 {lab=GND}
N 1630 1200 1630 1240 {lab=N_A2}
N 1630 1240 1630 1280 {lab=N_A2}
N 1620 1270 1670 1270 {lab=word15}
N 1670 1270 1710 1270 {lab=word15}
N 1540 1200 1540 1280 {lab=A2}
N 1530 1270 1620 1270 {lab=word15}
N 1490 1240 1500 1240 {lab=GND}
N 1500 1210 1500 1240 {lab=GND}
N 1490 1210 1500 1210 {lab=GND}
N 1450 1200 1450 1240 {lab=N_A1}
N 1450 1240 1450 1280 {lab=N_A1}
N 1440 1270 1490 1270 {lab=word15}
N 1490 1270 1530 1270 {lab=word15}
N 1360 1200 1360 1280 {lab=A1}
N 1350 1270 1440 1270 {lab=word15}
N 1310 1240 1320 1240 {lab=GND}
N 1320 1210 1320 1240 {lab=GND}
N 1310 1210 1320 1210 {lab=GND}
N 1270 1200 1270 1240 {lab=N_A0}
N 1270 1240 1270 1280 {lab=N_A0}
N 1260 1270 1310 1270 {lab=word15}
N 1310 1270 1350 1270 {lab=word15}
N 1180 1200 1180 1280 {lab=A0}
N 1170 1270 1260 1270 {lab=word15}
N 1080 1270 1170 1270 { }
N 1070 1200 1070 1280 {lab=A6}
N 990 1270 1080 1270 {lab=word15}
N 940 1230 980 1230 {lab=N_A7}
N 940 1270 940 1280 {lab=VDD}
N 970 1270 990 1270 {lab=word15}
N 900 1270 910 1270 {lab=#net1513}
N 980 1200 980 1230 {lab=N_A7}
N 980 1230 980 1280 {lab=N_A7}
N 890 1200 890 1280 {lab=A7}
N 810 1270 900 1270 {lab=#net1513}
N 760 1230 800 1230 {lab=N_A8}
N 760 1270 760 1280 {lab=VDD}
N 790 1270 810 1270 {lab=#net1513}
N 720 1270 730 1270 {lab=#net1515}
N 800 1200 800 1230 {lab=N_A8}
N 800 1230 800 1280 {lab=N_A8}
N 710 1200 710 1280 {lab=A8}
N 630 1270 720 1270 {lab=#net1515}
N 580 1230 620 1230 {lab=N_A9}
N 580 1270 580 1280 {lab=VDD}
N 610 1270 630 1270 {lab=#net1515}
N 540 1270 550 1270 {lab=#net1517}
N 620 1200 620 1230 {lab=N_A9}
N 620 1230 620 1280 {lab=N_A9}
N 530 1200 530 1280 {lab=A9}
N 450 1270 540 1270 {lab=#net1517}
N 400 1230 440 1230 {lab=N_A10}
N 400 1270 400 1280 {lab=VDD}
N 430 1270 450 1270 {lab=#net1517}
N 360 1270 370 1270 {lab=#net1519}
N 440 1200 440 1230 {lab=N_A10}
N 440 1230 440 1280 {lab=N_A10}
N 310 1230 350 1230 {lab=A10}
N 310 1270 310 1280 {lab=VDD}
N 340 1270 360 1270 {lab=#net1519}
N 270 1270 280 1270 {lab=#net1521}
N 350 1200 350 1230 {lab=A10}
N 350 1230 350 1280 {lab=A10}
N 260 1200 260 1280 {lab=N_A11}
N 180 1270 270 1270 {lab=#net1521}
N 130 1230 170 1230 {lab=A11}
N 130 1270 130 1280 {lab=VDD}
N 160 1270 180 1270 {lab=#net1521}
N 90 1270 100 1270 {lab=#net1523}
N 170 1200 170 1230 {lab=A11}
N 170 1230 170 1280 {lab=A11}
N 80 1200 80 1280 {lab=N_A12}
N 0 1270 90 1270 {lab=#net1523}
N 0 1200 0 1280 { }
N 2170 1280 2170 1360 {lab=N_A5}
N 2160 1350 2250 1350 {lab=word16}
N 2120 1320 2130 1320 {lab=GND}
N 2130 1290 2130 1320 {lab=GND}
N 2120 1290 2130 1290 {lab=GND}
N 2080 1280 2080 1320 {lab=A5}
N 2080 1320 2080 1360 {lab=A5}
N 2070 1350 2120 1350 {lab=word16}
N 2120 1350 2160 1350 {lab=word16}
N 2030 1320 2040 1320 {lab=GND}
N 2040 1290 2040 1320 {lab=GND}
N 2030 1290 2040 1290 {lab=GND}
N 1990 1280 1990 1320 {lab=N_A4}
N 1990 1320 1990 1360 {lab=N_A4}
N 1980 1350 2030 1350 {lab=word16}
N 2030 1350 2070 1350 {lab=word16}
N 1900 1280 1900 1360 {lab=A4}
N 1890 1350 1980 1350 {lab=word16}
N 1810 1280 1810 1360 {lab=N_A3}
N 1800 1350 1890 1350 {lab=word16}
N 1760 1320 1770 1320 {lab=GND}
N 1770 1290 1770 1320 {lab=GND}
N 1760 1290 1770 1290 {lab=GND}
N 1720 1280 1720 1320 {lab=A3}
N 1720 1320 1720 1360 {lab=A3}
N 1710 1350 1760 1350 {lab=word16}
N 1760 1350 1800 1350 {lab=word16}
N 1630 1280 1630 1360 {lab=N_A2}
N 1620 1350 1710 1350 {lab=word16}
N 1580 1320 1590 1320 {lab=GND}
N 1590 1290 1590 1320 {lab=GND}
N 1580 1290 1590 1290 {lab=GND}
N 1540 1280 1540 1320 {lab=A2}
N 1540 1320 1540 1360 {lab=A2}
N 1530 1350 1580 1350 {lab=word16}
N 1580 1350 1620 1350 {lab=word16}
N 1450 1280 1450 1360 {lab=N_A1}
N 1440 1350 1530 1350 {lab=word16}
N 1400 1320 1410 1320 {lab=GND}
N 1410 1290 1410 1320 {lab=GND}
N 1400 1290 1410 1290 {lab=GND}
N 1360 1280 1360 1320 {lab=A1}
N 1360 1320 1360 1360 {lab=A1}
N 1350 1350 1400 1350 {lab=word16}
N 1400 1350 1440 1350 {lab=word16}
N 1270 1280 1270 1360 {lab=N_A0}
N 1260 1350 1350 1350 {lab=word16}
N 1220 1320 1230 1320 {lab=GND}
N 1230 1290 1230 1320 {lab=GND}
N 1220 1290 1230 1290 {lab=GND}
N 1180 1280 1180 1320 {lab=A0}
N 1180 1320 1180 1360 {lab=A0}
N 1170 1350 1220 1350 {lab=word16}
N 1220 1350 1260 1350 {lab=word16}
N 1080 1350 1170 1350 { }
N 1030 1310 1070 1310 {lab=A6}
N 1030 1350 1030 1360 {lab=VDD}
N 1060 1350 1080 1350 {lab=word16}
N 990 1350 1000 1350 {lab=#net1613}
N 1070 1280 1070 1310 {lab=A6}
N 1070 1310 1070 1360 {lab=A6}
N 980 1280 980 1360 {lab=N_A7}
N 900 1350 990 1350 {lab=#net1613}
N 850 1310 890 1310 {lab=A7}
N 850 1350 850 1360 {lab=VDD}
N 880 1350 900 1350 {lab=#net1613}
N 810 1350 820 1350 {lab=#net1615}
N 890 1280 890 1310 {lab=A7}
N 890 1310 890 1360 {lab=A7}
N 800 1280 800 1360 {lab=N_A8}
N 720 1350 810 1350 {lab=#net1615}
N 670 1310 710 1310 {lab=A8}
N 670 1350 670 1360 {lab=VDD}
N 700 1350 720 1350 {lab=#net1615}
N 630 1350 640 1350 {lab=#net1617}
N 710 1280 710 1310 {lab=A8}
N 710 1310 710 1360 {lab=A8}
N 620 1280 620 1360 {lab=N_A9}
N 540 1350 630 1350 {lab=#net1617}
N 490 1310 530 1310 {lab=A9}
N 490 1350 490 1360 {lab=VDD}
N 520 1350 540 1350 {lab=#net1617}
N 450 1350 460 1350 {lab=#net1619}
N 530 1280 530 1310 {lab=A9}
N 530 1310 530 1360 {lab=A9}
N 440 1280 440 1360 {lab=N_A10}
N 360 1350 450 1350 {lab=#net1619}
N 350 1280 350 1360 {lab=A10}
N 270 1350 360 1350 {lab=#net1619}
N 220 1310 260 1310 {lab=N_A11}
N 220 1350 220 1360 {lab=VDD}
N 250 1350 270 1350 {lab=#net1619}
N 180 1350 190 1350 {lab=#net1621}
N 260 1280 260 1310 {lab=N_A11}
N 260 1310 260 1360 {lab=N_A11}
N 130 1310 170 1310 {lab=A11}
N 130 1350 130 1360 {lab=VDD}
N 160 1350 180 1350 {lab=#net1621}
N 90 1350 100 1350 {lab=#net1623}
N 170 1280 170 1310 {lab=A11}
N 170 1310 170 1360 {lab=A11}
N 80 1280 80 1360 {lab=N_A12}
N 0 1350 90 1350 {lab=#net1623}
N 0 1280 0 1360 { }
N 2170 1360 2170 1440 {lab=N_A5}
N 2160 1430 2250 1430 {lab=word17}
N 2120 1400 2130 1400 {lab=GND}
N 2130 1370 2130 1400 {lab=GND}
N 2120 1370 2130 1370 {lab=GND}
N 2080 1360 2080 1400 {lab=A5}
N 2080 1400 2080 1440 {lab=A5}
N 2070 1430 2120 1430 {lab=word17}
N 2120 1430 2160 1430 {lab=word17}
N 2030 1400 2040 1400 {lab=GND}
N 2040 1370 2040 1400 {lab=GND}
N 2030 1370 2040 1370 {lab=GND}
N 1990 1360 1990 1400 {lab=N_A4}
N 1990 1400 1990 1440 {lab=N_A4}
N 1980 1430 2030 1430 {lab=word17}
N 2030 1430 2070 1430 {lab=word17}
N 1900 1360 1900 1440 {lab=A4}
N 1890 1430 1980 1430 {lab=word17}
N 1810 1360 1810 1440 {lab=N_A3}
N 1800 1430 1890 1430 {lab=word17}
N 1760 1400 1770 1400 {lab=GND}
N 1770 1370 1770 1400 {lab=GND}
N 1760 1370 1770 1370 {lab=GND}
N 1720 1360 1720 1400 {lab=A3}
N 1720 1400 1720 1440 {lab=A3}
N 1710 1430 1760 1430 {lab=word17}
N 1760 1430 1800 1430 {lab=word17}
N 1630 1360 1630 1440 {lab=N_A2}
N 1620 1430 1710 1430 {lab=word17}
N 1580 1400 1590 1400 {lab=GND}
N 1590 1370 1590 1400 {lab=GND}
N 1580 1370 1590 1370 {lab=GND}
N 1540 1360 1540 1400 {lab=A2}
N 1540 1400 1540 1440 {lab=A2}
N 1530 1430 1580 1430 {lab=word17}
N 1580 1430 1620 1430 {lab=word17}
N 1450 1360 1450 1440 {lab=N_A1}
N 1440 1430 1530 1430 {lab=word17}
N 1400 1400 1410 1400 {lab=GND}
N 1410 1370 1410 1400 {lab=GND}
N 1400 1370 1410 1370 {lab=GND}
N 1360 1360 1360 1400 {lab=A1}
N 1360 1400 1360 1440 {lab=A1}
N 1350 1430 1400 1430 {lab=word17}
N 1400 1430 1440 1430 {lab=word17}
N 1310 1400 1320 1400 {lab=GND}
N 1320 1370 1320 1400 {lab=GND}
N 1310 1370 1320 1370 {lab=GND}
N 1270 1360 1270 1400 {lab=N_A0}
N 1270 1400 1270 1440 {lab=N_A0}
N 1260 1430 1310 1430 {lab=word17}
N 1310 1430 1350 1430 {lab=word17}
N 1180 1360 1180 1440 {lab=A0}
N 1170 1430 1260 1430 {lab=word17}
N 1080 1430 1170 1430 { }
N 1070 1360 1070 1440 {lab=A6}
N 990 1430 1080 1430 {lab=word17}
N 940 1390 980 1390 {lab=N_A7}
N 940 1430 940 1440 {lab=VDD}
N 970 1430 990 1430 {lab=word17}
N 900 1430 910 1430 {lab=#net1713}
N 980 1360 980 1390 {lab=N_A7}
N 980 1390 980 1440 {lab=N_A7}
N 850 1390 890 1390 {lab=A7}
N 850 1430 850 1440 {lab=VDD}
N 880 1430 900 1430 {lab=#net1713}
N 810 1430 820 1430 {lab=#net1715}
N 890 1360 890 1390 {lab=A7}
N 890 1390 890 1440 {lab=A7}
N 800 1360 800 1440 {lab=N_A8}
N 720 1430 810 1430 {lab=#net1715}
N 670 1390 710 1390 {lab=A8}
N 670 1430 670 1440 {lab=VDD}
N 700 1430 720 1430 {lab=#net1715}
N 630 1430 640 1430 {lab=#net1717}
N 710 1360 710 1390 {lab=A8}
N 710 1390 710 1440 {lab=A8}
N 620 1360 620 1440 {lab=N_A9}
N 540 1430 630 1430 {lab=#net1717}
N 490 1390 530 1390 {lab=A9}
N 490 1430 490 1440 {lab=VDD}
N 520 1430 540 1430 {lab=#net1717}
N 450 1430 460 1430 {lab=#net1719}
N 530 1360 530 1390 {lab=A9}
N 530 1390 530 1440 {lab=A9}
N 440 1360 440 1440 {lab=N_A10}
N 360 1430 450 1430 {lab=#net1719}
N 350 1360 350 1440 {lab=A10}
N 270 1430 360 1430 {lab=#net1719}
N 220 1390 260 1390 {lab=N_A11}
N 220 1430 220 1440 {lab=VDD}
N 250 1430 270 1430 {lab=#net1719}
N 180 1430 190 1430 {lab=#net1721}
N 260 1360 260 1390 {lab=N_A11}
N 260 1390 260 1440 {lab=N_A11}
N 130 1390 170 1390 {lab=A11}
N 130 1430 130 1440 {lab=VDD}
N 160 1430 180 1430 {lab=#net1721}
N 90 1430 100 1430 {lab=#net1723}
N 170 1360 170 1390 {lab=A11}
N 170 1390 170 1440 {lab=A11}
N 80 1360 80 1440 {lab=N_A12}
N 0 1430 90 1430 {lab=#net1723}
N 0 1360 0 1440 { }
N 2170 1440 2170 1520 {lab=N_A5}
N 2160 1510 2250 1510 {lab=word18}
N 2120 1480 2130 1480 {lab=GND}
N 2130 1450 2130 1480 {lab=GND}
N 2120 1450 2130 1450 {lab=GND}
N 2080 1440 2080 1480 {lab=A5}
N 2080 1480 2080 1520 {lab=A5}
N 2070 1510 2120 1510 {lab=word18}
N 2120 1510 2160 1510 {lab=word18}
N 2030 1480 2040 1480 {lab=GND}
N 2040 1450 2040 1480 {lab=GND}
N 2030 1450 2040 1450 {lab=GND}
N 1990 1440 1990 1480 {lab=N_A4}
N 1990 1480 1990 1520 {lab=N_A4}
N 1980 1510 2030 1510 {lab=word18}
N 2030 1510 2070 1510 {lab=word18}
N 1900 1440 1900 1520 {lab=A4}
N 1890 1510 1980 1510 {lab=word18}
N 1810 1440 1810 1520 {lab=N_A3}
N 1800 1510 1890 1510 {lab=word18}
N 1760 1480 1770 1480 {lab=GND}
N 1770 1450 1770 1480 {lab=GND}
N 1760 1450 1770 1450 {lab=GND}
N 1720 1440 1720 1480 {lab=A3}
N 1720 1480 1720 1520 {lab=A3}
N 1710 1510 1760 1510 {lab=word18}
N 1760 1510 1800 1510 {lab=word18}
N 1630 1440 1630 1520 {lab=N_A2}
N 1620 1510 1710 1510 {lab=word18}
N 1580 1480 1590 1480 {lab=GND}
N 1590 1450 1590 1480 {lab=GND}
N 1580 1450 1590 1450 {lab=GND}
N 1540 1440 1540 1480 {lab=A2}
N 1540 1480 1540 1520 {lab=A2}
N 1530 1510 1580 1510 {lab=word18}
N 1580 1510 1620 1510 {lab=word18}
N 1490 1480 1500 1480 {lab=GND}
N 1500 1450 1500 1480 {lab=GND}
N 1490 1450 1500 1450 {lab=GND}
N 1450 1440 1450 1480 {lab=N_A1}
N 1450 1480 1450 1520 {lab=N_A1}
N 1440 1510 1490 1510 {lab=word18}
N 1490 1510 1530 1510 {lab=word18}
N 1360 1440 1360 1520 {lab=A1}
N 1350 1510 1440 1510 {lab=word18}
N 1270 1440 1270 1520 {lab=N_A0}
N 1260 1510 1350 1510 {lab=word18}
N 1220 1480 1230 1480 {lab=GND}
N 1230 1450 1230 1480 {lab=GND}
N 1220 1450 1230 1450 {lab=GND}
N 1180 1440 1180 1480 {lab=A0}
N 1180 1480 1180 1520 {lab=A0}
N 1170 1510 1220 1510 {lab=word18}
N 1220 1510 1260 1510 {lab=word18}
N 1080 1510 1170 1510 { }
N 1030 1470 1070 1470 {lab=A6}
N 1030 1510 1030 1520 {lab=VDD}
N 1060 1510 1080 1510 {lab=word18}
N 990 1510 1000 1510 {lab=#net1813}
N 1070 1440 1070 1470 {lab=A6}
N 1070 1470 1070 1520 {lab=A6}
N 980 1440 980 1520 {lab=N_A7}
N 900 1510 990 1510 {lab=#net1813}
N 890 1440 890 1520 {lab=A7}
N 810 1510 900 1510 {lab=#net1813}
N 760 1470 800 1470 {lab=N_A8}
N 760 1510 760 1520 {lab=VDD}
N 790 1510 810 1510 {lab=#net1813}
N 720 1510 730 1510 {lab=#net1815}
N 800 1440 800 1470 {lab=N_A8}
N 800 1470 800 1520 {lab=N_A8}
N 670 1470 710 1470 {lab=A8}
N 670 1510 670 1520 {lab=VDD}
N 700 1510 720 1510 {lab=#net1815}
N 630 1510 640 1510 {lab=#net1817}
N 710 1440 710 1470 {lab=A8}
N 710 1470 710 1520 {lab=A8}
N 620 1440 620 1520 {lab=N_A9}
N 540 1510 630 1510 {lab=#net1817}
N 490 1470 530 1470 {lab=A9}
N 490 1510 490 1520 {lab=VDD}
N 520 1510 540 1510 {lab=#net1817}
N 450 1510 460 1510 {lab=#net1819}
N 530 1440 530 1470 {lab=A9}
N 530 1470 530 1520 {lab=A9}
N 440 1440 440 1520 {lab=N_A10}
N 360 1510 450 1510 {lab=#net1819}
N 350 1440 350 1520 {lab=A10}
N 270 1510 360 1510 {lab=#net1819}
N 220 1470 260 1470 {lab=N_A11}
N 220 1510 220 1520 {lab=VDD}
N 250 1510 270 1510 {lab=#net1819}
N 180 1510 190 1510 {lab=#net1821}
N 260 1440 260 1470 {lab=N_A11}
N 260 1470 260 1520 {lab=N_A11}
N 130 1470 170 1470 {lab=A11}
N 130 1510 130 1520 {lab=VDD}
N 160 1510 180 1510 {lab=#net1821}
N 90 1510 100 1510 {lab=#net1823}
N 170 1440 170 1470 {lab=A11}
N 170 1470 170 1520 {lab=A11}
N 80 1440 80 1520 {lab=N_A12}
N 0 1510 90 1510 {lab=#net1823}
N 0 1440 0 1520 { }
N 2170 1520 2170 1600 {lab=N_A5}
N 2160 1590 2250 1590 {lab=word19}
N 2120 1560 2130 1560 {lab=GND}
N 2130 1530 2130 1560 {lab=GND}
N 2120 1530 2130 1530 {lab=GND}
N 2080 1520 2080 1560 {lab=A5}
N 2080 1560 2080 1600 {lab=A5}
N 2070 1590 2120 1590 {lab=word19}
N 2120 1590 2160 1590 {lab=word19}
N 2030 1560 2040 1560 {lab=GND}
N 2040 1530 2040 1560 {lab=GND}
N 2030 1530 2040 1530 {lab=GND}
N 1990 1520 1990 1560 {lab=N_A4}
N 1990 1560 1990 1600 {lab=N_A4}
N 1980 1590 2030 1590 {lab=word19}
N 2030 1590 2070 1590 {lab=word19}
N 1900 1520 1900 1600 {lab=A4}
N 1890 1590 1980 1590 {lab=word19}
N 1810 1520 1810 1600 {lab=N_A3}
N 1800 1590 1890 1590 {lab=word19}
N 1760 1560 1770 1560 {lab=GND}
N 1770 1530 1770 1560 {lab=GND}
N 1760 1530 1770 1530 {lab=GND}
N 1720 1520 1720 1560 {lab=A3}
N 1720 1560 1720 1600 {lab=A3}
N 1710 1590 1760 1590 {lab=word19}
N 1760 1590 1800 1590 {lab=word19}
N 1630 1520 1630 1600 {lab=N_A2}
N 1620 1590 1710 1590 {lab=word19}
N 1580 1560 1590 1560 {lab=GND}
N 1590 1530 1590 1560 {lab=GND}
N 1580 1530 1590 1530 {lab=GND}
N 1540 1520 1540 1560 {lab=A2}
N 1540 1560 1540 1600 {lab=A2}
N 1530 1590 1580 1590 {lab=word19}
N 1580 1590 1620 1590 {lab=word19}
N 1490 1560 1500 1560 {lab=GND}
N 1500 1530 1500 1560 {lab=GND}
N 1490 1530 1500 1530 {lab=GND}
N 1450 1520 1450 1560 {lab=N_A1}
N 1450 1560 1450 1600 {lab=N_A1}
N 1440 1590 1490 1590 {lab=word19}
N 1490 1590 1530 1590 {lab=word19}
N 1360 1520 1360 1600 {lab=A1}
N 1350 1590 1440 1590 {lab=word19}
N 1310 1560 1320 1560 {lab=GND}
N 1320 1530 1320 1560 {lab=GND}
N 1310 1530 1320 1530 {lab=GND}
N 1270 1520 1270 1560 {lab=N_A0}
N 1270 1560 1270 1600 {lab=N_A0}
N 1260 1590 1310 1590 {lab=word19}
N 1310 1590 1350 1590 {lab=word19}
N 1180 1520 1180 1600 {lab=A0}
N 1170 1590 1260 1590 {lab=word19}
N 1080 1590 1170 1590 { }
N 1070 1520 1070 1600 {lab=A6}
N 990 1590 1080 1590 {lab=word19}
N 940 1550 980 1550 {lab=N_A7}
N 940 1590 940 1600 {lab=VDD}
N 970 1590 990 1590 {lab=word19}
N 900 1590 910 1590 {lab=#net1913}
N 980 1520 980 1550 {lab=N_A7}
N 980 1550 980 1600 {lab=N_A7}
N 890 1520 890 1600 {lab=A7}
N 810 1590 900 1590 {lab=#net1913}
N 760 1550 800 1550 {lab=N_A8}
N 760 1590 760 1600 {lab=VDD}
N 790 1590 810 1590 {lab=#net1913}
N 720 1590 730 1590 {lab=#net1915}
N 800 1520 800 1550 {lab=N_A8}
N 800 1550 800 1600 {lab=N_A8}
N 670 1550 710 1550 {lab=A8}
N 670 1590 670 1600 {lab=VDD}
N 700 1590 720 1590 {lab=#net1915}
N 630 1590 640 1590 {lab=#net1917}
N 710 1520 710 1550 {lab=A8}
N 710 1550 710 1600 {lab=A8}
N 620 1520 620 1600 {lab=N_A9}
N 540 1590 630 1590 {lab=#net1917}
N 490 1550 530 1550 {lab=A9}
N 490 1590 490 1600 {lab=VDD}
N 520 1590 540 1590 {lab=#net1917}
N 450 1590 460 1590 {lab=#net1919}
N 530 1520 530 1550 {lab=A9}
N 530 1550 530 1600 {lab=A9}
N 440 1520 440 1600 {lab=N_A10}
N 360 1590 450 1590 {lab=#net1919}
N 350 1520 350 1600 {lab=A10}
N 270 1590 360 1590 {lab=#net1919}
N 220 1550 260 1550 {lab=N_A11}
N 220 1590 220 1600 {lab=VDD}
N 250 1590 270 1590 {lab=#net1919}
N 180 1590 190 1590 {lab=#net1921}
N 260 1520 260 1550 {lab=N_A11}
N 260 1550 260 1600 {lab=N_A11}
N 130 1550 170 1550 {lab=A11}
N 130 1590 130 1600 {lab=VDD}
N 160 1590 180 1590 {lab=#net1921}
N 90 1590 100 1590 {lab=#net1923}
N 170 1520 170 1550 {lab=A11}
N 170 1550 170 1600 {lab=A11}
N 80 1520 80 1600 {lab=N_A12}
N 0 1590 90 1590 {lab=#net1923}
N 0 1520 0 1600 { }
N 2170 1600 2170 1680 {lab=N_A5}
N 2160 1670 2250 1670 {lab=word20}
N 2120 1640 2130 1640 {lab=GND}
N 2130 1610 2130 1640 {lab=GND}
N 2120 1610 2130 1610 {lab=GND}
N 2080 1600 2080 1640 {lab=A5}
N 2080 1640 2080 1680 {lab=A5}
N 2070 1670 2120 1670 {lab=word20}
N 2120 1670 2160 1670 {lab=word20}
N 2030 1640 2040 1640 {lab=GND}
N 2040 1610 2040 1640 {lab=GND}
N 2030 1610 2040 1610 {lab=GND}
N 1990 1600 1990 1640 {lab=N_A4}
N 1990 1640 1990 1680 {lab=N_A4}
N 1980 1670 2030 1670 {lab=word20}
N 2030 1670 2070 1670 {lab=word20}
N 1900 1600 1900 1680 {lab=A4}
N 1890 1670 1980 1670 {lab=word20}
N 1810 1600 1810 1680 {lab=N_A3}
N 1800 1670 1890 1670 {lab=word20}
N 1760 1640 1770 1640 {lab=GND}
N 1770 1610 1770 1640 {lab=GND}
N 1760 1610 1770 1610 {lab=GND}
N 1720 1600 1720 1640 {lab=A3}
N 1720 1640 1720 1680 {lab=A3}
N 1710 1670 1760 1670 {lab=word20}
N 1760 1670 1800 1670 {lab=word20}
N 1670 1640 1680 1640 {lab=GND}
N 1680 1610 1680 1640 {lab=GND}
N 1670 1610 1680 1610 {lab=GND}
N 1630 1600 1630 1640 {lab=N_A2}
N 1630 1640 1630 1680 {lab=N_A2}
N 1620 1670 1670 1670 {lab=word20}
N 1670 1670 1710 1670 {lab=word20}
N 1540 1600 1540 1680 {lab=A2}
N 1530 1670 1620 1670 {lab=word20}
N 1450 1600 1450 1680 {lab=N_A1}
N 1440 1670 1530 1670 {lab=word20}
N 1400 1640 1410 1640 {lab=GND}
N 1410 1610 1410 1640 {lab=GND}
N 1400 1610 1410 1610 {lab=GND}
N 1360 1600 1360 1640 {lab=A1}
N 1360 1640 1360 1680 {lab=A1}
N 1350 1670 1400 1670 {lab=word20}
N 1400 1670 1440 1670 {lab=word20}
N 1270 1600 1270 1680 {lab=N_A0}
N 1260 1670 1350 1670 {lab=word20}
N 1220 1640 1230 1640 {lab=GND}
N 1230 1610 1230 1640 {lab=GND}
N 1220 1610 1230 1610 {lab=GND}
N 1180 1600 1180 1640 {lab=A0}
N 1180 1640 1180 1680 {lab=A0}
N 1170 1670 1220 1670 {lab=word20}
N 1220 1670 1260 1670 {lab=word20}
N 1080 1670 1170 1670 { }
N 1030 1630 1070 1630 {lab=A6}
N 1030 1670 1030 1680 {lab=VDD}
N 1060 1670 1080 1670 {lab=word20}
N 990 1670 1000 1670 {lab=#net2013}
N 1070 1600 1070 1630 {lab=A6}
N 1070 1630 1070 1680 {lab=A6}
N 980 1600 980 1680 {lab=N_A7}
N 900 1670 990 1670 {lab=#net2013}
N 850 1630 890 1630 {lab=A7}
N 850 1670 850 1680 {lab=VDD}
N 880 1670 900 1670 {lab=#net2013}
N 810 1670 820 1670 {lab=#net2015}
N 890 1600 890 1630 {lab=A7}
N 890 1630 890 1680 {lab=A7}
N 800 1600 800 1680 {lab=N_A8}
N 720 1670 810 1670 {lab=#net2015}
N 710 1600 710 1680 {lab=A8}
N 630 1670 720 1670 {lab=#net2015}
N 580 1630 620 1630 {lab=N_A9}
N 580 1670 580 1680 {lab=VDD}
N 610 1670 630 1670 {lab=#net2015}
N 540 1670 550 1670 {lab=#net2017}
N 620 1600 620 1630 {lab=N_A9}
N 620 1630 620 1680 {lab=N_A9}
N 490 1630 530 1630 {lab=A9}
N 490 1670 490 1680 {lab=VDD}
N 520 1670 540 1670 {lab=#net2017}
N 450 1670 460 1670 {lab=#net2019}
N 530 1600 530 1630 {lab=A9}
N 530 1630 530 1680 {lab=A9}
N 440 1600 440 1680 {lab=N_A10}
N 360 1670 450 1670 {lab=#net2019}
N 350 1600 350 1680 {lab=A10}
N 270 1670 360 1670 {lab=#net2019}
N 220 1630 260 1630 {lab=N_A11}
N 220 1670 220 1680 {lab=VDD}
N 250 1670 270 1670 {lab=#net2019}
N 180 1670 190 1670 {lab=#net2021}
N 260 1600 260 1630 {lab=N_A11}
N 260 1630 260 1680 {lab=N_A11}
N 130 1630 170 1630 {lab=A11}
N 130 1670 130 1680 {lab=VDD}
N 160 1670 180 1670 {lab=#net2021}
N 90 1670 100 1670 {lab=#net2023}
N 170 1600 170 1630 {lab=A11}
N 170 1630 170 1680 {lab=A11}
N 80 1600 80 1680 {lab=N_A12}
N 0 1670 90 1670 {lab=#net2023}
N 0 1600 0 1680 { }
N 2170 1680 2170 1760 {lab=N_A5}
N 2160 1750 2250 1750 {lab=word21}
N 2120 1720 2130 1720 {lab=GND}
N 2130 1690 2130 1720 {lab=GND}
N 2120 1690 2130 1690 {lab=GND}
N 2080 1680 2080 1720 {lab=A5}
N 2080 1720 2080 1760 {lab=A5}
N 2070 1750 2120 1750 {lab=word21}
N 2120 1750 2160 1750 {lab=word21}
N 2030 1720 2040 1720 {lab=GND}
N 2040 1690 2040 1720 {lab=GND}
N 2030 1690 2040 1690 {lab=GND}
N 1990 1680 1990 1720 {lab=N_A4}
N 1990 1720 1990 1760 {lab=N_A4}
N 1980 1750 2030 1750 {lab=word21}
N 2030 1750 2070 1750 {lab=word21}
N 1900 1680 1900 1760 {lab=A4}
N 1890 1750 1980 1750 {lab=word21}
N 1810 1680 1810 1760 {lab=N_A3}
N 1800 1750 1890 1750 {lab=word21}
N 1760 1720 1770 1720 {lab=GND}
N 1770 1690 1770 1720 {lab=GND}
N 1760 1690 1770 1690 {lab=GND}
N 1720 1680 1720 1720 {lab=A3}
N 1720 1720 1720 1760 {lab=A3}
N 1710 1750 1760 1750 {lab=word21}
N 1760 1750 1800 1750 {lab=word21}
N 1670 1720 1680 1720 {lab=GND}
N 1680 1690 1680 1720 {lab=GND}
N 1670 1690 1680 1690 {lab=GND}
N 1630 1680 1630 1720 {lab=N_A2}
N 1630 1720 1630 1760 {lab=N_A2}
N 1620 1750 1670 1750 {lab=word21}
N 1670 1750 1710 1750 {lab=word21}
N 1540 1680 1540 1760 {lab=A2}
N 1530 1750 1620 1750 {lab=word21}
N 1450 1680 1450 1760 {lab=N_A1}
N 1440 1750 1530 1750 {lab=word21}
N 1400 1720 1410 1720 {lab=GND}
N 1410 1690 1410 1720 {lab=GND}
N 1400 1690 1410 1690 {lab=GND}
N 1360 1680 1360 1720 {lab=A1}
N 1360 1720 1360 1760 {lab=A1}
N 1350 1750 1400 1750 {lab=word21}
N 1400 1750 1440 1750 {lab=word21}
N 1310 1720 1320 1720 {lab=GND}
N 1320 1690 1320 1720 {lab=GND}
N 1310 1690 1320 1690 {lab=GND}
N 1270 1680 1270 1720 {lab=N_A0}
N 1270 1720 1270 1760 {lab=N_A0}
N 1260 1750 1310 1750 {lab=word21}
N 1310 1750 1350 1750 {lab=word21}
N 1180 1680 1180 1760 {lab=A0}
N 1170 1750 1260 1750 {lab=word21}
N 1080 1750 1170 1750 { }
N 1070 1680 1070 1760 {lab=A6}
N 990 1750 1080 1750 {lab=word21}
N 940 1710 980 1710 {lab=N_A7}
N 940 1750 940 1760 {lab=VDD}
N 970 1750 990 1750 {lab=word21}
N 900 1750 910 1750 {lab=#net2113}
N 980 1680 980 1710 {lab=N_A7}
N 980 1710 980 1760 {lab=N_A7}
N 850 1710 890 1710 {lab=A7}
N 850 1750 850 1760 {lab=VDD}
N 880 1750 900 1750 {lab=#net2113}
N 810 1750 820 1750 {lab=#net2115}
N 890 1680 890 1710 {lab=A7}
N 890 1710 890 1760 {lab=A7}
N 800 1680 800 1760 {lab=N_A8}
N 720 1750 810 1750 {lab=#net2115}
N 710 1680 710 1760 {lab=A8}
N 630 1750 720 1750 {lab=#net2115}
N 580 1710 620 1710 {lab=N_A9}
N 580 1750 580 1760 {lab=VDD}
N 610 1750 630 1750 {lab=#net2115}
N 540 1750 550 1750 {lab=#net2117}
N 620 1680 620 1710 {lab=N_A9}
N 620 1710 620 1760 {lab=N_A9}
N 490 1710 530 1710 {lab=A9}
N 490 1750 490 1760 {lab=VDD}
N 520 1750 540 1750 {lab=#net2117}
N 450 1750 460 1750 {lab=#net2119}
N 530 1680 530 1710 {lab=A9}
N 530 1710 530 1760 {lab=A9}
N 440 1680 440 1760 {lab=N_A10}
N 360 1750 450 1750 {lab=#net2119}
N 350 1680 350 1760 {lab=A10}
N 270 1750 360 1750 {lab=#net2119}
N 220 1710 260 1710 {lab=N_A11}
N 220 1750 220 1760 {lab=VDD}
N 250 1750 270 1750 {lab=#net2119}
N 180 1750 190 1750 {lab=#net2121}
N 260 1680 260 1710 {lab=N_A11}
N 260 1710 260 1760 {lab=N_A11}
N 130 1710 170 1710 {lab=A11}
N 130 1750 130 1760 {lab=VDD}
N 160 1750 180 1750 {lab=#net2121}
N 90 1750 100 1750 {lab=#net2123}
N 170 1680 170 1710 {lab=A11}
N 170 1710 170 1760 {lab=A11}
N 80 1680 80 1760 {lab=N_A12}
N 0 1750 90 1750 {lab=#net2123}
N 0 1680 0 1760 { }
N 2170 1760 2170 1840 {lab=N_A5}
N 2160 1830 2250 1830 {lab=word22}
N 2120 1800 2130 1800 {lab=GND}
N 2130 1770 2130 1800 {lab=GND}
N 2120 1770 2130 1770 {lab=GND}
N 2080 1760 2080 1800 {lab=A5}
N 2080 1800 2080 1840 {lab=A5}
N 2070 1830 2120 1830 {lab=word22}
N 2120 1830 2160 1830 {lab=word22}
N 2030 1800 2040 1800 {lab=GND}
N 2040 1770 2040 1800 {lab=GND}
N 2030 1770 2040 1770 {lab=GND}
N 1990 1760 1990 1800 {lab=N_A4}
N 1990 1800 1990 1840 {lab=N_A4}
N 1980 1830 2030 1830 {lab=word22}
N 2030 1830 2070 1830 {lab=word22}
N 1900 1760 1900 1840 {lab=A4}
N 1890 1830 1980 1830 {lab=word22}
N 1810 1760 1810 1840 {lab=N_A3}
N 1800 1830 1890 1830 {lab=word22}
N 1760 1800 1770 1800 {lab=GND}
N 1770 1770 1770 1800 {lab=GND}
N 1760 1770 1770 1770 {lab=GND}
N 1720 1760 1720 1800 {lab=A3}
N 1720 1800 1720 1840 {lab=A3}
N 1710 1830 1760 1830 {lab=word22}
N 1760 1830 1800 1830 {lab=word22}
N 1670 1800 1680 1800 {lab=GND}
N 1680 1770 1680 1800 {lab=GND}
N 1670 1770 1680 1770 {lab=GND}
N 1630 1760 1630 1800 {lab=N_A2}
N 1630 1800 1630 1840 {lab=N_A2}
N 1620 1830 1670 1830 {lab=word22}
N 1670 1830 1710 1830 {lab=word22}
N 1540 1760 1540 1840 {lab=A2}
N 1530 1830 1620 1830 {lab=word22}
N 1490 1800 1500 1800 {lab=GND}
N 1500 1770 1500 1800 {lab=GND}
N 1490 1770 1500 1770 {lab=GND}
N 1450 1760 1450 1800 {lab=N_A1}
N 1450 1800 1450 1840 {lab=N_A1}
N 1440 1830 1490 1830 {lab=word22}
N 1490 1830 1530 1830 {lab=word22}
N 1360 1760 1360 1840 {lab=A1}
N 1350 1830 1440 1830 {lab=word22}
N 1270 1760 1270 1840 {lab=N_A0}
N 1260 1830 1350 1830 {lab=word22}
N 1220 1800 1230 1800 {lab=GND}
N 1230 1770 1230 1800 {lab=GND}
N 1220 1770 1230 1770 {lab=GND}
N 1180 1760 1180 1800 {lab=A0}
N 1180 1800 1180 1840 {lab=A0}
N 1170 1830 1220 1830 {lab=word22}
N 1220 1830 1260 1830 {lab=word22}
N 1080 1830 1170 1830 { }
N 1030 1790 1070 1790 {lab=A6}
N 1030 1830 1030 1840 {lab=VDD}
N 1060 1830 1080 1830 {lab=word22}
N 990 1830 1000 1830 {lab=#net2213}
N 1070 1760 1070 1790 {lab=A6}
N 1070 1790 1070 1840 {lab=A6}
N 980 1760 980 1840 {lab=N_A7}
N 900 1830 990 1830 {lab=#net2213}
N 890 1760 890 1840 {lab=A7}
N 810 1830 900 1830 {lab=#net2213}
N 760 1790 800 1790 {lab=N_A8}
N 760 1830 760 1840 {lab=VDD}
N 790 1830 810 1830 {lab=#net2213}
N 720 1830 730 1830 {lab=#net2215}
N 800 1760 800 1790 {lab=N_A8}
N 800 1790 800 1840 {lab=N_A8}
N 710 1760 710 1840 {lab=A8}
N 630 1830 720 1830 {lab=#net2215}
N 580 1790 620 1790 {lab=N_A9}
N 580 1830 580 1840 {lab=VDD}
N 610 1830 630 1830 {lab=#net2215}
N 540 1830 550 1830 {lab=#net2217}
N 620 1760 620 1790 {lab=N_A9}
N 620 1790 620 1840 {lab=N_A9}
N 490 1790 530 1790 {lab=A9}
N 490 1830 490 1840 {lab=VDD}
N 520 1830 540 1830 {lab=#net2217}
N 450 1830 460 1830 {lab=#net2219}
N 530 1760 530 1790 {lab=A9}
N 530 1790 530 1840 {lab=A9}
N 440 1760 440 1840 {lab=N_A10}
N 360 1830 450 1830 {lab=#net2219}
N 350 1760 350 1840 {lab=A10}
N 270 1830 360 1830 {lab=#net2219}
N 220 1790 260 1790 {lab=N_A11}
N 220 1830 220 1840 {lab=VDD}
N 250 1830 270 1830 {lab=#net2219}
N 180 1830 190 1830 {lab=#net2221}
N 260 1760 260 1790 {lab=N_A11}
N 260 1790 260 1840 {lab=N_A11}
N 130 1790 170 1790 {lab=A11}
N 130 1830 130 1840 {lab=VDD}
N 160 1830 180 1830 {lab=#net2221}
N 90 1830 100 1830 {lab=#net2223}
N 170 1760 170 1790 {lab=A11}
N 170 1790 170 1840 {lab=A11}
N 80 1760 80 1840 {lab=N_A12}
N 0 1830 90 1830 {lab=#net2223}
N 0 1760 0 1840 { }
N 2170 1840 2170 1920 {lab=N_A5}
N 2160 1910 2250 1910 {lab=word23}
N 2120 1880 2130 1880 {lab=GND}
N 2130 1850 2130 1880 {lab=GND}
N 2120 1850 2130 1850 {lab=GND}
N 2080 1840 2080 1880 {lab=A5}
N 2080 1880 2080 1920 {lab=A5}
N 2070 1910 2120 1910 {lab=word23}
N 2120 1910 2160 1910 {lab=word23}
N 2030 1880 2040 1880 {lab=GND}
N 2040 1850 2040 1880 {lab=GND}
N 2030 1850 2040 1850 {lab=GND}
N 1990 1840 1990 1880 {lab=N_A4}
N 1990 1880 1990 1920 {lab=N_A4}
N 1980 1910 2030 1910 {lab=word23}
N 2030 1910 2070 1910 {lab=word23}
N 1900 1840 1900 1920 {lab=A4}
N 1890 1910 1980 1910 {lab=word23}
N 1810 1840 1810 1920 {lab=N_A3}
N 1800 1910 1890 1910 {lab=word23}
N 1760 1880 1770 1880 {lab=GND}
N 1770 1850 1770 1880 {lab=GND}
N 1760 1850 1770 1850 {lab=GND}
N 1720 1840 1720 1880 {lab=A3}
N 1720 1880 1720 1920 {lab=A3}
N 1710 1910 1760 1910 {lab=word23}
N 1760 1910 1800 1910 {lab=word23}
N 1670 1880 1680 1880 {lab=GND}
N 1680 1850 1680 1880 {lab=GND}
N 1670 1850 1680 1850 {lab=GND}
N 1630 1840 1630 1880 {lab=N_A2}
N 1630 1880 1630 1920 {lab=N_A2}
N 1620 1910 1670 1910 {lab=word23}
N 1670 1910 1710 1910 {lab=word23}
N 1540 1840 1540 1920 {lab=A2}
N 1530 1910 1620 1910 {lab=word23}
N 1490 1880 1500 1880 {lab=GND}
N 1500 1850 1500 1880 {lab=GND}
N 1490 1850 1500 1850 {lab=GND}
N 1450 1840 1450 1880 {lab=N_A1}
N 1450 1880 1450 1920 {lab=N_A1}
N 1440 1910 1490 1910 {lab=word23}
N 1490 1910 1530 1910 {lab=word23}
N 1360 1840 1360 1920 {lab=A1}
N 1350 1910 1440 1910 {lab=word23}
N 1310 1880 1320 1880 {lab=GND}
N 1320 1850 1320 1880 {lab=GND}
N 1310 1850 1320 1850 {lab=GND}
N 1270 1840 1270 1880 {lab=N_A0}
N 1270 1880 1270 1920 {lab=N_A0}
N 1260 1910 1310 1910 {lab=word23}
N 1310 1910 1350 1910 {lab=word23}
N 1180 1840 1180 1920 {lab=A0}
N 1170 1910 1260 1910 {lab=word23}
N 1080 1910 1170 1910 { }
N 1070 1840 1070 1920 {lab=A6}
N 990 1910 1080 1910 {lab=word23}
N 940 1870 980 1870 {lab=N_A7}
N 940 1910 940 1920 {lab=VDD}
N 970 1910 990 1910 {lab=word23}
N 900 1910 910 1910 {lab=#net2313}
N 980 1840 980 1870 {lab=N_A7}
N 980 1870 980 1920 {lab=N_A7}
N 890 1840 890 1920 {lab=A7}
N 810 1910 900 1910 {lab=#net2313}
N 760 1870 800 1870 {lab=N_A8}
N 760 1910 760 1920 {lab=VDD}
N 790 1910 810 1910 {lab=#net2313}
N 720 1910 730 1910 {lab=#net2315}
N 800 1840 800 1870 {lab=N_A8}
N 800 1870 800 1920 {lab=N_A8}
N 710 1840 710 1920 {lab=A8}
N 630 1910 720 1910 {lab=#net2315}
N 580 1870 620 1870 {lab=N_A9}
N 580 1910 580 1920 {lab=VDD}
N 610 1910 630 1910 {lab=#net2315}
N 540 1910 550 1910 {lab=#net2317}
N 620 1840 620 1870 {lab=N_A9}
N 620 1870 620 1920 {lab=N_A9}
N 490 1870 530 1870 {lab=A9}
N 490 1910 490 1920 {lab=VDD}
N 520 1910 540 1910 {lab=#net2317}
N 450 1910 460 1910 {lab=#net2319}
N 530 1840 530 1870 {lab=A9}
N 530 1870 530 1920 {lab=A9}
N 440 1840 440 1920 {lab=N_A10}
N 360 1910 450 1910 {lab=#net2319}
N 350 1840 350 1920 {lab=A10}
N 270 1910 360 1910 {lab=#net2319}
N 220 1870 260 1870 {lab=N_A11}
N 220 1910 220 1920 {lab=VDD}
N 250 1910 270 1910 {lab=#net2319}
N 180 1910 190 1910 {lab=#net2321}
N 260 1840 260 1870 {lab=N_A11}
N 260 1870 260 1920 {lab=N_A11}
N 130 1870 170 1870 {lab=A11}
N 130 1910 130 1920 {lab=VDD}
N 160 1910 180 1910 {lab=#net2321}
N 90 1910 100 1910 {lab=#net2323}
N 170 1840 170 1870 {lab=A11}
N 170 1870 170 1920 {lab=A11}
N 80 1840 80 1920 {lab=N_A12}
N 0 1910 90 1910 {lab=#net2323}
N 0 1840 0 1920 { }
N 2170 1920 2170 2000 {lab=N_A5}
N 2160 1990 2250 1990 {lab=word24}
N 2120 1960 2130 1960 {lab=GND}
N 2130 1930 2130 1960 {lab=GND}
N 2120 1930 2130 1930 {lab=GND}
N 2080 1920 2080 1960 {lab=A5}
N 2080 1960 2080 2000 {lab=A5}
N 2070 1990 2120 1990 {lab=word24}
N 2120 1990 2160 1990 {lab=word24}
N 2030 1960 2040 1960 {lab=GND}
N 2040 1930 2040 1960 {lab=GND}
N 2030 1930 2040 1930 {lab=GND}
N 1990 1920 1990 1960 {lab=N_A4}
N 1990 1960 1990 2000 {lab=N_A4}
N 1980 1990 2030 1990 {lab=word24}
N 2030 1990 2070 1990 {lab=word24}
N 1900 1920 1900 2000 {lab=A4}
N 1890 1990 1980 1990 {lab=word24}
N 1850 1960 1860 1960 {lab=GND}
N 1860 1930 1860 1960 {lab=GND}
N 1850 1930 1860 1930 {lab=GND}
N 1810 1920 1810 1960 {lab=N_A3}
N 1810 1960 1810 2000 {lab=N_A3}
N 1800 1990 1850 1990 {lab=word24}
N 1850 1990 1890 1990 {lab=word24}
N 1720 1920 1720 2000 {lab=A3}
N 1710 1990 1800 1990 {lab=word24}
N 1630 1920 1630 2000 {lab=N_A2}
N 1620 1990 1710 1990 {lab=word24}
N 1580 1960 1590 1960 {lab=GND}
N 1590 1930 1590 1960 {lab=GND}
N 1580 1930 1590 1930 {lab=GND}
N 1540 1920 1540 1960 {lab=A2}
N 1540 1960 1540 2000 {lab=A2}
N 1530 1990 1580 1990 {lab=word24}
N 1580 1990 1620 1990 {lab=word24}
N 1450 1920 1450 2000 {lab=N_A1}
N 1440 1990 1530 1990 {lab=word24}
N 1400 1960 1410 1960 {lab=GND}
N 1410 1930 1410 1960 {lab=GND}
N 1400 1930 1410 1930 {lab=GND}
N 1360 1920 1360 1960 {lab=A1}
N 1360 1960 1360 2000 {lab=A1}
N 1350 1990 1400 1990 {lab=word24}
N 1400 1990 1440 1990 {lab=word24}
N 1270 1920 1270 2000 {lab=N_A0}
N 1260 1990 1350 1990 {lab=word24}
N 1220 1960 1230 1960 {lab=GND}
N 1230 1930 1230 1960 {lab=GND}
N 1220 1930 1230 1930 {lab=GND}
N 1180 1920 1180 1960 {lab=A0}
N 1180 1960 1180 2000 {lab=A0}
N 1170 1990 1220 1990 {lab=word24}
N 1220 1990 1260 1990 {lab=word24}
N 1080 1990 1170 1990 { }
N 1030 1950 1070 1950 {lab=A6}
N 1030 1990 1030 2000 {lab=VDD}
N 1060 1990 1080 1990 {lab=word24}
N 990 1990 1000 1990 {lab=#net2413}
N 1070 1920 1070 1950 {lab=A6}
N 1070 1950 1070 2000 {lab=A6}
N 980 1920 980 2000 {lab=N_A7}
N 900 1990 990 1990 {lab=#net2413}
N 850 1950 890 1950 {lab=A7}
N 850 1990 850 2000 {lab=VDD}
N 880 1990 900 1990 {lab=#net2413}
N 810 1990 820 1990 {lab=#net2415}
N 890 1920 890 1950 {lab=A7}
N 890 1950 890 2000 {lab=A7}
N 800 1920 800 2000 {lab=N_A8}
N 720 1990 810 1990 {lab=#net2415}
N 670 1950 710 1950 {lab=A8}
N 670 1990 670 2000 {lab=VDD}
N 700 1990 720 1990 {lab=#net2415}
N 630 1990 640 1990 {lab=#net2417}
N 710 1920 710 1950 {lab=A8}
N 710 1950 710 2000 {lab=A8}
N 620 1920 620 2000 {lab=N_A9}
N 540 1990 630 1990 {lab=#net2417}
N 530 1920 530 2000 {lab=A9}
N 450 1990 540 1990 {lab=#net2417}
N 400 1950 440 1950 {lab=N_A10}
N 400 1990 400 2000 {lab=VDD}
N 430 1990 450 1990 {lab=#net2417}
N 360 1990 370 1990 {lab=#net2419}
N 440 1920 440 1950 {lab=N_A10}
N 440 1950 440 2000 {lab=N_A10}
N 350 1920 350 2000 {lab=A10}
N 270 1990 360 1990 {lab=#net2419}
N 220 1950 260 1950 {lab=N_A11}
N 220 1990 220 2000 {lab=VDD}
N 250 1990 270 1990 {lab=#net2419}
N 180 1990 190 1990 {lab=#net2421}
N 260 1920 260 1950 {lab=N_A11}
N 260 1950 260 2000 {lab=N_A11}
N 130 1950 170 1950 {lab=A11}
N 130 1990 130 2000 {lab=VDD}
N 160 1990 180 1990 {lab=#net2421}
N 90 1990 100 1990 {lab=#net2423}
N 170 1920 170 1950 {lab=A11}
N 170 1950 170 2000 {lab=A11}
N 80 1920 80 2000 {lab=N_A12}
N 0 1990 90 1990 {lab=#net2423}
N 0 1920 0 2000 { }
N 2170 2000 2170 2080 {lab=N_A5}
N 2160 2070 2250 2070 {lab=word25}
N 2120 2040 2130 2040 {lab=GND}
N 2130 2010 2130 2040 {lab=GND}
N 2120 2010 2130 2010 {lab=GND}
N 2080 2000 2080 2040 {lab=A5}
N 2080 2040 2080 2080 {lab=A5}
N 2070 2070 2120 2070 {lab=word25}
N 2120 2070 2160 2070 {lab=word25}
N 2030 2040 2040 2040 {lab=GND}
N 2040 2010 2040 2040 {lab=GND}
N 2030 2010 2040 2010 {lab=GND}
N 1990 2000 1990 2040 {lab=N_A4}
N 1990 2040 1990 2080 {lab=N_A4}
N 1980 2070 2030 2070 {lab=word25}
N 2030 2070 2070 2070 {lab=word25}
N 1900 2000 1900 2080 {lab=A4}
N 1890 2070 1980 2070 {lab=word25}
N 1850 2040 1860 2040 {lab=GND}
N 1860 2010 1860 2040 {lab=GND}
N 1850 2010 1860 2010 {lab=GND}
N 1810 2000 1810 2040 {lab=N_A3}
N 1810 2040 1810 2080 {lab=N_A3}
N 1800 2070 1850 2070 {lab=word25}
N 1850 2070 1890 2070 {lab=word25}
N 1720 2000 1720 2080 {lab=A3}
N 1710 2070 1800 2070 {lab=word25}
N 1630 2000 1630 2080 {lab=N_A2}
N 1620 2070 1710 2070 {lab=word25}
N 1580 2040 1590 2040 {lab=GND}
N 1590 2010 1590 2040 {lab=GND}
N 1580 2010 1590 2010 {lab=GND}
N 1540 2000 1540 2040 {lab=A2}
N 1540 2040 1540 2080 {lab=A2}
N 1530 2070 1580 2070 {lab=word25}
N 1580 2070 1620 2070 {lab=word25}
N 1450 2000 1450 2080 {lab=N_A1}
N 1440 2070 1530 2070 {lab=word25}
N 1400 2040 1410 2040 {lab=GND}
N 1410 2010 1410 2040 {lab=GND}
N 1400 2010 1410 2010 {lab=GND}
N 1360 2000 1360 2040 {lab=A1}
N 1360 2040 1360 2080 {lab=A1}
N 1350 2070 1400 2070 {lab=word25}
N 1400 2070 1440 2070 {lab=word25}
N 1310 2040 1320 2040 {lab=GND}
N 1320 2010 1320 2040 {lab=GND}
N 1310 2010 1320 2010 {lab=GND}
N 1270 2000 1270 2040 {lab=N_A0}
N 1270 2040 1270 2080 {lab=N_A0}
N 1260 2070 1310 2070 {lab=word25}
N 1310 2070 1350 2070 {lab=word25}
N 1180 2000 1180 2080 {lab=A0}
N 1170 2070 1260 2070 {lab=word25}
N 1080 2070 1170 2070 { }
N 1070 2000 1070 2080 {lab=A6}
N 990 2070 1080 2070 {lab=word25}
N 940 2030 980 2030 {lab=N_A7}
N 940 2070 940 2080 {lab=VDD}
N 970 2070 990 2070 {lab=word25}
N 900 2070 910 2070 {lab=#net2513}
N 980 2000 980 2030 {lab=N_A7}
N 980 2030 980 2080 {lab=N_A7}
N 850 2030 890 2030 {lab=A7}
N 850 2070 850 2080 {lab=VDD}
N 880 2070 900 2070 {lab=#net2513}
N 810 2070 820 2070 {lab=#net2515}
N 890 2000 890 2030 {lab=A7}
N 890 2030 890 2080 {lab=A7}
N 800 2000 800 2080 {lab=N_A8}
N 720 2070 810 2070 {lab=#net2515}
N 670 2030 710 2030 {lab=A8}
N 670 2070 670 2080 {lab=VDD}
N 700 2070 720 2070 {lab=#net2515}
N 630 2070 640 2070 {lab=#net2517}
N 710 2000 710 2030 {lab=A8}
N 710 2030 710 2080 {lab=A8}
N 620 2000 620 2080 {lab=N_A9}
N 540 2070 630 2070 {lab=#net2517}
N 530 2000 530 2080 {lab=A9}
N 450 2070 540 2070 {lab=#net2517}
N 400 2030 440 2030 {lab=N_A10}
N 400 2070 400 2080 {lab=VDD}
N 430 2070 450 2070 {lab=#net2517}
N 360 2070 370 2070 {lab=#net2519}
N 440 2000 440 2030 {lab=N_A10}
N 440 2030 440 2080 {lab=N_A10}
N 350 2000 350 2080 {lab=A10}
N 270 2070 360 2070 {lab=#net2519}
N 220 2030 260 2030 {lab=N_A11}
N 220 2070 220 2080 {lab=VDD}
N 250 2070 270 2070 {lab=#net2519}
N 180 2070 190 2070 {lab=#net2521}
N 260 2000 260 2030 {lab=N_A11}
N 260 2030 260 2080 {lab=N_A11}
N 130 2030 170 2030 {lab=A11}
N 130 2070 130 2080 {lab=VDD}
N 160 2070 180 2070 {lab=#net2521}
N 90 2070 100 2070 {lab=#net2523}
N 170 2000 170 2030 {lab=A11}
N 170 2030 170 2080 {lab=A11}
N 80 2000 80 2080 {lab=N_A12}
N 0 2070 90 2070 {lab=#net2523}
N 0 2000 0 2080 { }
N 2170 2080 2170 2160 {lab=N_A5}
N 2160 2150 2250 2150 {lab=word26}
N 2120 2120 2130 2120 {lab=GND}
N 2130 2090 2130 2120 {lab=GND}
N 2120 2090 2130 2090 {lab=GND}
N 2080 2080 2080 2120 {lab=A5}
N 2080 2120 2080 2160 {lab=A5}
N 2070 2150 2120 2150 {lab=word26}
N 2120 2150 2160 2150 {lab=word26}
N 2030 2120 2040 2120 {lab=GND}
N 2040 2090 2040 2120 {lab=GND}
N 2030 2090 2040 2090 {lab=GND}
N 1990 2080 1990 2120 {lab=N_A4}
N 1990 2120 1990 2160 {lab=N_A4}
N 1980 2150 2030 2150 {lab=word26}
N 2030 2150 2070 2150 {lab=word26}
N 1900 2080 1900 2160 {lab=A4}
N 1890 2150 1980 2150 {lab=word26}
N 1850 2120 1860 2120 {lab=GND}
N 1860 2090 1860 2120 {lab=GND}
N 1850 2090 1860 2090 {lab=GND}
N 1810 2080 1810 2120 {lab=N_A3}
N 1810 2120 1810 2160 {lab=N_A3}
N 1800 2150 1850 2150 {lab=word26}
N 1850 2150 1890 2150 {lab=word26}
N 1720 2080 1720 2160 {lab=A3}
N 1710 2150 1800 2150 {lab=word26}
N 1630 2080 1630 2160 {lab=N_A2}
N 1620 2150 1710 2150 {lab=word26}
N 1580 2120 1590 2120 {lab=GND}
N 1590 2090 1590 2120 {lab=GND}
N 1580 2090 1590 2090 {lab=GND}
N 1540 2080 1540 2120 {lab=A2}
N 1540 2120 1540 2160 {lab=A2}
N 1530 2150 1580 2150 {lab=word26}
N 1580 2150 1620 2150 {lab=word26}
N 1490 2120 1500 2120 {lab=GND}
N 1500 2090 1500 2120 {lab=GND}
N 1490 2090 1500 2090 {lab=GND}
N 1450 2080 1450 2120 {lab=N_A1}
N 1450 2120 1450 2160 {lab=N_A1}
N 1440 2150 1490 2150 {lab=word26}
N 1490 2150 1530 2150 {lab=word26}
N 1360 2080 1360 2160 {lab=A1}
N 1350 2150 1440 2150 {lab=word26}
N 1270 2080 1270 2160 {lab=N_A0}
N 1260 2150 1350 2150 {lab=word26}
N 1220 2120 1230 2120 {lab=GND}
N 1230 2090 1230 2120 {lab=GND}
N 1220 2090 1230 2090 {lab=GND}
N 1180 2080 1180 2120 {lab=A0}
N 1180 2120 1180 2160 {lab=A0}
N 1170 2150 1220 2150 {lab=word26}
N 1220 2150 1260 2150 {lab=word26}
N 1080 2150 1170 2150 { }
N 1030 2110 1070 2110 {lab=A6}
N 1030 2150 1030 2160 {lab=VDD}
N 1060 2150 1080 2150 {lab=word26}
N 990 2150 1000 2150 {lab=#net2613}
N 1070 2080 1070 2110 {lab=A6}
N 1070 2110 1070 2160 {lab=A6}
N 980 2080 980 2160 {lab=N_A7}
N 900 2150 990 2150 {lab=#net2613}
N 890 2080 890 2160 {lab=A7}
N 810 2150 900 2150 {lab=#net2613}
N 760 2110 800 2110 {lab=N_A8}
N 760 2150 760 2160 {lab=VDD}
N 790 2150 810 2150 {lab=#net2613}
N 720 2150 730 2150 {lab=#net2615}
N 800 2080 800 2110 {lab=N_A8}
N 800 2110 800 2160 {lab=N_A8}
N 670 2110 710 2110 {lab=A8}
N 670 2150 670 2160 {lab=VDD}
N 700 2150 720 2150 {lab=#net2615}
N 630 2150 640 2150 {lab=#net2617}
N 710 2080 710 2110 {lab=A8}
N 710 2110 710 2160 {lab=A8}
N 620 2080 620 2160 {lab=N_A9}
N 540 2150 630 2150 {lab=#net2617}
N 530 2080 530 2160 {lab=A9}
N 450 2150 540 2150 {lab=#net2617}
N 400 2110 440 2110 {lab=N_A10}
N 400 2150 400 2160 {lab=VDD}
N 430 2150 450 2150 {lab=#net2617}
N 360 2150 370 2150 {lab=#net2619}
N 440 2080 440 2110 {lab=N_A10}
N 440 2110 440 2160 {lab=N_A10}
N 350 2080 350 2160 {lab=A10}
N 270 2150 360 2150 {lab=#net2619}
N 220 2110 260 2110 {lab=N_A11}
N 220 2150 220 2160 {lab=VDD}
N 250 2150 270 2150 {lab=#net2619}
N 180 2150 190 2150 {lab=#net2621}
N 260 2080 260 2110 {lab=N_A11}
N 260 2110 260 2160 {lab=N_A11}
N 130 2110 170 2110 {lab=A11}
N 130 2150 130 2160 {lab=VDD}
N 160 2150 180 2150 {lab=#net2621}
N 90 2150 100 2150 {lab=#net2623}
N 170 2080 170 2110 {lab=A11}
N 170 2110 170 2160 {lab=A11}
N 80 2080 80 2160 {lab=N_A12}
N 0 2150 90 2150 {lab=#net2623}
N 0 2080 0 2160 { }
N 2170 2160 2170 2240 {lab=N_A5}
N 2160 2230 2250 2230 {lab=word27}
N 2120 2200 2130 2200 {lab=GND}
N 2130 2170 2130 2200 {lab=GND}
N 2120 2170 2130 2170 {lab=GND}
N 2080 2160 2080 2200 {lab=A5}
N 2080 2200 2080 2240 {lab=A5}
N 2070 2230 2120 2230 {lab=word27}
N 2120 2230 2160 2230 {lab=word27}
N 2030 2200 2040 2200 {lab=GND}
N 2040 2170 2040 2200 {lab=GND}
N 2030 2170 2040 2170 {lab=GND}
N 1990 2160 1990 2200 {lab=N_A4}
N 1990 2200 1990 2240 {lab=N_A4}
N 1980 2230 2030 2230 {lab=word27}
N 2030 2230 2070 2230 {lab=word27}
N 1900 2160 1900 2240 {lab=A4}
N 1890 2230 1980 2230 {lab=word27}
N 1850 2200 1860 2200 {lab=GND}
N 1860 2170 1860 2200 {lab=GND}
N 1850 2170 1860 2170 {lab=GND}
N 1810 2160 1810 2200 {lab=N_A3}
N 1810 2200 1810 2240 {lab=N_A3}
N 1800 2230 1850 2230 {lab=word27}
N 1850 2230 1890 2230 {lab=word27}
N 1720 2160 1720 2240 {lab=A3}
N 1710 2230 1800 2230 {lab=word27}
N 1630 2160 1630 2240 {lab=N_A2}
N 1620 2230 1710 2230 {lab=word27}
N 1580 2200 1590 2200 {lab=GND}
N 1590 2170 1590 2200 {lab=GND}
N 1580 2170 1590 2170 {lab=GND}
N 1540 2160 1540 2200 {lab=A2}
N 1540 2200 1540 2240 {lab=A2}
N 1530 2230 1580 2230 {lab=word27}
N 1580 2230 1620 2230 {lab=word27}
N 1490 2200 1500 2200 {lab=GND}
N 1500 2170 1500 2200 {lab=GND}
N 1490 2170 1500 2170 {lab=GND}
N 1450 2160 1450 2200 {lab=N_A1}
N 1450 2200 1450 2240 {lab=N_A1}
N 1440 2230 1490 2230 {lab=word27}
N 1490 2230 1530 2230 {lab=word27}
N 1360 2160 1360 2240 {lab=A1}
N 1350 2230 1440 2230 {lab=word27}
N 1310 2200 1320 2200 {lab=GND}
N 1320 2170 1320 2200 {lab=GND}
N 1310 2170 1320 2170 {lab=GND}
N 1270 2160 1270 2200 {lab=N_A0}
N 1270 2200 1270 2240 {lab=N_A0}
N 1260 2230 1310 2230 {lab=word27}
N 1310 2230 1350 2230 {lab=word27}
N 1180 2160 1180 2240 {lab=A0}
N 1170 2230 1260 2230 {lab=word27}
N 1080 2230 1170 2230 { }
N 1070 2160 1070 2240 {lab=A6}
N 990 2230 1080 2230 {lab=word27}
N 940 2190 980 2190 {lab=N_A7}
N 940 2230 940 2240 {lab=VDD}
N 970 2230 990 2230 {lab=word27}
N 900 2230 910 2230 {lab=#net2713}
N 980 2160 980 2190 {lab=N_A7}
N 980 2190 980 2240 {lab=N_A7}
N 890 2160 890 2240 {lab=A7}
N 810 2230 900 2230 {lab=#net2713}
N 760 2190 800 2190 {lab=N_A8}
N 760 2230 760 2240 {lab=VDD}
N 790 2230 810 2230 {lab=#net2713}
N 720 2230 730 2230 {lab=#net2715}
N 800 2160 800 2190 {lab=N_A8}
N 800 2190 800 2240 {lab=N_A8}
N 670 2190 710 2190 {lab=A8}
N 670 2230 670 2240 {lab=VDD}
N 700 2230 720 2230 {lab=#net2715}
N 630 2230 640 2230 {lab=#net2717}
N 710 2160 710 2190 {lab=A8}
N 710 2190 710 2240 {lab=A8}
N 620 2160 620 2240 {lab=N_A9}
N 540 2230 630 2230 {lab=#net2717}
N 530 2160 530 2240 {lab=A9}
N 450 2230 540 2230 {lab=#net2717}
N 400 2190 440 2190 {lab=N_A10}
N 400 2230 400 2240 {lab=VDD}
N 430 2230 450 2230 {lab=#net2717}
N 360 2230 370 2230 {lab=#net2719}
N 440 2160 440 2190 {lab=N_A10}
N 440 2190 440 2240 {lab=N_A10}
N 350 2160 350 2240 {lab=A10}
N 270 2230 360 2230 {lab=#net2719}
N 220 2190 260 2190 {lab=N_A11}
N 220 2230 220 2240 {lab=VDD}
N 250 2230 270 2230 {lab=#net2719}
N 180 2230 190 2230 {lab=#net2721}
N 260 2160 260 2190 {lab=N_A11}
N 260 2190 260 2240 {lab=N_A11}
N 130 2190 170 2190 {lab=A11}
N 130 2230 130 2240 {lab=VDD}
N 160 2230 180 2230 {lab=#net2721}
N 90 2230 100 2230 {lab=#net2723}
N 170 2160 170 2190 {lab=A11}
N 170 2190 170 2240 {lab=A11}
N 80 2160 80 2240 {lab=N_A12}
N 0 2230 90 2230 {lab=#net2723}
N 0 2160 0 2240 { }
N 2170 2240 2170 2320 {lab=N_A5}
N 2160 2310 2250 2310 {lab=word28}
N 2120 2280 2130 2280 {lab=GND}
N 2130 2250 2130 2280 {lab=GND}
N 2120 2250 2130 2250 {lab=GND}
N 2080 2240 2080 2280 {lab=A5}
N 2080 2280 2080 2320 {lab=A5}
N 2070 2310 2120 2310 {lab=word28}
N 2120 2310 2160 2310 {lab=word28}
N 2030 2280 2040 2280 {lab=GND}
N 2040 2250 2040 2280 {lab=GND}
N 2030 2250 2040 2250 {lab=GND}
N 1990 2240 1990 2280 {lab=N_A4}
N 1990 2280 1990 2320 {lab=N_A4}
N 1980 2310 2030 2310 {lab=word28}
N 2030 2310 2070 2310 {lab=word28}
N 1900 2240 1900 2320 {lab=A4}
N 1890 2310 1980 2310 {lab=word28}
N 1850 2280 1860 2280 {lab=GND}
N 1860 2250 1860 2280 {lab=GND}
N 1850 2250 1860 2250 {lab=GND}
N 1810 2240 1810 2280 {lab=N_A3}
N 1810 2280 1810 2320 {lab=N_A3}
N 1800 2310 1850 2310 {lab=word28}
N 1850 2310 1890 2310 {lab=word28}
N 1720 2240 1720 2320 {lab=A3}
N 1710 2310 1800 2310 {lab=word28}
N 1670 2280 1680 2280 {lab=GND}
N 1680 2250 1680 2280 {lab=GND}
N 1670 2250 1680 2250 {lab=GND}
N 1630 2240 1630 2280 {lab=N_A2}
N 1630 2280 1630 2320 {lab=N_A2}
N 1620 2310 1670 2310 {lab=word28}
N 1670 2310 1710 2310 {lab=word28}
N 1540 2240 1540 2320 {lab=A2}
N 1530 2310 1620 2310 {lab=word28}
N 1450 2240 1450 2320 {lab=N_A1}
N 1440 2310 1530 2310 {lab=word28}
N 1400 2280 1410 2280 {lab=GND}
N 1410 2250 1410 2280 {lab=GND}
N 1400 2250 1410 2250 {lab=GND}
N 1360 2240 1360 2280 {lab=A1}
N 1360 2280 1360 2320 {lab=A1}
N 1350 2310 1400 2310 {lab=word28}
N 1400 2310 1440 2310 {lab=word28}
N 1270 2240 1270 2320 {lab=N_A0}
N 1260 2310 1350 2310 {lab=word28}
N 1220 2280 1230 2280 {lab=GND}
N 1230 2250 1230 2280 {lab=GND}
N 1220 2250 1230 2250 {lab=GND}
N 1180 2240 1180 2280 {lab=A0}
N 1180 2280 1180 2320 {lab=A0}
N 1170 2310 1220 2310 {lab=word28}
N 1220 2310 1260 2310 {lab=word28}
N 1080 2310 1170 2310 { }
N 1030 2270 1070 2270 {lab=A6}
N 1030 2310 1030 2320 {lab=VDD}
N 1060 2310 1080 2310 {lab=word28}
N 990 2310 1000 2310 {lab=#net2813}
N 1070 2240 1070 2270 {lab=A6}
N 1070 2270 1070 2320 {lab=A6}
N 980 2240 980 2320 {lab=N_A7}
N 900 2310 990 2310 {lab=#net2813}
N 850 2270 890 2270 {lab=A7}
N 850 2310 850 2320 {lab=VDD}
N 880 2310 900 2310 {lab=#net2813}
N 810 2310 820 2310 {lab=#net2815}
N 890 2240 890 2270 {lab=A7}
N 890 2270 890 2320 {lab=A7}
N 800 2240 800 2320 {lab=N_A8}
N 720 2310 810 2310 {lab=#net2815}
N 710 2240 710 2320 {lab=A8}
N 630 2310 720 2310 {lab=#net2815}
N 580 2270 620 2270 {lab=N_A9}
N 580 2310 580 2320 {lab=VDD}
N 610 2310 630 2310 {lab=#net2815}
N 540 2310 550 2310 {lab=#net2817}
N 620 2240 620 2270 {lab=N_A9}
N 620 2270 620 2320 {lab=N_A9}
N 530 2240 530 2320 {lab=A9}
N 450 2310 540 2310 {lab=#net2817}
N 400 2270 440 2270 {lab=N_A10}
N 400 2310 400 2320 {lab=VDD}
N 430 2310 450 2310 {lab=#net2817}
N 360 2310 370 2310 {lab=#net2819}
N 440 2240 440 2270 {lab=N_A10}
N 440 2270 440 2320 {lab=N_A10}
N 350 2240 350 2320 {lab=A10}
N 270 2310 360 2310 {lab=#net2819}
N 220 2270 260 2270 {lab=N_A11}
N 220 2310 220 2320 {lab=VDD}
N 250 2310 270 2310 {lab=#net2819}
N 180 2310 190 2310 {lab=#net2821}
N 260 2240 260 2270 {lab=N_A11}
N 260 2270 260 2320 {lab=N_A11}
N 130 2270 170 2270 {lab=A11}
N 130 2310 130 2320 {lab=VDD}
N 160 2310 180 2310 {lab=#net2821}
N 90 2310 100 2310 {lab=#net2823}
N 170 2240 170 2270 {lab=A11}
N 170 2270 170 2320 {lab=A11}
N 80 2240 80 2320 {lab=N_A12}
N 0 2310 90 2310 {lab=#net2823}
N 0 2240 0 2320 { }
N 2170 2320 2170 2400 {lab=N_A5}
N 2160 2390 2250 2390 {lab=word29}
N 2120 2360 2130 2360 {lab=GND}
N 2130 2330 2130 2360 {lab=GND}
N 2120 2330 2130 2330 {lab=GND}
N 2080 2320 2080 2360 {lab=A5}
N 2080 2360 2080 2400 {lab=A5}
N 2070 2390 2120 2390 {lab=word29}
N 2120 2390 2160 2390 {lab=word29}
N 2030 2360 2040 2360 {lab=GND}
N 2040 2330 2040 2360 {lab=GND}
N 2030 2330 2040 2330 {lab=GND}
N 1990 2320 1990 2360 {lab=N_A4}
N 1990 2360 1990 2400 {lab=N_A4}
N 1980 2390 2030 2390 {lab=word29}
N 2030 2390 2070 2390 {lab=word29}
N 1900 2320 1900 2400 {lab=A4}
N 1890 2390 1980 2390 {lab=word29}
N 1850 2360 1860 2360 {lab=GND}
N 1860 2330 1860 2360 {lab=GND}
N 1850 2330 1860 2330 {lab=GND}
N 1810 2320 1810 2360 {lab=N_A3}
N 1810 2360 1810 2400 {lab=N_A3}
N 1800 2390 1850 2390 {lab=word29}
N 1850 2390 1890 2390 {lab=word29}
N 1720 2320 1720 2400 {lab=A3}
N 1710 2390 1800 2390 {lab=word29}
N 1670 2360 1680 2360 {lab=GND}
N 1680 2330 1680 2360 {lab=GND}
N 1670 2330 1680 2330 {lab=GND}
N 1630 2320 1630 2360 {lab=N_A2}
N 1630 2360 1630 2400 {lab=N_A2}
N 1620 2390 1670 2390 {lab=word29}
N 1670 2390 1710 2390 {lab=word29}
N 1540 2320 1540 2400 {lab=A2}
N 1530 2390 1620 2390 {lab=word29}
N 1450 2320 1450 2400 {lab=N_A1}
N 1440 2390 1530 2390 {lab=word29}
N 1400 2360 1410 2360 {lab=GND}
N 1410 2330 1410 2360 {lab=GND}
N 1400 2330 1410 2330 {lab=GND}
N 1360 2320 1360 2360 {lab=A1}
N 1360 2360 1360 2400 {lab=A1}
N 1350 2390 1400 2390 {lab=word29}
N 1400 2390 1440 2390 {lab=word29}
N 1310 2360 1320 2360 {lab=GND}
N 1320 2330 1320 2360 {lab=GND}
N 1310 2330 1320 2330 {lab=GND}
N 1270 2320 1270 2360 {lab=N_A0}
N 1270 2360 1270 2400 {lab=N_A0}
N 1260 2390 1310 2390 {lab=word29}
N 1310 2390 1350 2390 {lab=word29}
N 1180 2320 1180 2400 {lab=A0}
N 1170 2390 1260 2390 {lab=word29}
N 1080 2390 1170 2390 { }
N 1070 2320 1070 2400 {lab=A6}
N 990 2390 1080 2390 {lab=word29}
N 940 2350 980 2350 {lab=N_A7}
N 940 2390 940 2400 {lab=VDD}
N 970 2390 990 2390 {lab=word29}
N 900 2390 910 2390 {lab=#net2913}
N 980 2320 980 2350 {lab=N_A7}
N 980 2350 980 2400 {lab=N_A7}
N 850 2350 890 2350 {lab=A7}
N 850 2390 850 2400 {lab=VDD}
N 880 2390 900 2390 {lab=#net2913}
N 810 2390 820 2390 {lab=#net2915}
N 890 2320 890 2350 {lab=A7}
N 890 2350 890 2400 {lab=A7}
N 800 2320 800 2400 {lab=N_A8}
N 720 2390 810 2390 {lab=#net2915}
N 710 2320 710 2400 {lab=A8}
N 630 2390 720 2390 {lab=#net2915}
N 580 2350 620 2350 {lab=N_A9}
N 580 2390 580 2400 {lab=VDD}
N 610 2390 630 2390 {lab=#net2915}
N 540 2390 550 2390 {lab=#net2917}
N 620 2320 620 2350 {lab=N_A9}
N 620 2350 620 2400 {lab=N_A9}
N 530 2320 530 2400 {lab=A9}
N 450 2390 540 2390 {lab=#net2917}
N 400 2350 440 2350 {lab=N_A10}
N 400 2390 400 2400 {lab=VDD}
N 430 2390 450 2390 {lab=#net2917}
N 360 2390 370 2390 {lab=#net2919}
N 440 2320 440 2350 {lab=N_A10}
N 440 2350 440 2400 {lab=N_A10}
N 350 2320 350 2400 {lab=A10}
N 270 2390 360 2390 {lab=#net2919}
N 220 2350 260 2350 {lab=N_A11}
N 220 2390 220 2400 {lab=VDD}
N 250 2390 270 2390 {lab=#net2919}
N 180 2390 190 2390 {lab=#net2921}
N 260 2320 260 2350 {lab=N_A11}
N 260 2350 260 2400 {lab=N_A11}
N 130 2350 170 2350 {lab=A11}
N 130 2390 130 2400 {lab=VDD}
N 160 2390 180 2390 {lab=#net2921}
N 90 2390 100 2390 {lab=#net2923}
N 170 2320 170 2350 {lab=A11}
N 170 2350 170 2400 {lab=A11}
N 80 2320 80 2400 {lab=N_A12}
N 0 2390 90 2390 {lab=#net2923}
N 0 2320 0 2400 { }
N 2170 2400 2170 2480 {lab=N_A5}
N 2160 2470 2250 2470 {lab=word30}
N 2120 2440 2130 2440 {lab=GND}
N 2130 2410 2130 2440 {lab=GND}
N 2120 2410 2130 2410 {lab=GND}
N 2080 2400 2080 2440 {lab=A5}
N 2080 2440 2080 2480 {lab=A5}
N 2070 2470 2120 2470 {lab=word30}
N 2120 2470 2160 2470 {lab=word30}
N 2030 2440 2040 2440 {lab=GND}
N 2040 2410 2040 2440 {lab=GND}
N 2030 2410 2040 2410 {lab=GND}
N 1990 2400 1990 2440 {lab=N_A4}
N 1990 2440 1990 2480 {lab=N_A4}
N 1980 2470 2030 2470 {lab=word30}
N 2030 2470 2070 2470 {lab=word30}
N 1900 2400 1900 2480 {lab=A4}
N 1890 2470 1980 2470 {lab=word30}
N 1850 2440 1860 2440 {lab=GND}
N 1860 2410 1860 2440 {lab=GND}
N 1850 2410 1860 2410 {lab=GND}
N 1810 2400 1810 2440 {lab=N_A3}
N 1810 2440 1810 2480 {lab=N_A3}
N 1800 2470 1850 2470 {lab=word30}
N 1850 2470 1890 2470 {lab=word30}
N 1720 2400 1720 2480 {lab=A3}
N 1710 2470 1800 2470 {lab=word30}
N 1670 2440 1680 2440 {lab=GND}
N 1680 2410 1680 2440 {lab=GND}
N 1670 2410 1680 2410 {lab=GND}
N 1630 2400 1630 2440 {lab=N_A2}
N 1630 2440 1630 2480 {lab=N_A2}
N 1620 2470 1670 2470 {lab=word30}
N 1670 2470 1710 2470 {lab=word30}
N 1540 2400 1540 2480 {lab=A2}
N 1530 2470 1620 2470 {lab=word30}
N 1490 2440 1500 2440 {lab=GND}
N 1500 2410 1500 2440 {lab=GND}
N 1490 2410 1500 2410 {lab=GND}
N 1450 2400 1450 2440 {lab=N_A1}
N 1450 2440 1450 2480 {lab=N_A1}
N 1440 2470 1490 2470 {lab=word30}
N 1490 2470 1530 2470 {lab=word30}
N 1360 2400 1360 2480 {lab=A1}
N 1350 2470 1440 2470 {lab=word30}
N 1270 2400 1270 2480 {lab=N_A0}
N 1260 2470 1350 2470 {lab=word30}
N 1220 2440 1230 2440 {lab=GND}
N 1230 2410 1230 2440 {lab=GND}
N 1220 2410 1230 2410 {lab=GND}
N 1180 2400 1180 2440 {lab=A0}
N 1180 2440 1180 2480 {lab=A0}
N 1170 2470 1220 2470 {lab=word30}
N 1220 2470 1260 2470 {lab=word30}
N 1080 2470 1170 2470 { }
N 1030 2430 1070 2430 {lab=A6}
N 1030 2470 1030 2480 {lab=VDD}
N 1060 2470 1080 2470 {lab=word30}
N 990 2470 1000 2470 {lab=#net3013}
N 1070 2400 1070 2430 {lab=A6}
N 1070 2430 1070 2480 {lab=A6}
N 980 2400 980 2480 {lab=N_A7}
N 900 2470 990 2470 {lab=#net3013}
N 890 2400 890 2480 {lab=A7}
N 810 2470 900 2470 {lab=#net3013}
N 760 2430 800 2430 {lab=N_A8}
N 760 2470 760 2480 {lab=VDD}
N 790 2470 810 2470 {lab=#net3013}
N 720 2470 730 2470 {lab=#net3015}
N 800 2400 800 2430 {lab=N_A8}
N 800 2430 800 2480 {lab=N_A8}
N 710 2400 710 2480 {lab=A8}
N 630 2470 720 2470 {lab=#net3015}
N 580 2430 620 2430 {lab=N_A9}
N 580 2470 580 2480 {lab=VDD}
N 610 2470 630 2470 {lab=#net3015}
N 540 2470 550 2470 {lab=#net3017}
N 620 2400 620 2430 {lab=N_A9}
N 620 2430 620 2480 {lab=N_A9}
N 530 2400 530 2480 {lab=A9}
N 450 2470 540 2470 {lab=#net3017}
N 400 2430 440 2430 {lab=N_A10}
N 400 2470 400 2480 {lab=VDD}
N 430 2470 450 2470 {lab=#net3017}
N 360 2470 370 2470 {lab=#net3019}
N 440 2400 440 2430 {lab=N_A10}
N 440 2430 440 2480 {lab=N_A10}
N 350 2400 350 2480 {lab=A10}
N 270 2470 360 2470 {lab=#net3019}
N 220 2430 260 2430 {lab=N_A11}
N 220 2470 220 2480 {lab=VDD}
N 250 2470 270 2470 {lab=#net3019}
N 180 2470 190 2470 {lab=#net3021}
N 260 2400 260 2430 {lab=N_A11}
N 260 2430 260 2480 {lab=N_A11}
N 130 2430 170 2430 {lab=A11}
N 130 2470 130 2480 {lab=VDD}
N 160 2470 180 2470 {lab=#net3021}
N 90 2470 100 2470 {lab=#net3023}
N 170 2400 170 2430 {lab=A11}
N 170 2430 170 2480 {lab=A11}
N 80 2400 80 2480 {lab=N_A12}
N 0 2470 90 2470 {lab=#net3023}
N 0 2400 0 2480 { }
N 2170 2480 2170 2560 {lab=N_A5}
N 2160 2550 2250 2550 {lab=word31}
N 2120 2520 2130 2520 {lab=GND}
N 2130 2490 2130 2520 {lab=GND}
N 2120 2490 2130 2490 {lab=GND}
N 2080 2480 2080 2520 {lab=A5}
N 2080 2520 2080 2560 {lab=A5}
N 2070 2550 2120 2550 {lab=word31}
N 2120 2550 2160 2550 {lab=word31}
N 2030 2520 2040 2520 {lab=GND}
N 2040 2490 2040 2520 {lab=GND}
N 2030 2490 2040 2490 {lab=GND}
N 1990 2480 1990 2520 {lab=N_A4}
N 1990 2520 1990 2560 {lab=N_A4}
N 1980 2550 2030 2550 {lab=word31}
N 2030 2550 2070 2550 {lab=word31}
N 1900 2480 1900 2560 {lab=A4}
N 1890 2550 1980 2550 {lab=word31}
N 1850 2520 1860 2520 {lab=GND}
N 1860 2490 1860 2520 {lab=GND}
N 1850 2490 1860 2490 {lab=GND}
N 1810 2480 1810 2520 {lab=N_A3}
N 1810 2520 1810 2560 {lab=N_A3}
N 1800 2550 1850 2550 {lab=word31}
N 1850 2550 1890 2550 {lab=word31}
N 1720 2480 1720 2560 {lab=A3}
N 1710 2550 1800 2550 {lab=word31}
N 1670 2520 1680 2520 {lab=GND}
N 1680 2490 1680 2520 {lab=GND}
N 1670 2490 1680 2490 {lab=GND}
N 1630 2480 1630 2520 {lab=N_A2}
N 1630 2520 1630 2560 {lab=N_A2}
N 1620 2550 1670 2550 {lab=word31}
N 1670 2550 1710 2550 {lab=word31}
N 1540 2480 1540 2560 {lab=A2}
N 1530 2550 1620 2550 {lab=word31}
N 1490 2520 1500 2520 {lab=GND}
N 1500 2490 1500 2520 {lab=GND}
N 1490 2490 1500 2490 {lab=GND}
N 1450 2480 1450 2520 {lab=N_A1}
N 1450 2520 1450 2560 {lab=N_A1}
N 1440 2550 1490 2550 {lab=word31}
N 1490 2550 1530 2550 {lab=word31}
N 1360 2480 1360 2560 {lab=A1}
N 1350 2550 1440 2550 {lab=word31}
N 1310 2520 1320 2520 {lab=GND}
N 1320 2490 1320 2520 {lab=GND}
N 1310 2490 1320 2490 {lab=GND}
N 1270 2480 1270 2520 {lab=N_A0}
N 1270 2520 1270 2560 {lab=N_A0}
N 1260 2550 1310 2550 {lab=word31}
N 1310 2550 1350 2550 {lab=word31}
N 1180 2480 1180 2560 {lab=A0}
N 1170 2550 1260 2550 {lab=word31}
N 1080 2550 1170 2550 { }
N 1070 2480 1070 2560 {lab=A6}
N 990 2550 1080 2550 {lab=word31}
N 940 2510 980 2510 {lab=N_A7}
N 940 2550 940 2560 {lab=VDD}
N 970 2550 990 2550 {lab=word31}
N 900 2550 910 2550 {lab=#net3113}
N 980 2480 980 2510 {lab=N_A7}
N 980 2510 980 2560 {lab=N_A7}
N 890 2480 890 2560 {lab=A7}
N 810 2550 900 2550 {lab=#net3113}
N 760 2510 800 2510 {lab=N_A8}
N 760 2550 760 2560 {lab=VDD}
N 790 2550 810 2550 {lab=#net3113}
N 720 2550 730 2550 {lab=#net3115}
N 800 2480 800 2510 {lab=N_A8}
N 800 2510 800 2560 {lab=N_A8}
N 710 2480 710 2560 {lab=A8}
N 630 2550 720 2550 {lab=#net3115}
N 580 2510 620 2510 {lab=N_A9}
N 580 2550 580 2560 {lab=VDD}
N 610 2550 630 2550 {lab=#net3115}
N 540 2550 550 2550 {lab=#net3117}
N 620 2480 620 2510 {lab=N_A9}
N 620 2510 620 2560 {lab=N_A9}
N 530 2480 530 2560 {lab=A9}
N 450 2550 540 2550 {lab=#net3117}
N 400 2510 440 2510 {lab=N_A10}
N 400 2550 400 2560 {lab=VDD}
N 430 2550 450 2550 {lab=#net3117}
N 360 2550 370 2550 {lab=#net3119}
N 440 2480 440 2510 {lab=N_A10}
N 440 2510 440 2560 {lab=N_A10}
N 350 2480 350 2560 {lab=A10}
N 270 2550 360 2550 {lab=#net3119}
N 220 2510 260 2510 {lab=N_A11}
N 220 2550 220 2560 {lab=VDD}
N 250 2550 270 2550 {lab=#net3119}
N 180 2550 190 2550 {lab=#net3121}
N 260 2480 260 2510 {lab=N_A11}
N 260 2510 260 2560 {lab=N_A11}
N 130 2510 170 2510 {lab=A11}
N 130 2550 130 2560 {lab=VDD}
N 160 2550 180 2550 {lab=#net3121}
N 90 2550 100 2550 {lab=#net3123}
N 170 2480 170 2510 {lab=A11}
N 170 2510 170 2560 {lab=A11}
N 80 2480 80 2560 {lab=N_A12}
N 0 2550 90 2550 {lab=#net3123}
N 0 2480 0 2560 { }
N 2210 2600 2220 2600 {lab=GND}
N 2220 2570 2220 2600 {lab=GND}
N 2210 2570 2220 2570 {lab=GND}
N 2170 2560 2170 2600 {lab=N_A5}
N 2170 2600 2170 2640 {lab=N_A5}
N 2160 2630 2210 2630 {lab=word32}
N 2210 2630 2250 2630 {lab=word32}
N 2080 2560 2080 2640 {lab=A5}
N 2070 2630 2160 2630 {lab=word32}
N 1990 2560 1990 2640 {lab=N_A4}
N 1980 2630 2070 2630 {lab=word32}
N 1940 2600 1950 2600 {lab=GND}
N 1950 2570 1950 2600 {lab=GND}
N 1940 2570 1950 2570 {lab=GND}
N 1900 2560 1900 2600 {lab=A4}
N 1900 2600 1900 2640 {lab=A4}
N 1890 2630 1940 2630 {lab=word32}
N 1940 2630 1980 2630 {lab=word32}
N 1810 2560 1810 2640 {lab=N_A3}
N 1800 2630 1890 2630 {lab=word32}
N 1760 2600 1770 2600 {lab=GND}
N 1770 2570 1770 2600 {lab=GND}
N 1760 2570 1770 2570 {lab=GND}
N 1720 2560 1720 2600 {lab=A3}
N 1720 2600 1720 2640 {lab=A3}
N 1710 2630 1760 2630 {lab=word32}
N 1760 2630 1800 2630 {lab=word32}
N 1630 2560 1630 2640 {lab=N_A2}
N 1620 2630 1710 2630 {lab=word32}
N 1580 2600 1590 2600 {lab=GND}
N 1590 2570 1590 2600 {lab=GND}
N 1580 2570 1590 2570 {lab=GND}
N 1540 2560 1540 2600 {lab=A2}
N 1540 2600 1540 2640 {lab=A2}
N 1530 2630 1580 2630 {lab=word32}
N 1580 2630 1620 2630 {lab=word32}
N 1450 2560 1450 2640 {lab=N_A1}
N 1440 2630 1530 2630 {lab=word32}
N 1400 2600 1410 2600 {lab=GND}
N 1410 2570 1410 2600 {lab=GND}
N 1400 2570 1410 2570 {lab=GND}
N 1360 2560 1360 2600 {lab=A1}
N 1360 2600 1360 2640 {lab=A1}
N 1350 2630 1400 2630 {lab=word32}
N 1400 2630 1440 2630 {lab=word32}
N 1270 2560 1270 2640 {lab=N_A0}
N 1260 2630 1350 2630 {lab=word32}
N 1220 2600 1230 2600 {lab=GND}
N 1230 2570 1230 2600 {lab=GND}
N 1220 2570 1230 2570 {lab=GND}
N 1180 2560 1180 2600 {lab=A0}
N 1180 2600 1180 2640 {lab=A0}
N 1170 2630 1220 2630 {lab=word32}
N 1220 2630 1260 2630 {lab=word32}
N 1080 2630 1170 2630 { }
N 1030 2590 1070 2590 {lab=A6}
N 1030 2630 1030 2640 {lab=VDD}
N 1060 2630 1080 2630 {lab=word32}
N 990 2630 1000 2630 {lab=#net3213}
N 1070 2560 1070 2590 {lab=A6}
N 1070 2590 1070 2640 {lab=A6}
N 980 2560 980 2640 {lab=N_A7}
N 900 2630 990 2630 {lab=#net3213}
N 850 2590 890 2590 {lab=A7}
N 850 2630 850 2640 {lab=VDD}
N 880 2630 900 2630 {lab=#net3213}
N 810 2630 820 2630 {lab=#net3215}
N 890 2560 890 2590 {lab=A7}
N 890 2590 890 2640 {lab=A7}
N 800 2560 800 2640 {lab=N_A8}
N 720 2630 810 2630 {lab=#net3215}
N 670 2590 710 2590 {lab=A8}
N 670 2630 670 2640 {lab=VDD}
N 700 2630 720 2630 {lab=#net3215}
N 630 2630 640 2630 {lab=#net3217}
N 710 2560 710 2590 {lab=A8}
N 710 2590 710 2640 {lab=A8}
N 620 2560 620 2640 {lab=N_A9}
N 540 2630 630 2630 {lab=#net3217}
N 490 2590 530 2590 {lab=A9}
N 490 2630 490 2640 {lab=VDD}
N 520 2630 540 2630 {lab=#net3217}
N 450 2630 460 2630 {lab=#net3219}
N 530 2560 530 2590 {lab=A9}
N 530 2590 530 2640 {lab=A9}
N 440 2560 440 2640 {lab=N_A10}
N 360 2630 450 2630 {lab=#net3219}
N 310 2590 350 2590 {lab=A10}
N 310 2630 310 2640 {lab=VDD}
N 340 2630 360 2630 {lab=#net3219}
N 270 2630 280 2630 {lab=#net3221}
N 350 2560 350 2590 {lab=A10}
N 350 2590 350 2640 {lab=A10}
N 260 2560 260 2640 {lab=N_A11}
N 180 2630 270 2630 {lab=#net3221}
N 170 2560 170 2640 {lab=A11}
N 90 2630 180 2630 {lab=#net3221}
N 40 2590 80 2590 {lab=N_A12}
N 40 2630 40 2640 {lab=VDD}
N 70 2630 90 2630 {lab=#net3221}
N 0 2630 10 2630 {lab=#net3223}
N 80 2560 80 2590 {lab=N_A12}
N 80 2590 80 2640 {lab=N_A12}
N 0 2560 0 2640 { }
N 2210 2680 2220 2680 {lab=GND}
N 2220 2650 2220 2680 {lab=GND}
N 2210 2650 2220 2650 {lab=GND}
N 2170 2640 2170 2680 {lab=N_A5}
N 2170 2680 2170 2720 {lab=N_A5}
N 2160 2710 2210 2710 {lab=word33}
N 2210 2710 2250 2710 {lab=word33}
N 2080 2640 2080 2720 {lab=A5}
N 2070 2710 2160 2710 {lab=word33}
N 1990 2640 1990 2720 {lab=N_A4}
N 1980 2710 2070 2710 {lab=word33}
N 1940 2680 1950 2680 {lab=GND}
N 1950 2650 1950 2680 {lab=GND}
N 1940 2650 1950 2650 {lab=GND}
N 1900 2640 1900 2680 {lab=A4}
N 1900 2680 1900 2720 {lab=A4}
N 1890 2710 1940 2710 {lab=word33}
N 1940 2710 1980 2710 {lab=word33}
N 1810 2640 1810 2720 {lab=N_A3}
N 1800 2710 1890 2710 {lab=word33}
N 1760 2680 1770 2680 {lab=GND}
N 1770 2650 1770 2680 {lab=GND}
N 1760 2650 1770 2650 {lab=GND}
N 1720 2640 1720 2680 {lab=A3}
N 1720 2680 1720 2720 {lab=A3}
N 1710 2710 1760 2710 {lab=word33}
N 1760 2710 1800 2710 {lab=word33}
N 1630 2640 1630 2720 {lab=N_A2}
N 1620 2710 1710 2710 {lab=word33}
N 1580 2680 1590 2680 {lab=GND}
N 1590 2650 1590 2680 {lab=GND}
N 1580 2650 1590 2650 {lab=GND}
N 1540 2640 1540 2680 {lab=A2}
N 1540 2680 1540 2720 {lab=A2}
N 1530 2710 1580 2710 {lab=word33}
N 1580 2710 1620 2710 {lab=word33}
N 1450 2640 1450 2720 {lab=N_A1}
N 1440 2710 1530 2710 {lab=word33}
N 1400 2680 1410 2680 {lab=GND}
N 1410 2650 1410 2680 {lab=GND}
N 1400 2650 1410 2650 {lab=GND}
N 1360 2640 1360 2680 {lab=A1}
N 1360 2680 1360 2720 {lab=A1}
N 1350 2710 1400 2710 {lab=word33}
N 1400 2710 1440 2710 {lab=word33}
N 1310 2680 1320 2680 {lab=GND}
N 1320 2650 1320 2680 {lab=GND}
N 1310 2650 1320 2650 {lab=GND}
N 1270 2640 1270 2680 {lab=N_A0}
N 1270 2680 1270 2720 {lab=N_A0}
N 1260 2710 1310 2710 {lab=word33}
N 1310 2710 1350 2710 {lab=word33}
N 1180 2640 1180 2720 {lab=A0}
N 1170 2710 1260 2710 {lab=word33}
N 1080 2710 1170 2710 { }
N 1070 2640 1070 2720 {lab=A6}
N 990 2710 1080 2710 {lab=word33}
N 940 2670 980 2670 {lab=N_A7}
N 940 2710 940 2720 {lab=VDD}
N 970 2710 990 2710 {lab=word33}
N 900 2710 910 2710 {lab=#net3313}
N 980 2640 980 2670 {lab=N_A7}
N 980 2670 980 2720 {lab=N_A7}
N 850 2670 890 2670 {lab=A7}
N 850 2710 850 2720 {lab=VDD}
N 880 2710 900 2710 {lab=#net3313}
N 810 2710 820 2710 {lab=#net3315}
N 890 2640 890 2670 {lab=A7}
N 890 2670 890 2720 {lab=A7}
N 800 2640 800 2720 {lab=N_A8}
N 720 2710 810 2710 {lab=#net3315}
N 670 2670 710 2670 {lab=A8}
N 670 2710 670 2720 {lab=VDD}
N 700 2710 720 2710 {lab=#net3315}
N 630 2710 640 2710 {lab=#net3317}
N 710 2640 710 2670 {lab=A8}
N 710 2670 710 2720 {lab=A8}
N 620 2640 620 2720 {lab=N_A9}
N 540 2710 630 2710 {lab=#net3317}
N 490 2670 530 2670 {lab=A9}
N 490 2710 490 2720 {lab=VDD}
N 520 2710 540 2710 {lab=#net3317}
N 450 2710 460 2710 {lab=#net3319}
N 530 2640 530 2670 {lab=A9}
N 530 2670 530 2720 {lab=A9}
N 440 2640 440 2720 {lab=N_A10}
N 360 2710 450 2710 {lab=#net3319}
N 310 2670 350 2670 {lab=A10}
N 310 2710 310 2720 {lab=VDD}
N 340 2710 360 2710 {lab=#net3319}
N 270 2710 280 2710 {lab=#net3321}
N 350 2640 350 2670 {lab=A10}
N 350 2670 350 2720 {lab=A10}
N 260 2640 260 2720 {lab=N_A11}
N 180 2710 270 2710 {lab=#net3321}
N 170 2640 170 2720 {lab=A11}
N 90 2710 180 2710 {lab=#net3321}
N 40 2670 80 2670 {lab=N_A12}
N 40 2710 40 2720 {lab=VDD}
N 70 2710 90 2710 {lab=#net3321}
N 0 2710 10 2710 {lab=#net3323}
N 80 2640 80 2670 {lab=N_A12}
N 80 2670 80 2720 {lab=N_A12}
N 0 2640 0 2720 { }
N 2210 2760 2220 2760 {lab=GND}
N 2220 2730 2220 2760 {lab=GND}
N 2210 2730 2220 2730 {lab=GND}
N 2170 2720 2170 2760 {lab=N_A5}
N 2170 2760 2170 2800 {lab=N_A5}
N 2160 2790 2210 2790 {lab=word34}
N 2210 2790 2250 2790 {lab=word34}
N 2080 2720 2080 2800 {lab=A5}
N 2070 2790 2160 2790 {lab=word34}
N 1990 2720 1990 2800 {lab=N_A4}
N 1980 2790 2070 2790 {lab=word34}
N 1940 2760 1950 2760 {lab=GND}
N 1950 2730 1950 2760 {lab=GND}
N 1940 2730 1950 2730 {lab=GND}
N 1900 2720 1900 2760 {lab=A4}
N 1900 2760 1900 2800 {lab=A4}
N 1890 2790 1940 2790 {lab=word34}
N 1940 2790 1980 2790 {lab=word34}
N 1810 2720 1810 2800 {lab=N_A3}
N 1800 2790 1890 2790 {lab=word34}
N 1760 2760 1770 2760 {lab=GND}
N 1770 2730 1770 2760 {lab=GND}
N 1760 2730 1770 2730 {lab=GND}
N 1720 2720 1720 2760 {lab=A3}
N 1720 2760 1720 2800 {lab=A3}
N 1710 2790 1760 2790 {lab=word34}
N 1760 2790 1800 2790 {lab=word34}
N 1630 2720 1630 2800 {lab=N_A2}
N 1620 2790 1710 2790 {lab=word34}
N 1580 2760 1590 2760 {lab=GND}
N 1590 2730 1590 2760 {lab=GND}
N 1580 2730 1590 2730 {lab=GND}
N 1540 2720 1540 2760 {lab=A2}
N 1540 2760 1540 2800 {lab=A2}
N 1530 2790 1580 2790 {lab=word34}
N 1580 2790 1620 2790 {lab=word34}
N 1490 2760 1500 2760 {lab=GND}
N 1500 2730 1500 2760 {lab=GND}
N 1490 2730 1500 2730 {lab=GND}
N 1450 2720 1450 2760 {lab=N_A1}
N 1450 2760 1450 2800 {lab=N_A1}
N 1440 2790 1490 2790 {lab=word34}
N 1490 2790 1530 2790 {lab=word34}
N 1360 2720 1360 2800 {lab=A1}
N 1350 2790 1440 2790 {lab=word34}
N 1270 2720 1270 2800 {lab=N_A0}
N 1260 2790 1350 2790 {lab=word34}
N 1220 2760 1230 2760 {lab=GND}
N 1230 2730 1230 2760 {lab=GND}
N 1220 2730 1230 2730 {lab=GND}
N 1180 2720 1180 2760 {lab=A0}
N 1180 2760 1180 2800 {lab=A0}
N 1170 2790 1220 2790 {lab=word34}
N 1220 2790 1260 2790 {lab=word34}
N 1080 2790 1170 2790 { }
N 1030 2750 1070 2750 {lab=A6}
N 1030 2790 1030 2800 {lab=VDD}
N 1060 2790 1080 2790 {lab=word34}
N 990 2790 1000 2790 {lab=#net3413}
N 1070 2720 1070 2750 {lab=A6}
N 1070 2750 1070 2800 {lab=A6}
N 980 2720 980 2800 {lab=N_A7}
N 900 2790 990 2790 {lab=#net3413}
N 890 2720 890 2800 {lab=A7}
N 810 2790 900 2790 {lab=#net3413}
N 760 2750 800 2750 {lab=N_A8}
N 760 2790 760 2800 {lab=VDD}
N 790 2790 810 2790 {lab=#net3413}
N 720 2790 730 2790 {lab=#net3415}
N 800 2720 800 2750 {lab=N_A8}
N 800 2750 800 2800 {lab=N_A8}
N 670 2750 710 2750 {lab=A8}
N 670 2790 670 2800 {lab=VDD}
N 700 2790 720 2790 {lab=#net3415}
N 630 2790 640 2790 {lab=#net3417}
N 710 2720 710 2750 {lab=A8}
N 710 2750 710 2800 {lab=A8}
N 620 2720 620 2800 {lab=N_A9}
N 540 2790 630 2790 {lab=#net3417}
N 490 2750 530 2750 {lab=A9}
N 490 2790 490 2800 {lab=VDD}
N 520 2790 540 2790 {lab=#net3417}
N 450 2790 460 2790 {lab=#net3419}
N 530 2720 530 2750 {lab=A9}
N 530 2750 530 2800 {lab=A9}
N 440 2720 440 2800 {lab=N_A10}
N 360 2790 450 2790 {lab=#net3419}
N 310 2750 350 2750 {lab=A10}
N 310 2790 310 2800 {lab=VDD}
N 340 2790 360 2790 {lab=#net3419}
N 270 2790 280 2790 {lab=#net3421}
N 350 2720 350 2750 {lab=A10}
N 350 2750 350 2800 {lab=A10}
N 260 2720 260 2800 {lab=N_A11}
N 180 2790 270 2790 {lab=#net3421}
N 170 2720 170 2800 {lab=A11}
N 90 2790 180 2790 {lab=#net3421}
N 40 2750 80 2750 {lab=N_A12}
N 40 2790 40 2800 {lab=VDD}
N 70 2790 90 2790 {lab=#net3421}
N 0 2790 10 2790 {lab=#net3423}
N 80 2720 80 2750 {lab=N_A12}
N 80 2750 80 2800 {lab=N_A12}
N 0 2720 0 2800 { }
N 2210 2840 2220 2840 {lab=GND}
N 2220 2810 2220 2840 {lab=GND}
N 2210 2810 2220 2810 {lab=GND}
N 2170 2800 2170 2840 {lab=N_A5}
N 2170 2840 2170 2880 {lab=N_A5}
N 2160 2870 2210 2870 {lab=word35}
N 2210 2870 2250 2870 {lab=word35}
N 2080 2800 2080 2880 {lab=A5}
N 2070 2870 2160 2870 {lab=word35}
N 1990 2800 1990 2880 {lab=N_A4}
N 1980 2870 2070 2870 {lab=word35}
N 1940 2840 1950 2840 {lab=GND}
N 1950 2810 1950 2840 {lab=GND}
N 1940 2810 1950 2810 {lab=GND}
N 1900 2800 1900 2840 {lab=A4}
N 1900 2840 1900 2880 {lab=A4}
N 1890 2870 1940 2870 {lab=word35}
N 1940 2870 1980 2870 {lab=word35}
N 1810 2800 1810 2880 {lab=N_A3}
N 1800 2870 1890 2870 {lab=word35}
N 1760 2840 1770 2840 {lab=GND}
N 1770 2810 1770 2840 {lab=GND}
N 1760 2810 1770 2810 {lab=GND}
N 1720 2800 1720 2840 {lab=A3}
N 1720 2840 1720 2880 {lab=A3}
N 1710 2870 1760 2870 {lab=word35}
N 1760 2870 1800 2870 {lab=word35}
N 1630 2800 1630 2880 {lab=N_A2}
N 1620 2870 1710 2870 {lab=word35}
N 1580 2840 1590 2840 {lab=GND}
N 1590 2810 1590 2840 {lab=GND}
N 1580 2810 1590 2810 {lab=GND}
N 1540 2800 1540 2840 {lab=A2}
N 1540 2840 1540 2880 {lab=A2}
N 1530 2870 1580 2870 {lab=word35}
N 1580 2870 1620 2870 {lab=word35}
N 1490 2840 1500 2840 {lab=GND}
N 1500 2810 1500 2840 {lab=GND}
N 1490 2810 1500 2810 {lab=GND}
N 1450 2800 1450 2840 {lab=N_A1}
N 1450 2840 1450 2880 {lab=N_A1}
N 1440 2870 1490 2870 {lab=word35}
N 1490 2870 1530 2870 {lab=word35}
N 1360 2800 1360 2880 {lab=A1}
N 1350 2870 1440 2870 {lab=word35}
N 1310 2840 1320 2840 {lab=GND}
N 1320 2810 1320 2840 {lab=GND}
N 1310 2810 1320 2810 {lab=GND}
N 1270 2800 1270 2840 {lab=N_A0}
N 1270 2840 1270 2880 {lab=N_A0}
N 1260 2870 1310 2870 {lab=word35}
N 1310 2870 1350 2870 {lab=word35}
N 1180 2800 1180 2880 {lab=A0}
N 1170 2870 1260 2870 {lab=word35}
N 1080 2870 1170 2870 { }
N 1070 2800 1070 2880 {lab=A6}
N 990 2870 1080 2870 {lab=word35}
N 940 2830 980 2830 {lab=N_A7}
N 940 2870 940 2880 {lab=VDD}
N 970 2870 990 2870 {lab=word35}
N 900 2870 910 2870 {lab=#net3513}
N 980 2800 980 2830 {lab=N_A7}
N 980 2830 980 2880 {lab=N_A7}
N 890 2800 890 2880 {lab=A7}
N 810 2870 900 2870 {lab=#net3513}
N 760 2830 800 2830 {lab=N_A8}
N 760 2870 760 2880 {lab=VDD}
N 790 2870 810 2870 {lab=#net3513}
N 720 2870 730 2870 {lab=#net3515}
N 800 2800 800 2830 {lab=N_A8}
N 800 2830 800 2880 {lab=N_A8}
N 670 2830 710 2830 {lab=A8}
N 670 2870 670 2880 {lab=VDD}
N 700 2870 720 2870 {lab=#net3515}
N 630 2870 640 2870 {lab=#net3517}
N 710 2800 710 2830 {lab=A8}
N 710 2830 710 2880 {lab=A8}
N 620 2800 620 2880 {lab=N_A9}
N 540 2870 630 2870 {lab=#net3517}
N 490 2830 530 2830 {lab=A9}
N 490 2870 490 2880 {lab=VDD}
N 520 2870 540 2870 {lab=#net3517}
N 450 2870 460 2870 {lab=#net3519}
N 530 2800 530 2830 {lab=A9}
N 530 2830 530 2880 {lab=A9}
N 440 2800 440 2880 {lab=N_A10}
N 360 2870 450 2870 {lab=#net3519}
N 310 2830 350 2830 {lab=A10}
N 310 2870 310 2880 {lab=VDD}
N 340 2870 360 2870 {lab=#net3519}
N 270 2870 280 2870 {lab=#net3521}
N 350 2800 350 2830 {lab=A10}
N 350 2830 350 2880 {lab=A10}
N 260 2800 260 2880 {lab=N_A11}
N 180 2870 270 2870 {lab=#net3521}
N 170 2800 170 2880 {lab=A11}
N 90 2870 180 2870 {lab=#net3521}
N 40 2830 80 2830 {lab=N_A12}
N 40 2870 40 2880 {lab=VDD}
N 70 2870 90 2870 {lab=#net3521}
N 0 2870 10 2870 {lab=#net3523}
N 80 2800 80 2830 {lab=N_A12}
N 80 2830 80 2880 {lab=N_A12}
N 0 2800 0 2880 { }
N 2210 2920 2220 2920 {lab=GND}
N 2220 2890 2220 2920 {lab=GND}
N 2210 2890 2220 2890 {lab=GND}
N 2170 2880 2170 2920 {lab=N_A5}
N 2170 2920 2170 2960 {lab=N_A5}
N 2160 2950 2210 2950 {lab=word36}
N 2210 2950 2250 2950 {lab=word36}
N 2080 2880 2080 2960 {lab=A5}
N 2070 2950 2160 2950 {lab=word36}
N 1990 2880 1990 2960 {lab=N_A4}
N 1980 2950 2070 2950 {lab=word36}
N 1940 2920 1950 2920 {lab=GND}
N 1950 2890 1950 2920 {lab=GND}
N 1940 2890 1950 2890 {lab=GND}
N 1900 2880 1900 2920 {lab=A4}
N 1900 2920 1900 2960 {lab=A4}
N 1890 2950 1940 2950 {lab=word36}
N 1940 2950 1980 2950 {lab=word36}
N 1810 2880 1810 2960 {lab=N_A3}
N 1800 2950 1890 2950 {lab=word36}
N 1760 2920 1770 2920 {lab=GND}
N 1770 2890 1770 2920 {lab=GND}
N 1760 2890 1770 2890 {lab=GND}
N 1720 2880 1720 2920 {lab=A3}
N 1720 2920 1720 2960 {lab=A3}
N 1710 2950 1760 2950 {lab=word36}
N 1760 2950 1800 2950 {lab=word36}
N 1670 2920 1680 2920 {lab=GND}
N 1680 2890 1680 2920 {lab=GND}
N 1670 2890 1680 2890 {lab=GND}
N 1630 2880 1630 2920 {lab=N_A2}
N 1630 2920 1630 2960 {lab=N_A2}
N 1620 2950 1670 2950 {lab=word36}
N 1670 2950 1710 2950 {lab=word36}
N 1540 2880 1540 2960 {lab=A2}
N 1530 2950 1620 2950 {lab=word36}
N 1450 2880 1450 2960 {lab=N_A1}
N 1440 2950 1530 2950 {lab=word36}
N 1400 2920 1410 2920 {lab=GND}
N 1410 2890 1410 2920 {lab=GND}
N 1400 2890 1410 2890 {lab=GND}
N 1360 2880 1360 2920 {lab=A1}
N 1360 2920 1360 2960 {lab=A1}
N 1350 2950 1400 2950 {lab=word36}
N 1400 2950 1440 2950 {lab=word36}
N 1270 2880 1270 2960 {lab=N_A0}
N 1260 2950 1350 2950 {lab=word36}
N 1220 2920 1230 2920 {lab=GND}
N 1230 2890 1230 2920 {lab=GND}
N 1220 2890 1230 2890 {lab=GND}
N 1180 2880 1180 2920 {lab=A0}
N 1180 2920 1180 2960 {lab=A0}
N 1170 2950 1220 2950 {lab=word36}
N 1220 2950 1260 2950 {lab=word36}
N 1080 2950 1170 2950 { }
N 1030 2910 1070 2910 {lab=A6}
N 1030 2950 1030 2960 {lab=VDD}
N 1060 2950 1080 2950 {lab=word36}
N 990 2950 1000 2950 {lab=#net3613}
N 1070 2880 1070 2910 {lab=A6}
N 1070 2910 1070 2960 {lab=A6}
N 980 2880 980 2960 {lab=N_A7}
N 900 2950 990 2950 {lab=#net3613}
N 850 2910 890 2910 {lab=A7}
N 850 2950 850 2960 {lab=VDD}
N 880 2950 900 2950 {lab=#net3613}
N 810 2950 820 2950 {lab=#net3615}
N 890 2880 890 2910 {lab=A7}
N 890 2910 890 2960 {lab=A7}
N 800 2880 800 2960 {lab=N_A8}
N 720 2950 810 2950 {lab=#net3615}
N 710 2880 710 2960 {lab=A8}
N 630 2950 720 2950 {lab=#net3615}
N 580 2910 620 2910 {lab=N_A9}
N 580 2950 580 2960 {lab=VDD}
N 610 2950 630 2950 {lab=#net3615}
N 540 2950 550 2950 {lab=#net3617}
N 620 2880 620 2910 {lab=N_A9}
N 620 2910 620 2960 {lab=N_A9}
N 490 2910 530 2910 {lab=A9}
N 490 2950 490 2960 {lab=VDD}
N 520 2950 540 2950 {lab=#net3617}
N 450 2950 460 2950 {lab=#net3619}
N 530 2880 530 2910 {lab=A9}
N 530 2910 530 2960 {lab=A9}
N 440 2880 440 2960 {lab=N_A10}
N 360 2950 450 2950 {lab=#net3619}
N 310 2910 350 2910 {lab=A10}
N 310 2950 310 2960 {lab=VDD}
N 340 2950 360 2950 {lab=#net3619}
N 270 2950 280 2950 {lab=#net3621}
N 350 2880 350 2910 {lab=A10}
N 350 2910 350 2960 {lab=A10}
N 260 2880 260 2960 {lab=N_A11}
N 180 2950 270 2950 {lab=#net3621}
N 170 2880 170 2960 {lab=A11}
N 90 2950 180 2950 {lab=#net3621}
N 40 2910 80 2910 {lab=N_A12}
N 40 2950 40 2960 {lab=VDD}
N 70 2950 90 2950 {lab=#net3621}
N 0 2950 10 2950 {lab=#net3623}
N 80 2880 80 2910 {lab=N_A12}
N 80 2910 80 2960 {lab=N_A12}
N 0 2880 0 2960 { }
N 2210 3000 2220 3000 {lab=GND}
N 2220 2970 2220 3000 {lab=GND}
N 2210 2970 2220 2970 {lab=GND}
N 2170 2960 2170 3000 {lab=N_A5}
N 2170 3000 2170 3040 {lab=N_A5}
N 2160 3030 2210 3030 {lab=word37}
N 2210 3030 2250 3030 {lab=word37}
N 2080 2960 2080 3040 {lab=A5}
N 2070 3030 2160 3030 {lab=word37}
N 1990 2960 1990 3040 {lab=N_A4}
N 1980 3030 2070 3030 {lab=word37}
N 1940 3000 1950 3000 {lab=GND}
N 1950 2970 1950 3000 {lab=GND}
N 1940 2970 1950 2970 {lab=GND}
N 1900 2960 1900 3000 {lab=A4}
N 1900 3000 1900 3040 {lab=A4}
N 1890 3030 1940 3030 {lab=word37}
N 1940 3030 1980 3030 {lab=word37}
N 1810 2960 1810 3040 {lab=N_A3}
N 1800 3030 1890 3030 {lab=word37}
N 1760 3000 1770 3000 {lab=GND}
N 1770 2970 1770 3000 {lab=GND}
N 1760 2970 1770 2970 {lab=GND}
N 1720 2960 1720 3000 {lab=A3}
N 1720 3000 1720 3040 {lab=A3}
N 1710 3030 1760 3030 {lab=word37}
N 1760 3030 1800 3030 {lab=word37}
N 1670 3000 1680 3000 {lab=GND}
N 1680 2970 1680 3000 {lab=GND}
N 1670 2970 1680 2970 {lab=GND}
N 1630 2960 1630 3000 {lab=N_A2}
N 1630 3000 1630 3040 {lab=N_A2}
N 1620 3030 1670 3030 {lab=word37}
N 1670 3030 1710 3030 {lab=word37}
N 1540 2960 1540 3040 {lab=A2}
N 1530 3030 1620 3030 {lab=word37}
N 1450 2960 1450 3040 {lab=N_A1}
N 1440 3030 1530 3030 {lab=word37}
N 1400 3000 1410 3000 {lab=GND}
N 1410 2970 1410 3000 {lab=GND}
N 1400 2970 1410 2970 {lab=GND}
N 1360 2960 1360 3000 {lab=A1}
N 1360 3000 1360 3040 {lab=A1}
N 1350 3030 1400 3030 {lab=word37}
N 1400 3030 1440 3030 {lab=word37}
N 1310 3000 1320 3000 {lab=GND}
N 1320 2970 1320 3000 {lab=GND}
N 1310 2970 1320 2970 {lab=GND}
N 1270 2960 1270 3000 {lab=N_A0}
N 1270 3000 1270 3040 {lab=N_A0}
N 1260 3030 1310 3030 {lab=word37}
N 1310 3030 1350 3030 {lab=word37}
N 1180 2960 1180 3040 {lab=A0}
N 1170 3030 1260 3030 {lab=word37}
N 1080 3030 1170 3030 { }
N 1070 2960 1070 3040 {lab=A6}
N 990 3030 1080 3030 {lab=word37}
N 940 2990 980 2990 {lab=N_A7}
N 940 3030 940 3040 {lab=VDD}
N 970 3030 990 3030 {lab=word37}
N 900 3030 910 3030 {lab=#net3713}
N 980 2960 980 2990 {lab=N_A7}
N 980 2990 980 3040 {lab=N_A7}
N 850 2990 890 2990 {lab=A7}
N 850 3030 850 3040 {lab=VDD}
N 880 3030 900 3030 {lab=#net3713}
N 810 3030 820 3030 {lab=#net3715}
N 890 2960 890 2990 {lab=A7}
N 890 2990 890 3040 {lab=A7}
N 800 2960 800 3040 {lab=N_A8}
N 720 3030 810 3030 {lab=#net3715}
N 710 2960 710 3040 {lab=A8}
N 630 3030 720 3030 {lab=#net3715}
N 580 2990 620 2990 {lab=N_A9}
N 580 3030 580 3040 {lab=VDD}
N 610 3030 630 3030 {lab=#net3715}
N 540 3030 550 3030 {lab=#net3717}
N 620 2960 620 2990 {lab=N_A9}
N 620 2990 620 3040 {lab=N_A9}
N 490 2990 530 2990 {lab=A9}
N 490 3030 490 3040 {lab=VDD}
N 520 3030 540 3030 {lab=#net3717}
N 450 3030 460 3030 {lab=#net3719}
N 530 2960 530 2990 {lab=A9}
N 530 2990 530 3040 {lab=A9}
N 440 2960 440 3040 {lab=N_A10}
N 360 3030 450 3030 {lab=#net3719}
N 310 2990 350 2990 {lab=A10}
N 310 3030 310 3040 {lab=VDD}
N 340 3030 360 3030 {lab=#net3719}
N 270 3030 280 3030 {lab=#net3721}
N 350 2960 350 2990 {lab=A10}
N 350 2990 350 3040 {lab=A10}
N 260 2960 260 3040 {lab=N_A11}
N 180 3030 270 3030 {lab=#net3721}
N 170 2960 170 3040 {lab=A11}
N 90 3030 180 3030 {lab=#net3721}
N 40 2990 80 2990 {lab=N_A12}
N 40 3030 40 3040 {lab=VDD}
N 70 3030 90 3030 {lab=#net3721}
N 0 3030 10 3030 {lab=#net3723}
N 80 2960 80 2990 {lab=N_A12}
N 80 2990 80 3040 {lab=N_A12}
N 0 2960 0 3040 { }
N 2210 3080 2220 3080 {lab=GND}
N 2220 3050 2220 3080 {lab=GND}
N 2210 3050 2220 3050 {lab=GND}
N 2170 3040 2170 3080 {lab=N_A5}
N 2170 3080 2170 3120 {lab=N_A5}
N 2160 3110 2210 3110 {lab=word38}
N 2210 3110 2250 3110 {lab=word38}
N 2080 3040 2080 3120 {lab=A5}
N 2070 3110 2160 3110 {lab=word38}
N 1990 3040 1990 3120 {lab=N_A4}
N 1980 3110 2070 3110 {lab=word38}
N 1940 3080 1950 3080 {lab=GND}
N 1950 3050 1950 3080 {lab=GND}
N 1940 3050 1950 3050 {lab=GND}
N 1900 3040 1900 3080 {lab=A4}
N 1900 3080 1900 3120 {lab=A4}
N 1890 3110 1940 3110 {lab=word38}
N 1940 3110 1980 3110 {lab=word38}
N 1810 3040 1810 3120 {lab=N_A3}
N 1800 3110 1890 3110 {lab=word38}
N 1760 3080 1770 3080 {lab=GND}
N 1770 3050 1770 3080 {lab=GND}
N 1760 3050 1770 3050 {lab=GND}
N 1720 3040 1720 3080 {lab=A3}
N 1720 3080 1720 3120 {lab=A3}
N 1710 3110 1760 3110 {lab=word38}
N 1760 3110 1800 3110 {lab=word38}
N 1670 3080 1680 3080 {lab=GND}
N 1680 3050 1680 3080 {lab=GND}
N 1670 3050 1680 3050 {lab=GND}
N 1630 3040 1630 3080 {lab=N_A2}
N 1630 3080 1630 3120 {lab=N_A2}
N 1620 3110 1670 3110 {lab=word38}
N 1670 3110 1710 3110 {lab=word38}
N 1540 3040 1540 3120 {lab=A2}
N 1530 3110 1620 3110 {lab=word38}
N 1490 3080 1500 3080 {lab=GND}
N 1500 3050 1500 3080 {lab=GND}
N 1490 3050 1500 3050 {lab=GND}
N 1450 3040 1450 3080 {lab=N_A1}
N 1450 3080 1450 3120 {lab=N_A1}
N 1440 3110 1490 3110 {lab=word38}
N 1490 3110 1530 3110 {lab=word38}
N 1360 3040 1360 3120 {lab=A1}
N 1350 3110 1440 3110 {lab=word38}
N 1270 3040 1270 3120 {lab=N_A0}
N 1260 3110 1350 3110 {lab=word38}
N 1220 3080 1230 3080 {lab=GND}
N 1230 3050 1230 3080 {lab=GND}
N 1220 3050 1230 3050 {lab=GND}
N 1180 3040 1180 3080 {lab=A0}
N 1180 3080 1180 3120 {lab=A0}
N 1170 3110 1220 3110 {lab=word38}
N 1220 3110 1260 3110 {lab=word38}
N 1080 3110 1170 3110 { }
N 1030 3070 1070 3070 {lab=A6}
N 1030 3110 1030 3120 {lab=VDD}
N 1060 3110 1080 3110 {lab=word38}
N 990 3110 1000 3110 {lab=#net3813}
N 1070 3040 1070 3070 {lab=A6}
N 1070 3070 1070 3120 {lab=A6}
N 980 3040 980 3120 {lab=N_A7}
N 900 3110 990 3110 {lab=#net3813}
N 890 3040 890 3120 {lab=A7}
N 810 3110 900 3110 {lab=#net3813}
N 760 3070 800 3070 {lab=N_A8}
N 760 3110 760 3120 {lab=VDD}
N 790 3110 810 3110 {lab=#net3813}
N 720 3110 730 3110 {lab=#net3815}
N 800 3040 800 3070 {lab=N_A8}
N 800 3070 800 3120 {lab=N_A8}
N 710 3040 710 3120 {lab=A8}
N 630 3110 720 3110 {lab=#net3815}
N 580 3070 620 3070 {lab=N_A9}
N 580 3110 580 3120 {lab=VDD}
N 610 3110 630 3110 {lab=#net3815}
N 540 3110 550 3110 {lab=#net3817}
N 620 3040 620 3070 {lab=N_A9}
N 620 3070 620 3120 {lab=N_A9}
N 490 3070 530 3070 {lab=A9}
N 490 3110 490 3120 {lab=VDD}
N 520 3110 540 3110 {lab=#net3817}
N 450 3110 460 3110 {lab=#net3819}
N 530 3040 530 3070 {lab=A9}
N 530 3070 530 3120 {lab=A9}
N 440 3040 440 3120 {lab=N_A10}
N 360 3110 450 3110 {lab=#net3819}
N 310 3070 350 3070 {lab=A10}
N 310 3110 310 3120 {lab=VDD}
N 340 3110 360 3110 {lab=#net3819}
N 270 3110 280 3110 {lab=#net3821}
N 350 3040 350 3070 {lab=A10}
N 350 3070 350 3120 {lab=A10}
N 260 3040 260 3120 {lab=N_A11}
N 180 3110 270 3110 {lab=#net3821}
N 170 3040 170 3120 {lab=A11}
N 90 3110 180 3110 {lab=#net3821}
N 40 3070 80 3070 {lab=N_A12}
N 40 3110 40 3120 {lab=VDD}
N 70 3110 90 3110 {lab=#net3821}
N 0 3110 10 3110 {lab=#net3823}
N 80 3040 80 3070 {lab=N_A12}
N 80 3070 80 3120 {lab=N_A12}
N 0 3040 0 3120 { }
N 2210 3160 2220 3160 {lab=GND}
N 2220 3130 2220 3160 {lab=GND}
N 2210 3130 2220 3130 {lab=GND}
N 2170 3120 2170 3160 {lab=N_A5}
N 2170 3160 2170 3200 {lab=N_A5}
N 2160 3190 2210 3190 {lab=word39}
N 2210 3190 2250 3190 {lab=word39}
N 2080 3120 2080 3200 {lab=A5}
N 2070 3190 2160 3190 {lab=word39}
N 1990 3120 1990 3200 {lab=N_A4}
N 1980 3190 2070 3190 {lab=word39}
N 1940 3160 1950 3160 {lab=GND}
N 1950 3130 1950 3160 {lab=GND}
N 1940 3130 1950 3130 {lab=GND}
N 1900 3120 1900 3160 {lab=A4}
N 1900 3160 1900 3200 {lab=A4}
N 1890 3190 1940 3190 {lab=word39}
N 1940 3190 1980 3190 {lab=word39}
N 1810 3120 1810 3200 {lab=N_A3}
N 1800 3190 1890 3190 {lab=word39}
N 1760 3160 1770 3160 {lab=GND}
N 1770 3130 1770 3160 {lab=GND}
N 1760 3130 1770 3130 {lab=GND}
N 1720 3120 1720 3160 {lab=A3}
N 1720 3160 1720 3200 {lab=A3}
N 1710 3190 1760 3190 {lab=word39}
N 1760 3190 1800 3190 {lab=word39}
N 1670 3160 1680 3160 {lab=GND}
N 1680 3130 1680 3160 {lab=GND}
N 1670 3130 1680 3130 {lab=GND}
N 1630 3120 1630 3160 {lab=N_A2}
N 1630 3160 1630 3200 {lab=N_A2}
N 1620 3190 1670 3190 {lab=word39}
N 1670 3190 1710 3190 {lab=word39}
N 1540 3120 1540 3200 {lab=A2}
N 1530 3190 1620 3190 {lab=word39}
N 1490 3160 1500 3160 {lab=GND}
N 1500 3130 1500 3160 {lab=GND}
N 1490 3130 1500 3130 {lab=GND}
N 1450 3120 1450 3160 {lab=N_A1}
N 1450 3160 1450 3200 {lab=N_A1}
N 1440 3190 1490 3190 {lab=word39}
N 1490 3190 1530 3190 {lab=word39}
N 1360 3120 1360 3200 {lab=A1}
N 1350 3190 1440 3190 {lab=word39}
N 1310 3160 1320 3160 {lab=GND}
N 1320 3130 1320 3160 {lab=GND}
N 1310 3130 1320 3130 {lab=GND}
N 1270 3120 1270 3160 {lab=N_A0}
N 1270 3160 1270 3200 {lab=N_A0}
N 1260 3190 1310 3190 {lab=word39}
N 1310 3190 1350 3190 {lab=word39}
N 1180 3120 1180 3200 {lab=A0}
N 1170 3190 1260 3190 {lab=word39}
N 1080 3190 1170 3190 { }
N 1070 3120 1070 3200 {lab=A6}
N 990 3190 1080 3190 {lab=word39}
N 940 3150 980 3150 {lab=N_A7}
N 940 3190 940 3200 {lab=VDD}
N 970 3190 990 3190 {lab=word39}
N 900 3190 910 3190 {lab=#net3913}
N 980 3120 980 3150 {lab=N_A7}
N 980 3150 980 3200 {lab=N_A7}
N 890 3120 890 3200 {lab=A7}
N 810 3190 900 3190 {lab=#net3913}
N 760 3150 800 3150 {lab=N_A8}
N 760 3190 760 3200 {lab=VDD}
N 790 3190 810 3190 {lab=#net3913}
N 720 3190 730 3190 {lab=#net3915}
N 800 3120 800 3150 {lab=N_A8}
N 800 3150 800 3200 {lab=N_A8}
N 710 3120 710 3200 {lab=A8}
N 630 3190 720 3190 {lab=#net3915}
N 580 3150 620 3150 {lab=N_A9}
N 580 3190 580 3200 {lab=VDD}
N 610 3190 630 3190 {lab=#net3915}
N 540 3190 550 3190 {lab=#net3917}
N 620 3120 620 3150 {lab=N_A9}
N 620 3150 620 3200 {lab=N_A9}
N 490 3150 530 3150 {lab=A9}
N 490 3190 490 3200 {lab=VDD}
N 520 3190 540 3190 {lab=#net3917}
N 450 3190 460 3190 {lab=#net3919}
N 530 3120 530 3150 {lab=A9}
N 530 3150 530 3200 {lab=A9}
N 440 3120 440 3200 {lab=N_A10}
N 360 3190 450 3190 {lab=#net3919}
N 310 3150 350 3150 {lab=A10}
N 310 3190 310 3200 {lab=VDD}
N 340 3190 360 3190 {lab=#net3919}
N 270 3190 280 3190 {lab=#net3921}
N 350 3120 350 3150 {lab=A10}
N 350 3150 350 3200 {lab=A10}
N 260 3120 260 3200 {lab=N_A11}
N 180 3190 270 3190 {lab=#net3921}
N 170 3120 170 3200 {lab=A11}
N 90 3190 180 3190 {lab=#net3921}
N 40 3150 80 3150 {lab=N_A12}
N 40 3190 40 3200 {lab=VDD}
N 70 3190 90 3190 {lab=#net3921}
N 0 3190 10 3190 {lab=#net3923}
N 80 3120 80 3150 {lab=N_A12}
N 80 3150 80 3200 {lab=N_A12}
N 0 3120 0 3200 { }
N 2210 3240 2220 3240 {lab=GND}
N 2220 3210 2220 3240 {lab=GND}
N 2210 3210 2220 3210 {lab=GND}
N 2170 3200 2170 3240 {lab=N_A5}
N 2170 3240 2170 3280 {lab=N_A5}
N 2160 3270 2210 3270 {lab=word40}
N 2210 3270 2250 3270 {lab=word40}
N 2080 3200 2080 3280 {lab=A5}
N 2070 3270 2160 3270 {lab=word40}
N 1990 3200 1990 3280 {lab=N_A4}
N 1980 3270 2070 3270 {lab=word40}
N 1940 3240 1950 3240 {lab=GND}
N 1950 3210 1950 3240 {lab=GND}
N 1940 3210 1950 3210 {lab=GND}
N 1900 3200 1900 3240 {lab=A4}
N 1900 3240 1900 3280 {lab=A4}
N 1890 3270 1940 3270 {lab=word40}
N 1940 3270 1980 3270 {lab=word40}
N 1850 3240 1860 3240 {lab=GND}
N 1860 3210 1860 3240 {lab=GND}
N 1850 3210 1860 3210 {lab=GND}
N 1810 3200 1810 3240 {lab=N_A3}
N 1810 3240 1810 3280 {lab=N_A3}
N 1800 3270 1850 3270 {lab=word40}
N 1850 3270 1890 3270 {lab=word40}
N 1720 3200 1720 3280 {lab=A3}
N 1710 3270 1800 3270 {lab=word40}
N 1630 3200 1630 3280 {lab=N_A2}
N 1620 3270 1710 3270 {lab=word40}
N 1580 3240 1590 3240 {lab=GND}
N 1590 3210 1590 3240 {lab=GND}
N 1580 3210 1590 3210 {lab=GND}
N 1540 3200 1540 3240 {lab=A2}
N 1540 3240 1540 3280 {lab=A2}
N 1530 3270 1580 3270 {lab=word40}
N 1580 3270 1620 3270 {lab=word40}
N 1450 3200 1450 3280 {lab=N_A1}
N 1440 3270 1530 3270 {lab=word40}
N 1400 3240 1410 3240 {lab=GND}
N 1410 3210 1410 3240 {lab=GND}
N 1400 3210 1410 3210 {lab=GND}
N 1360 3200 1360 3240 {lab=A1}
N 1360 3240 1360 3280 {lab=A1}
N 1350 3270 1400 3270 {lab=word40}
N 1400 3270 1440 3270 {lab=word40}
N 1270 3200 1270 3280 {lab=N_A0}
N 1260 3270 1350 3270 {lab=word40}
N 1220 3240 1230 3240 {lab=GND}
N 1230 3210 1230 3240 {lab=GND}
N 1220 3210 1230 3210 {lab=GND}
N 1180 3200 1180 3240 {lab=A0}
N 1180 3240 1180 3280 {lab=A0}
N 1170 3270 1220 3270 {lab=word40}
N 1220 3270 1260 3270 {lab=word40}
N 1080 3270 1170 3270 { }
N 1030 3230 1070 3230 {lab=A6}
N 1030 3270 1030 3280 {lab=VDD}
N 1060 3270 1080 3270 {lab=word40}
N 990 3270 1000 3270 {lab=#net4013}
N 1070 3200 1070 3230 {lab=A6}
N 1070 3230 1070 3280 {lab=A6}
N 980 3200 980 3280 {lab=N_A7}
N 900 3270 990 3270 {lab=#net4013}
N 850 3230 890 3230 {lab=A7}
N 850 3270 850 3280 {lab=VDD}
N 880 3270 900 3270 {lab=#net4013}
N 810 3270 820 3270 {lab=#net4015}
N 890 3200 890 3230 {lab=A7}
N 890 3230 890 3280 {lab=A7}
N 800 3200 800 3280 {lab=N_A8}
N 720 3270 810 3270 {lab=#net4015}
N 670 3230 710 3230 {lab=A8}
N 670 3270 670 3280 {lab=VDD}
N 700 3270 720 3270 {lab=#net4015}
N 630 3270 640 3270 {lab=#net4017}
N 710 3200 710 3230 {lab=A8}
N 710 3230 710 3280 {lab=A8}
N 620 3200 620 3280 {lab=N_A9}
N 540 3270 630 3270 {lab=#net4017}
N 530 3200 530 3280 {lab=A9}
N 450 3270 540 3270 {lab=#net4017}
N 400 3230 440 3230 {lab=N_A10}
N 400 3270 400 3280 {lab=VDD}
N 430 3270 450 3270 {lab=#net4017}
N 360 3270 370 3270 {lab=#net4019}
N 440 3200 440 3230 {lab=N_A10}
N 440 3230 440 3280 {lab=N_A10}
N 310 3230 350 3230 {lab=A10}
N 310 3270 310 3280 {lab=VDD}
N 340 3270 360 3270 {lab=#net4019}
N 270 3270 280 3270 {lab=#net4021}
N 350 3200 350 3230 {lab=A10}
N 350 3230 350 3280 {lab=A10}
N 260 3200 260 3280 {lab=N_A11}
N 180 3270 270 3270 {lab=#net4021}
N 170 3200 170 3280 {lab=A11}
N 90 3270 180 3270 {lab=#net4021}
N 40 3230 80 3230 {lab=N_A12}
N 40 3270 40 3280 {lab=VDD}
N 70 3270 90 3270 {lab=#net4021}
N 0 3270 10 3270 {lab=#net4023}
N 80 3200 80 3230 {lab=N_A12}
N 80 3230 80 3280 {lab=N_A12}
N 0 3200 0 3280 { }
N 2210 3320 2220 3320 {lab=GND}
N 2220 3290 2220 3320 {lab=GND}
N 2210 3290 2220 3290 {lab=GND}
N 2170 3280 2170 3320 {lab=N_A5}
N 2170 3320 2170 3360 {lab=N_A5}
N 2160 3350 2210 3350 {lab=word41}
N 2210 3350 2250 3350 {lab=word41}
N 2080 3280 2080 3360 {lab=A5}
N 2070 3350 2160 3350 {lab=word41}
N 1990 3280 1990 3360 {lab=N_A4}
N 1980 3350 2070 3350 {lab=word41}
N 1940 3320 1950 3320 {lab=GND}
N 1950 3290 1950 3320 {lab=GND}
N 1940 3290 1950 3290 {lab=GND}
N 1900 3280 1900 3320 {lab=A4}
N 1900 3320 1900 3360 {lab=A4}
N 1890 3350 1940 3350 {lab=word41}
N 1940 3350 1980 3350 {lab=word41}
N 1850 3320 1860 3320 {lab=GND}
N 1860 3290 1860 3320 {lab=GND}
N 1850 3290 1860 3290 {lab=GND}
N 1810 3280 1810 3320 {lab=N_A3}
N 1810 3320 1810 3360 {lab=N_A3}
N 1800 3350 1850 3350 {lab=word41}
N 1850 3350 1890 3350 {lab=word41}
N 1720 3280 1720 3360 {lab=A3}
N 1710 3350 1800 3350 {lab=word41}
N 1630 3280 1630 3360 {lab=N_A2}
N 1620 3350 1710 3350 {lab=word41}
N 1580 3320 1590 3320 {lab=GND}
N 1590 3290 1590 3320 {lab=GND}
N 1580 3290 1590 3290 {lab=GND}
N 1540 3280 1540 3320 {lab=A2}
N 1540 3320 1540 3360 {lab=A2}
N 1530 3350 1580 3350 {lab=word41}
N 1580 3350 1620 3350 {lab=word41}
N 1450 3280 1450 3360 {lab=N_A1}
N 1440 3350 1530 3350 {lab=word41}
N 1400 3320 1410 3320 {lab=GND}
N 1410 3290 1410 3320 {lab=GND}
N 1400 3290 1410 3290 {lab=GND}
N 1360 3280 1360 3320 {lab=A1}
N 1360 3320 1360 3360 {lab=A1}
N 1350 3350 1400 3350 {lab=word41}
N 1400 3350 1440 3350 {lab=word41}
N 1310 3320 1320 3320 {lab=GND}
N 1320 3290 1320 3320 {lab=GND}
N 1310 3290 1320 3290 {lab=GND}
N 1270 3280 1270 3320 {lab=N_A0}
N 1270 3320 1270 3360 {lab=N_A0}
N 1260 3350 1310 3350 {lab=word41}
N 1310 3350 1350 3350 {lab=word41}
N 1180 3280 1180 3360 {lab=A0}
N 1170 3350 1260 3350 {lab=word41}
N 1080 3350 1170 3350 { }
N 1070 3280 1070 3360 {lab=A6}
N 990 3350 1080 3350 {lab=word41}
N 940 3310 980 3310 {lab=N_A7}
N 940 3350 940 3360 {lab=VDD}
N 970 3350 990 3350 {lab=word41}
N 900 3350 910 3350 {lab=#net4113}
N 980 3280 980 3310 {lab=N_A7}
N 980 3310 980 3360 {lab=N_A7}
N 850 3310 890 3310 {lab=A7}
N 850 3350 850 3360 {lab=VDD}
N 880 3350 900 3350 {lab=#net4113}
N 810 3350 820 3350 {lab=#net4115}
N 890 3280 890 3310 {lab=A7}
N 890 3310 890 3360 {lab=A7}
N 800 3280 800 3360 {lab=N_A8}
N 720 3350 810 3350 {lab=#net4115}
N 670 3310 710 3310 {lab=A8}
N 670 3350 670 3360 {lab=VDD}
N 700 3350 720 3350 {lab=#net4115}
N 630 3350 640 3350 {lab=#net4117}
N 710 3280 710 3310 {lab=A8}
N 710 3310 710 3360 {lab=A8}
N 620 3280 620 3360 {lab=N_A9}
N 540 3350 630 3350 {lab=#net4117}
N 530 3280 530 3360 {lab=A9}
N 450 3350 540 3350 {lab=#net4117}
N 400 3310 440 3310 {lab=N_A10}
N 400 3350 400 3360 {lab=VDD}
N 430 3350 450 3350 {lab=#net4117}
N 360 3350 370 3350 {lab=#net4119}
N 440 3280 440 3310 {lab=N_A10}
N 440 3310 440 3360 {lab=N_A10}
N 310 3310 350 3310 {lab=A10}
N 310 3350 310 3360 {lab=VDD}
N 340 3350 360 3350 {lab=#net4119}
N 270 3350 280 3350 {lab=#net4121}
N 350 3280 350 3310 {lab=A10}
N 350 3310 350 3360 {lab=A10}
N 260 3280 260 3360 {lab=N_A11}
N 180 3350 270 3350 {lab=#net4121}
N 170 3280 170 3360 {lab=A11}
N 90 3350 180 3350 {lab=#net4121}
N 40 3310 80 3310 {lab=N_A12}
N 40 3350 40 3360 {lab=VDD}
N 70 3350 90 3350 {lab=#net4121}
N 0 3350 10 3350 {lab=#net4123}
N 80 3280 80 3310 {lab=N_A12}
N 80 3310 80 3360 {lab=N_A12}
N 0 3280 0 3360 { }
N 2210 3400 2220 3400 {lab=GND}
N 2220 3370 2220 3400 {lab=GND}
N 2210 3370 2220 3370 {lab=GND}
N 2170 3360 2170 3400 {lab=N_A5}
N 2170 3400 2170 3440 {lab=N_A5}
N 2160 3430 2210 3430 {lab=word42}
N 2210 3430 2250 3430 {lab=word42}
N 2080 3360 2080 3440 {lab=A5}
N 2070 3430 2160 3430 {lab=word42}
N 1990 3360 1990 3440 {lab=N_A4}
N 1980 3430 2070 3430 {lab=word42}
N 1940 3400 1950 3400 {lab=GND}
N 1950 3370 1950 3400 {lab=GND}
N 1940 3370 1950 3370 {lab=GND}
N 1900 3360 1900 3400 {lab=A4}
N 1900 3400 1900 3440 {lab=A4}
N 1890 3430 1940 3430 {lab=word42}
N 1940 3430 1980 3430 {lab=word42}
N 1850 3400 1860 3400 {lab=GND}
N 1860 3370 1860 3400 {lab=GND}
N 1850 3370 1860 3370 {lab=GND}
N 1810 3360 1810 3400 {lab=N_A3}
N 1810 3400 1810 3440 {lab=N_A3}
N 1800 3430 1850 3430 {lab=word42}
N 1850 3430 1890 3430 {lab=word42}
N 1720 3360 1720 3440 {lab=A3}
N 1710 3430 1800 3430 {lab=word42}
N 1630 3360 1630 3440 {lab=N_A2}
N 1620 3430 1710 3430 {lab=word42}
N 1580 3400 1590 3400 {lab=GND}
N 1590 3370 1590 3400 {lab=GND}
N 1580 3370 1590 3370 {lab=GND}
N 1540 3360 1540 3400 {lab=A2}
N 1540 3400 1540 3440 {lab=A2}
N 1530 3430 1580 3430 {lab=word42}
N 1580 3430 1620 3430 {lab=word42}
N 1490 3400 1500 3400 {lab=GND}
N 1500 3370 1500 3400 {lab=GND}
N 1490 3370 1500 3370 {lab=GND}
N 1450 3360 1450 3400 {lab=N_A1}
N 1450 3400 1450 3440 {lab=N_A1}
N 1440 3430 1490 3430 {lab=word42}
N 1490 3430 1530 3430 {lab=word42}
N 1360 3360 1360 3440 {lab=A1}
N 1350 3430 1440 3430 {lab=word42}
N 1270 3360 1270 3440 {lab=N_A0}
N 1260 3430 1350 3430 {lab=word42}
N 1220 3400 1230 3400 {lab=GND}
N 1230 3370 1230 3400 {lab=GND}
N 1220 3370 1230 3370 {lab=GND}
N 1180 3360 1180 3400 {lab=A0}
N 1180 3400 1180 3440 {lab=A0}
N 1170 3430 1220 3430 {lab=word42}
N 1220 3430 1260 3430 {lab=word42}
N 1080 3430 1170 3430 { }
N 1030 3390 1070 3390 {lab=A6}
N 1030 3430 1030 3440 {lab=VDD}
N 1060 3430 1080 3430 {lab=word42}
N 990 3430 1000 3430 {lab=#net4213}
N 1070 3360 1070 3390 {lab=A6}
N 1070 3390 1070 3440 {lab=A6}
N 980 3360 980 3440 {lab=N_A7}
N 900 3430 990 3430 {lab=#net4213}
N 890 3360 890 3440 {lab=A7}
N 810 3430 900 3430 {lab=#net4213}
N 760 3390 800 3390 {lab=N_A8}
N 760 3430 760 3440 {lab=VDD}
N 790 3430 810 3430 {lab=#net4213}
N 720 3430 730 3430 {lab=#net4215}
N 800 3360 800 3390 {lab=N_A8}
N 800 3390 800 3440 {lab=N_A8}
N 670 3390 710 3390 {lab=A8}
N 670 3430 670 3440 {lab=VDD}
N 700 3430 720 3430 {lab=#net4215}
N 630 3430 640 3430 {lab=#net4217}
N 710 3360 710 3390 {lab=A8}
N 710 3390 710 3440 {lab=A8}
N 620 3360 620 3440 {lab=N_A9}
N 540 3430 630 3430 {lab=#net4217}
N 530 3360 530 3440 {lab=A9}
N 450 3430 540 3430 {lab=#net4217}
N 400 3390 440 3390 {lab=N_A10}
N 400 3430 400 3440 {lab=VDD}
N 430 3430 450 3430 {lab=#net4217}
N 360 3430 370 3430 {lab=#net4219}
N 440 3360 440 3390 {lab=N_A10}
N 440 3390 440 3440 {lab=N_A10}
N 310 3390 350 3390 {lab=A10}
N 310 3430 310 3440 {lab=VDD}
N 340 3430 360 3430 {lab=#net4219}
N 270 3430 280 3430 {lab=#net4221}
N 350 3360 350 3390 {lab=A10}
N 350 3390 350 3440 {lab=A10}
N 260 3360 260 3440 {lab=N_A11}
N 180 3430 270 3430 {lab=#net4221}
N 170 3360 170 3440 {lab=A11}
N 90 3430 180 3430 {lab=#net4221}
N 40 3390 80 3390 {lab=N_A12}
N 40 3430 40 3440 {lab=VDD}
N 70 3430 90 3430 {lab=#net4221}
N 0 3430 10 3430 {lab=#net4223}
N 80 3360 80 3390 {lab=N_A12}
N 80 3390 80 3440 {lab=N_A12}
N 0 3360 0 3440 { }
N 2210 3480 2220 3480 {lab=GND}
N 2220 3450 2220 3480 {lab=GND}
N 2210 3450 2220 3450 {lab=GND}
N 2170 3440 2170 3480 {lab=N_A5}
N 2170 3480 2170 3520 {lab=N_A5}
N 2160 3510 2210 3510 {lab=word43}
N 2210 3510 2250 3510 {lab=word43}
N 2080 3440 2080 3520 {lab=A5}
N 2070 3510 2160 3510 {lab=word43}
N 1990 3440 1990 3520 {lab=N_A4}
N 1980 3510 2070 3510 {lab=word43}
N 1940 3480 1950 3480 {lab=GND}
N 1950 3450 1950 3480 {lab=GND}
N 1940 3450 1950 3450 {lab=GND}
N 1900 3440 1900 3480 {lab=A4}
N 1900 3480 1900 3520 {lab=A4}
N 1890 3510 1940 3510 {lab=word43}
N 1940 3510 1980 3510 {lab=word43}
N 1850 3480 1860 3480 {lab=GND}
N 1860 3450 1860 3480 {lab=GND}
N 1850 3450 1860 3450 {lab=GND}
N 1810 3440 1810 3480 {lab=N_A3}
N 1810 3480 1810 3520 {lab=N_A3}
N 1800 3510 1850 3510 {lab=word43}
N 1850 3510 1890 3510 {lab=word43}
N 1720 3440 1720 3520 {lab=A3}
N 1710 3510 1800 3510 {lab=word43}
N 1630 3440 1630 3520 {lab=N_A2}
N 1620 3510 1710 3510 {lab=word43}
N 1580 3480 1590 3480 {lab=GND}
N 1590 3450 1590 3480 {lab=GND}
N 1580 3450 1590 3450 {lab=GND}
N 1540 3440 1540 3480 {lab=A2}
N 1540 3480 1540 3520 {lab=A2}
N 1530 3510 1580 3510 {lab=word43}
N 1580 3510 1620 3510 {lab=word43}
N 1490 3480 1500 3480 {lab=GND}
N 1500 3450 1500 3480 {lab=GND}
N 1490 3450 1500 3450 {lab=GND}
N 1450 3440 1450 3480 {lab=N_A1}
N 1450 3480 1450 3520 {lab=N_A1}
N 1440 3510 1490 3510 {lab=word43}
N 1490 3510 1530 3510 {lab=word43}
N 1360 3440 1360 3520 {lab=A1}
N 1350 3510 1440 3510 {lab=word43}
N 1310 3480 1320 3480 {lab=GND}
N 1320 3450 1320 3480 {lab=GND}
N 1310 3450 1320 3450 {lab=GND}
N 1270 3440 1270 3480 {lab=N_A0}
N 1270 3480 1270 3520 {lab=N_A0}
N 1260 3510 1310 3510 {lab=word43}
N 1310 3510 1350 3510 {lab=word43}
N 1180 3440 1180 3520 {lab=A0}
N 1170 3510 1260 3510 {lab=word43}
N 1080 3510 1170 3510 { }
N 1070 3440 1070 3520 {lab=A6}
N 990 3510 1080 3510 {lab=word43}
N 940 3470 980 3470 {lab=N_A7}
N 940 3510 940 3520 {lab=VDD}
N 970 3510 990 3510 {lab=word43}
N 900 3510 910 3510 {lab=#net4313}
N 980 3440 980 3470 {lab=N_A7}
N 980 3470 980 3520 {lab=N_A7}
N 890 3440 890 3520 {lab=A7}
N 810 3510 900 3510 {lab=#net4313}
N 760 3470 800 3470 {lab=N_A8}
N 760 3510 760 3520 {lab=VDD}
N 790 3510 810 3510 {lab=#net4313}
N 720 3510 730 3510 {lab=#net4315}
N 800 3440 800 3470 {lab=N_A8}
N 800 3470 800 3520 {lab=N_A8}
N 670 3470 710 3470 {lab=A8}
N 670 3510 670 3520 {lab=VDD}
N 700 3510 720 3510 {lab=#net4315}
N 630 3510 640 3510 {lab=#net4317}
N 710 3440 710 3470 {lab=A8}
N 710 3470 710 3520 {lab=A8}
N 620 3440 620 3520 {lab=N_A9}
N 540 3510 630 3510 {lab=#net4317}
N 530 3440 530 3520 {lab=A9}
N 450 3510 540 3510 {lab=#net4317}
N 400 3470 440 3470 {lab=N_A10}
N 400 3510 400 3520 {lab=VDD}
N 430 3510 450 3510 {lab=#net4317}
N 360 3510 370 3510 {lab=#net4319}
N 440 3440 440 3470 {lab=N_A10}
N 440 3470 440 3520 {lab=N_A10}
N 310 3470 350 3470 {lab=A10}
N 310 3510 310 3520 {lab=VDD}
N 340 3510 360 3510 {lab=#net4319}
N 270 3510 280 3510 {lab=#net4321}
N 350 3440 350 3470 {lab=A10}
N 350 3470 350 3520 {lab=A10}
N 260 3440 260 3520 {lab=N_A11}
N 180 3510 270 3510 {lab=#net4321}
N 170 3440 170 3520 {lab=A11}
N 90 3510 180 3510 {lab=#net4321}
N 40 3470 80 3470 {lab=N_A12}
N 40 3510 40 3520 {lab=VDD}
N 70 3510 90 3510 {lab=#net4321}
N 0 3510 10 3510 {lab=#net4323}
N 80 3440 80 3470 {lab=N_A12}
N 80 3470 80 3520 {lab=N_A12}
N 0 3440 0 3520 { }
N 2210 3560 2220 3560 {lab=GND}
N 2220 3530 2220 3560 {lab=GND}
N 2210 3530 2220 3530 {lab=GND}
N 2170 3520 2170 3560 {lab=N_A5}
N 2170 3560 2170 3600 {lab=N_A5}
N 2160 3590 2210 3590 {lab=word44}
N 2210 3590 2250 3590 {lab=word44}
N 2080 3520 2080 3600 {lab=A5}
N 2070 3590 2160 3590 {lab=word44}
N 1990 3520 1990 3600 {lab=N_A4}
N 1980 3590 2070 3590 {lab=word44}
N 1940 3560 1950 3560 {lab=GND}
N 1950 3530 1950 3560 {lab=GND}
N 1940 3530 1950 3530 {lab=GND}
N 1900 3520 1900 3560 {lab=A4}
N 1900 3560 1900 3600 {lab=A4}
N 1890 3590 1940 3590 {lab=word44}
N 1940 3590 1980 3590 {lab=word44}
N 1850 3560 1860 3560 {lab=GND}
N 1860 3530 1860 3560 {lab=GND}
N 1850 3530 1860 3530 {lab=GND}
N 1810 3520 1810 3560 {lab=N_A3}
N 1810 3560 1810 3600 {lab=N_A3}
N 1800 3590 1850 3590 {lab=word44}
N 1850 3590 1890 3590 {lab=word44}
N 1720 3520 1720 3600 {lab=A3}
N 1710 3590 1800 3590 {lab=word44}
N 1670 3560 1680 3560 {lab=GND}
N 1680 3530 1680 3560 {lab=GND}
N 1670 3530 1680 3530 {lab=GND}
N 1630 3520 1630 3560 {lab=N_A2}
N 1630 3560 1630 3600 {lab=N_A2}
N 1620 3590 1670 3590 {lab=word44}
N 1670 3590 1710 3590 {lab=word44}
N 1540 3520 1540 3600 {lab=A2}
N 1530 3590 1620 3590 {lab=word44}
N 1450 3520 1450 3600 {lab=N_A1}
N 1440 3590 1530 3590 {lab=word44}
N 1400 3560 1410 3560 {lab=GND}
N 1410 3530 1410 3560 {lab=GND}
N 1400 3530 1410 3530 {lab=GND}
N 1360 3520 1360 3560 {lab=A1}
N 1360 3560 1360 3600 {lab=A1}
N 1350 3590 1400 3590 {lab=word44}
N 1400 3590 1440 3590 {lab=word44}
N 1270 3520 1270 3600 {lab=N_A0}
N 1260 3590 1350 3590 {lab=word44}
N 1220 3560 1230 3560 {lab=GND}
N 1230 3530 1230 3560 {lab=GND}
N 1220 3530 1230 3530 {lab=GND}
N 1180 3520 1180 3560 {lab=A0}
N 1180 3560 1180 3600 {lab=A0}
N 1170 3590 1220 3590 {lab=word44}
N 1220 3590 1260 3590 {lab=word44}
N 1080 3590 1170 3590 { }
N 1030 3550 1070 3550 {lab=A6}
N 1030 3590 1030 3600 {lab=VDD}
N 1060 3590 1080 3590 {lab=word44}
N 990 3590 1000 3590 {lab=#net4413}
N 1070 3520 1070 3550 {lab=A6}
N 1070 3550 1070 3600 {lab=A6}
N 980 3520 980 3600 {lab=N_A7}
N 900 3590 990 3590 {lab=#net4413}
N 850 3550 890 3550 {lab=A7}
N 850 3590 850 3600 {lab=VDD}
N 880 3590 900 3590 {lab=#net4413}
N 810 3590 820 3590 {lab=#net4415}
N 890 3520 890 3550 {lab=A7}
N 890 3550 890 3600 {lab=A7}
N 800 3520 800 3600 {lab=N_A8}
N 720 3590 810 3590 {lab=#net4415}
N 710 3520 710 3600 {lab=A8}
N 630 3590 720 3590 {lab=#net4415}
N 580 3550 620 3550 {lab=N_A9}
N 580 3590 580 3600 {lab=VDD}
N 610 3590 630 3590 {lab=#net4415}
N 540 3590 550 3590 {lab=#net4417}
N 620 3520 620 3550 {lab=N_A9}
N 620 3550 620 3600 {lab=N_A9}
N 530 3520 530 3600 {lab=A9}
N 450 3590 540 3590 {lab=#net4417}
N 400 3550 440 3550 {lab=N_A10}
N 400 3590 400 3600 {lab=VDD}
N 430 3590 450 3590 {lab=#net4417}
N 360 3590 370 3590 {lab=#net4419}
N 440 3520 440 3550 {lab=N_A10}
N 440 3550 440 3600 {lab=N_A10}
N 310 3550 350 3550 {lab=A10}
N 310 3590 310 3600 {lab=VDD}
N 340 3590 360 3590 {lab=#net4419}
N 270 3590 280 3590 {lab=#net4421}
N 350 3520 350 3550 {lab=A10}
N 350 3550 350 3600 {lab=A10}
N 260 3520 260 3600 {lab=N_A11}
N 180 3590 270 3590 {lab=#net4421}
N 170 3520 170 3600 {lab=A11}
N 90 3590 180 3590 {lab=#net4421}
N 40 3550 80 3550 {lab=N_A12}
N 40 3590 40 3600 {lab=VDD}
N 70 3590 90 3590 {lab=#net4421}
N 0 3590 10 3590 {lab=#net4423}
N 80 3520 80 3550 {lab=N_A12}
N 80 3550 80 3600 {lab=N_A12}
N 0 3520 0 3600 { }
N 2210 3640 2220 3640 {lab=GND}
N 2220 3610 2220 3640 {lab=GND}
N 2210 3610 2220 3610 {lab=GND}
N 2170 3600 2170 3640 {lab=N_A5}
N 2170 3640 2170 3680 {lab=N_A5}
N 2160 3670 2210 3670 {lab=word45}
N 2210 3670 2250 3670 {lab=word45}
N 2080 3600 2080 3680 {lab=A5}
N 2070 3670 2160 3670 {lab=word45}
N 1990 3600 1990 3680 {lab=N_A4}
N 1980 3670 2070 3670 {lab=word45}
N 1940 3640 1950 3640 {lab=GND}
N 1950 3610 1950 3640 {lab=GND}
N 1940 3610 1950 3610 {lab=GND}
N 1900 3600 1900 3640 {lab=A4}
N 1900 3640 1900 3680 {lab=A4}
N 1890 3670 1940 3670 {lab=word45}
N 1940 3670 1980 3670 {lab=word45}
N 1850 3640 1860 3640 {lab=GND}
N 1860 3610 1860 3640 {lab=GND}
N 1850 3610 1860 3610 {lab=GND}
N 1810 3600 1810 3640 {lab=N_A3}
N 1810 3640 1810 3680 {lab=N_A3}
N 1800 3670 1850 3670 {lab=word45}
N 1850 3670 1890 3670 {lab=word45}
N 1720 3600 1720 3680 {lab=A3}
N 1710 3670 1800 3670 {lab=word45}
N 1670 3640 1680 3640 {lab=GND}
N 1680 3610 1680 3640 {lab=GND}
N 1670 3610 1680 3610 {lab=GND}
N 1630 3600 1630 3640 {lab=N_A2}
N 1630 3640 1630 3680 {lab=N_A2}
N 1620 3670 1670 3670 {lab=word45}
N 1670 3670 1710 3670 {lab=word45}
N 1540 3600 1540 3680 {lab=A2}
N 1530 3670 1620 3670 {lab=word45}
N 1450 3600 1450 3680 {lab=N_A1}
N 1440 3670 1530 3670 {lab=word45}
N 1400 3640 1410 3640 {lab=GND}
N 1410 3610 1410 3640 {lab=GND}
N 1400 3610 1410 3610 {lab=GND}
N 1360 3600 1360 3640 {lab=A1}
N 1360 3640 1360 3680 {lab=A1}
N 1350 3670 1400 3670 {lab=word45}
N 1400 3670 1440 3670 {lab=word45}
N 1310 3640 1320 3640 {lab=GND}
N 1320 3610 1320 3640 {lab=GND}
N 1310 3610 1320 3610 {lab=GND}
N 1270 3600 1270 3640 {lab=N_A0}
N 1270 3640 1270 3680 {lab=N_A0}
N 1260 3670 1310 3670 {lab=word45}
N 1310 3670 1350 3670 {lab=word45}
N 1180 3600 1180 3680 {lab=A0}
N 1170 3670 1260 3670 {lab=word45}
N 1080 3670 1170 3670 { }
N 1070 3600 1070 3680 {lab=A6}
N 990 3670 1080 3670 {lab=word45}
N 940 3630 980 3630 {lab=N_A7}
N 940 3670 940 3680 {lab=VDD}
N 970 3670 990 3670 {lab=word45}
N 900 3670 910 3670 {lab=#net4513}
N 980 3600 980 3630 {lab=N_A7}
N 980 3630 980 3680 {lab=N_A7}
N 850 3630 890 3630 {lab=A7}
N 850 3670 850 3680 {lab=VDD}
N 880 3670 900 3670 {lab=#net4513}
N 810 3670 820 3670 {lab=#net4515}
N 890 3600 890 3630 {lab=A7}
N 890 3630 890 3680 {lab=A7}
N 800 3600 800 3680 {lab=N_A8}
N 720 3670 810 3670 {lab=#net4515}
N 710 3600 710 3680 {lab=A8}
N 630 3670 720 3670 {lab=#net4515}
N 580 3630 620 3630 {lab=N_A9}
N 580 3670 580 3680 {lab=VDD}
N 610 3670 630 3670 {lab=#net4515}
N 540 3670 550 3670 {lab=#net4517}
N 620 3600 620 3630 {lab=N_A9}
N 620 3630 620 3680 {lab=N_A9}
N 530 3600 530 3680 {lab=A9}
N 450 3670 540 3670 {lab=#net4517}
N 400 3630 440 3630 {lab=N_A10}
N 400 3670 400 3680 {lab=VDD}
N 430 3670 450 3670 {lab=#net4517}
N 360 3670 370 3670 {lab=#net4519}
N 440 3600 440 3630 {lab=N_A10}
N 440 3630 440 3680 {lab=N_A10}
N 310 3630 350 3630 {lab=A10}
N 310 3670 310 3680 {lab=VDD}
N 340 3670 360 3670 {lab=#net4519}
N 270 3670 280 3670 {lab=#net4521}
N 350 3600 350 3630 {lab=A10}
N 350 3630 350 3680 {lab=A10}
N 260 3600 260 3680 {lab=N_A11}
N 180 3670 270 3670 {lab=#net4521}
N 170 3600 170 3680 {lab=A11}
N 90 3670 180 3670 {lab=#net4521}
N 40 3630 80 3630 {lab=N_A12}
N 40 3670 40 3680 {lab=VDD}
N 70 3670 90 3670 {lab=#net4521}
N 0 3670 10 3670 {lab=#net4523}
N 80 3600 80 3630 {lab=N_A12}
N 80 3630 80 3680 {lab=N_A12}
N 0 3600 0 3680 { }
N 2210 3720 2220 3720 {lab=GND}
N 2220 3690 2220 3720 {lab=GND}
N 2210 3690 2220 3690 {lab=GND}
N 2170 3680 2170 3720 {lab=N_A5}
N 2170 3720 2170 3760 {lab=N_A5}
N 2160 3750 2210 3750 {lab=word46}
N 2210 3750 2250 3750 {lab=word46}
N 2080 3680 2080 3760 {lab=A5}
N 2070 3750 2160 3750 {lab=word46}
N 1990 3680 1990 3760 {lab=N_A4}
N 1980 3750 2070 3750 {lab=word46}
N 1940 3720 1950 3720 {lab=GND}
N 1950 3690 1950 3720 {lab=GND}
N 1940 3690 1950 3690 {lab=GND}
N 1900 3680 1900 3720 {lab=A4}
N 1900 3720 1900 3760 {lab=A4}
N 1890 3750 1940 3750 {lab=word46}
N 1940 3750 1980 3750 {lab=word46}
N 1850 3720 1860 3720 {lab=GND}
N 1860 3690 1860 3720 {lab=GND}
N 1850 3690 1860 3690 {lab=GND}
N 1810 3680 1810 3720 {lab=N_A3}
N 1810 3720 1810 3760 {lab=N_A3}
N 1800 3750 1850 3750 {lab=word46}
N 1850 3750 1890 3750 {lab=word46}
N 1720 3680 1720 3760 {lab=A3}
N 1710 3750 1800 3750 {lab=word46}
N 1670 3720 1680 3720 {lab=GND}
N 1680 3690 1680 3720 {lab=GND}
N 1670 3690 1680 3690 {lab=GND}
N 1630 3680 1630 3720 {lab=N_A2}
N 1630 3720 1630 3760 {lab=N_A2}
N 1620 3750 1670 3750 {lab=word46}
N 1670 3750 1710 3750 {lab=word46}
N 1540 3680 1540 3760 {lab=A2}
N 1530 3750 1620 3750 {lab=word46}
N 1490 3720 1500 3720 {lab=GND}
N 1500 3690 1500 3720 {lab=GND}
N 1490 3690 1500 3690 {lab=GND}
N 1450 3680 1450 3720 {lab=N_A1}
N 1450 3720 1450 3760 {lab=N_A1}
N 1440 3750 1490 3750 {lab=word46}
N 1490 3750 1530 3750 {lab=word46}
N 1360 3680 1360 3760 {lab=A1}
N 1350 3750 1440 3750 {lab=word46}
N 1270 3680 1270 3760 {lab=N_A0}
N 1260 3750 1350 3750 {lab=word46}
N 1220 3720 1230 3720 {lab=GND}
N 1230 3690 1230 3720 {lab=GND}
N 1220 3690 1230 3690 {lab=GND}
N 1180 3680 1180 3720 {lab=A0}
N 1180 3720 1180 3760 {lab=A0}
N 1170 3750 1220 3750 {lab=word46}
N 1220 3750 1260 3750 {lab=word46}
N 1080 3750 1170 3750 { }
N 1030 3710 1070 3710 {lab=A6}
N 1030 3750 1030 3760 {lab=VDD}
N 1060 3750 1080 3750 {lab=word46}
N 990 3750 1000 3750 {lab=#net4613}
N 1070 3680 1070 3710 {lab=A6}
N 1070 3710 1070 3760 {lab=A6}
N 980 3680 980 3760 {lab=N_A7}
N 900 3750 990 3750 {lab=#net4613}
N 890 3680 890 3760 {lab=A7}
N 810 3750 900 3750 {lab=#net4613}
N 760 3710 800 3710 {lab=N_A8}
N 760 3750 760 3760 {lab=VDD}
N 790 3750 810 3750 {lab=#net4613}
N 720 3750 730 3750 {lab=#net4615}
N 800 3680 800 3710 {lab=N_A8}
N 800 3710 800 3760 {lab=N_A8}
N 710 3680 710 3760 {lab=A8}
N 630 3750 720 3750 {lab=#net4615}
N 580 3710 620 3710 {lab=N_A9}
N 580 3750 580 3760 {lab=VDD}
N 610 3750 630 3750 {lab=#net4615}
N 540 3750 550 3750 {lab=#net4617}
N 620 3680 620 3710 {lab=N_A9}
N 620 3710 620 3760 {lab=N_A9}
N 530 3680 530 3760 {lab=A9}
N 450 3750 540 3750 {lab=#net4617}
N 400 3710 440 3710 {lab=N_A10}
N 400 3750 400 3760 {lab=VDD}
N 430 3750 450 3750 {lab=#net4617}
N 360 3750 370 3750 {lab=#net4619}
N 440 3680 440 3710 {lab=N_A10}
N 440 3710 440 3760 {lab=N_A10}
N 310 3710 350 3710 {lab=A10}
N 310 3750 310 3760 {lab=VDD}
N 340 3750 360 3750 {lab=#net4619}
N 270 3750 280 3750 {lab=#net4621}
N 350 3680 350 3710 {lab=A10}
N 350 3710 350 3760 {lab=A10}
N 260 3680 260 3760 {lab=N_A11}
N 180 3750 270 3750 {lab=#net4621}
N 170 3680 170 3760 {lab=A11}
N 90 3750 180 3750 {lab=#net4621}
N 40 3710 80 3710 {lab=N_A12}
N 40 3750 40 3760 {lab=VDD}
N 70 3750 90 3750 {lab=#net4621}
N 0 3750 10 3750 {lab=#net4623}
N 80 3680 80 3710 {lab=N_A12}
N 80 3710 80 3760 {lab=N_A12}
N 0 3680 0 3760 { }
N 2210 3800 2220 3800 {lab=GND}
N 2220 3770 2220 3800 {lab=GND}
N 2210 3770 2220 3770 {lab=GND}
N 2170 3760 2170 3800 {lab=N_A5}
N 2170 3800 2170 3840 {lab=N_A5}
N 2160 3830 2210 3830 {lab=word47}
N 2210 3830 2250 3830 {lab=word47}
N 2080 3760 2080 3840 {lab=A5}
N 2070 3830 2160 3830 {lab=word47}
N 1990 3760 1990 3840 {lab=N_A4}
N 1980 3830 2070 3830 {lab=word47}
N 1940 3800 1950 3800 {lab=GND}
N 1950 3770 1950 3800 {lab=GND}
N 1940 3770 1950 3770 {lab=GND}
N 1900 3760 1900 3800 {lab=A4}
N 1900 3800 1900 3840 {lab=A4}
N 1890 3830 1940 3830 {lab=word47}
N 1940 3830 1980 3830 {lab=word47}
N 1850 3800 1860 3800 {lab=GND}
N 1860 3770 1860 3800 {lab=GND}
N 1850 3770 1860 3770 {lab=GND}
N 1810 3760 1810 3800 {lab=N_A3}
N 1810 3800 1810 3840 {lab=N_A3}
N 1800 3830 1850 3830 {lab=word47}
N 1850 3830 1890 3830 {lab=word47}
N 1720 3760 1720 3840 {lab=A3}
N 1710 3830 1800 3830 {lab=word47}
N 1670 3800 1680 3800 {lab=GND}
N 1680 3770 1680 3800 {lab=GND}
N 1670 3770 1680 3770 {lab=GND}
N 1630 3760 1630 3800 {lab=N_A2}
N 1630 3800 1630 3840 {lab=N_A2}
N 1620 3830 1670 3830 {lab=word47}
N 1670 3830 1710 3830 {lab=word47}
N 1540 3760 1540 3840 {lab=A2}
N 1530 3830 1620 3830 {lab=word47}
N 1490 3800 1500 3800 {lab=GND}
N 1500 3770 1500 3800 {lab=GND}
N 1490 3770 1500 3770 {lab=GND}
N 1450 3760 1450 3800 {lab=N_A1}
N 1450 3800 1450 3840 {lab=N_A1}
N 1440 3830 1490 3830 {lab=word47}
N 1490 3830 1530 3830 {lab=word47}
N 1360 3760 1360 3840 {lab=A1}
N 1350 3830 1440 3830 {lab=word47}
N 1310 3800 1320 3800 {lab=GND}
N 1320 3770 1320 3800 {lab=GND}
N 1310 3770 1320 3770 {lab=GND}
N 1270 3760 1270 3800 {lab=N_A0}
N 1270 3800 1270 3840 {lab=N_A0}
N 1260 3830 1310 3830 {lab=word47}
N 1310 3830 1350 3830 {lab=word47}
N 1180 3760 1180 3840 {lab=A0}
N 1170 3830 1260 3830 {lab=word47}
N 1080 3830 1170 3830 { }
N 1070 3760 1070 3840 {lab=A6}
N 990 3830 1080 3830 {lab=word47}
N 940 3790 980 3790 {lab=N_A7}
N 940 3830 940 3840 {lab=VDD}
N 970 3830 990 3830 {lab=word47}
N 900 3830 910 3830 {lab=#net4713}
N 980 3760 980 3790 {lab=N_A7}
N 980 3790 980 3840 {lab=N_A7}
N 890 3760 890 3840 {lab=A7}
N 810 3830 900 3830 {lab=#net4713}
N 760 3790 800 3790 {lab=N_A8}
N 760 3830 760 3840 {lab=VDD}
N 790 3830 810 3830 {lab=#net4713}
N 720 3830 730 3830 {lab=#net4715}
N 800 3760 800 3790 {lab=N_A8}
N 800 3790 800 3840 {lab=N_A8}
N 710 3760 710 3840 {lab=A8}
N 630 3830 720 3830 {lab=#net4715}
N 580 3790 620 3790 {lab=N_A9}
N 580 3830 580 3840 {lab=VDD}
N 610 3830 630 3830 {lab=#net4715}
N 540 3830 550 3830 {lab=#net4717}
N 620 3760 620 3790 {lab=N_A9}
N 620 3790 620 3840 {lab=N_A9}
N 530 3760 530 3840 {lab=A9}
N 450 3830 540 3830 {lab=#net4717}
N 400 3790 440 3790 {lab=N_A10}
N 400 3830 400 3840 {lab=VDD}
N 430 3830 450 3830 {lab=#net4717}
N 360 3830 370 3830 {lab=#net4719}
N 440 3760 440 3790 {lab=N_A10}
N 440 3790 440 3840 {lab=N_A10}
N 310 3790 350 3790 {lab=A10}
N 310 3830 310 3840 {lab=VDD}
N 340 3830 360 3830 {lab=#net4719}
N 270 3830 280 3830 {lab=#net4721}
N 350 3760 350 3790 {lab=A10}
N 350 3790 350 3840 {lab=A10}
N 260 3760 260 3840 {lab=N_A11}
N 180 3830 270 3830 {lab=#net4721}
N 170 3760 170 3840 {lab=A11}
N 90 3830 180 3830 {lab=#net4721}
N 40 3790 80 3790 {lab=N_A12}
N 40 3830 40 3840 {lab=VDD}
N 70 3830 90 3830 {lab=#net4721}
N 0 3830 10 3830 {lab=#net4723}
N 80 3760 80 3790 {lab=N_A12}
N 80 3790 80 3840 {lab=N_A12}
N 0 3760 0 3840 { }
N 2210 3880 2220 3880 {lab=GND}
N 2220 3850 2220 3880 {lab=GND}
N 2210 3850 2220 3850 {lab=GND}
N 2170 3840 2170 3880 {lab=N_A5}
N 2170 3880 2170 3920 {lab=N_A5}
N 2160 3910 2210 3910 {lab=word48}
N 2210 3910 2250 3910 {lab=word48}
N 2080 3840 2080 3920 {lab=A5}
N 2070 3910 2160 3910 {lab=word48}
N 2030 3880 2040 3880 {lab=GND}
N 2040 3850 2040 3880 {lab=GND}
N 2030 3850 2040 3850 {lab=GND}
N 1990 3840 1990 3880 {lab=N_A4}
N 1990 3880 1990 3920 {lab=N_A4}
N 1980 3910 2030 3910 {lab=word48}
N 2030 3910 2070 3910 {lab=word48}
N 1900 3840 1900 3920 {lab=A4}
N 1890 3910 1980 3910 {lab=word48}
N 1810 3840 1810 3920 {lab=N_A3}
N 1800 3910 1890 3910 {lab=word48}
N 1760 3880 1770 3880 {lab=GND}
N 1770 3850 1770 3880 {lab=GND}
N 1760 3850 1770 3850 {lab=GND}
N 1720 3840 1720 3880 {lab=A3}
N 1720 3880 1720 3920 {lab=A3}
N 1710 3910 1760 3910 {lab=word48}
N 1760 3910 1800 3910 {lab=word48}
N 1630 3840 1630 3920 {lab=N_A2}
N 1620 3910 1710 3910 {lab=word48}
N 1580 3880 1590 3880 {lab=GND}
N 1590 3850 1590 3880 {lab=GND}
N 1580 3850 1590 3850 {lab=GND}
N 1540 3840 1540 3880 {lab=A2}
N 1540 3880 1540 3920 {lab=A2}
N 1530 3910 1580 3910 {lab=word48}
N 1580 3910 1620 3910 {lab=word48}
N 1450 3840 1450 3920 {lab=N_A1}
N 1440 3910 1530 3910 {lab=word48}
N 1400 3880 1410 3880 {lab=GND}
N 1410 3850 1410 3880 {lab=GND}
N 1400 3850 1410 3850 {lab=GND}
N 1360 3840 1360 3880 {lab=A1}
N 1360 3880 1360 3920 {lab=A1}
N 1350 3910 1400 3910 {lab=word48}
N 1400 3910 1440 3910 {lab=word48}
N 1270 3840 1270 3920 {lab=N_A0}
N 1260 3910 1350 3910 {lab=word48}
N 1220 3880 1230 3880 {lab=GND}
N 1230 3850 1230 3880 {lab=GND}
N 1220 3850 1230 3850 {lab=GND}
N 1180 3840 1180 3880 {lab=A0}
N 1180 3880 1180 3920 {lab=A0}
N 1170 3910 1220 3910 {lab=word48}
N 1220 3910 1260 3910 {lab=word48}
N 1080 3910 1170 3910 { }
N 1030 3870 1070 3870 {lab=A6}
N 1030 3910 1030 3920 {lab=VDD}
N 1060 3910 1080 3910 {lab=word48}
N 990 3910 1000 3910 {lab=#net4813}
N 1070 3840 1070 3870 {lab=A6}
N 1070 3870 1070 3920 {lab=A6}
N 980 3840 980 3920 {lab=N_A7}
N 900 3910 990 3910 {lab=#net4813}
N 850 3870 890 3870 {lab=A7}
N 850 3910 850 3920 {lab=VDD}
N 880 3910 900 3910 {lab=#net4813}
N 810 3910 820 3910 {lab=#net4815}
N 890 3840 890 3870 {lab=A7}
N 890 3870 890 3920 {lab=A7}
N 800 3840 800 3920 {lab=N_A8}
N 720 3910 810 3910 {lab=#net4815}
N 670 3870 710 3870 {lab=A8}
N 670 3910 670 3920 {lab=VDD}
N 700 3910 720 3910 {lab=#net4815}
N 630 3910 640 3910 {lab=#net4817}
N 710 3840 710 3870 {lab=A8}
N 710 3870 710 3920 {lab=A8}
N 620 3840 620 3920 {lab=N_A9}
N 540 3910 630 3910 {lab=#net4817}
N 490 3870 530 3870 {lab=A9}
N 490 3910 490 3920 {lab=VDD}
N 520 3910 540 3910 {lab=#net4817}
N 450 3910 460 3910 {lab=#net4819}
N 530 3840 530 3870 {lab=A9}
N 530 3870 530 3920 {lab=A9}
N 440 3840 440 3920 {lab=N_A10}
N 360 3910 450 3910 {lab=#net4819}
N 350 3840 350 3920 {lab=A10}
N 270 3910 360 3910 {lab=#net4819}
N 220 3870 260 3870 {lab=N_A11}
N 220 3910 220 3920 {lab=VDD}
N 250 3910 270 3910 {lab=#net4819}
N 180 3910 190 3910 {lab=#net4821}
N 260 3840 260 3870 {lab=N_A11}
N 260 3870 260 3920 {lab=N_A11}
N 170 3840 170 3920 {lab=A11}
N 90 3910 180 3910 {lab=#net4821}
N 40 3870 80 3870 {lab=N_A12}
N 40 3910 40 3920 {lab=VDD}
N 70 3910 90 3910 {lab=#net4821}
N 0 3910 10 3910 {lab=#net4823}
N 80 3840 80 3870 {lab=N_A12}
N 80 3870 80 3920 {lab=N_A12}
N 0 3840 0 3920 { }
N 2210 3960 2220 3960 {lab=GND}
N 2220 3930 2220 3960 {lab=GND}
N 2210 3930 2220 3930 {lab=GND}
N 2170 3920 2170 3960 {lab=N_A5}
N 2170 3960 2170 4000 {lab=N_A5}
N 2160 3990 2210 3990 {lab=word49}
N 2210 3990 2250 3990 {lab=word49}
N 2080 3920 2080 4000 {lab=A5}
N 2070 3990 2160 3990 {lab=word49}
N 2030 3960 2040 3960 {lab=GND}
N 2040 3930 2040 3960 {lab=GND}
N 2030 3930 2040 3930 {lab=GND}
N 1990 3920 1990 3960 {lab=N_A4}
N 1990 3960 1990 4000 {lab=N_A4}
N 1980 3990 2030 3990 {lab=word49}
N 2030 3990 2070 3990 {lab=word49}
N 1900 3920 1900 4000 {lab=A4}
N 1890 3990 1980 3990 {lab=word49}
N 1810 3920 1810 4000 {lab=N_A3}
N 1800 3990 1890 3990 {lab=word49}
N 1760 3960 1770 3960 {lab=GND}
N 1770 3930 1770 3960 {lab=GND}
N 1760 3930 1770 3930 {lab=GND}
N 1720 3920 1720 3960 {lab=A3}
N 1720 3960 1720 4000 {lab=A3}
N 1710 3990 1760 3990 {lab=word49}
N 1760 3990 1800 3990 {lab=word49}
N 1630 3920 1630 4000 {lab=N_A2}
N 1620 3990 1710 3990 {lab=word49}
N 1580 3960 1590 3960 {lab=GND}
N 1590 3930 1590 3960 {lab=GND}
N 1580 3930 1590 3930 {lab=GND}
N 1540 3920 1540 3960 {lab=A2}
N 1540 3960 1540 4000 {lab=A2}
N 1530 3990 1580 3990 {lab=word49}
N 1580 3990 1620 3990 {lab=word49}
N 1450 3920 1450 4000 {lab=N_A1}
N 1440 3990 1530 3990 {lab=word49}
N 1400 3960 1410 3960 {lab=GND}
N 1410 3930 1410 3960 {lab=GND}
N 1400 3930 1410 3930 {lab=GND}
N 1360 3920 1360 3960 {lab=A1}
N 1360 3960 1360 4000 {lab=A1}
N 1350 3990 1400 3990 {lab=word49}
N 1400 3990 1440 3990 {lab=word49}
N 1310 3960 1320 3960 {lab=GND}
N 1320 3930 1320 3960 {lab=GND}
N 1310 3930 1320 3930 {lab=GND}
N 1270 3920 1270 3960 {lab=N_A0}
N 1270 3960 1270 4000 {lab=N_A0}
N 1260 3990 1310 3990 {lab=word49}
N 1310 3990 1350 3990 {lab=word49}
N 1180 3920 1180 4000 {lab=A0}
N 1170 3990 1260 3990 {lab=word49}
N 1080 3990 1170 3990 { }
N 1070 3920 1070 4000 {lab=A6}
N 990 3990 1080 3990 {lab=word49}
N 940 3950 980 3950 {lab=N_A7}
N 940 3990 940 4000 {lab=VDD}
N 970 3990 990 3990 {lab=word49}
N 900 3990 910 3990 {lab=#net4913}
N 980 3920 980 3950 {lab=N_A7}
N 980 3950 980 4000 {lab=N_A7}
N 850 3950 890 3950 {lab=A7}
N 850 3990 850 4000 {lab=VDD}
N 880 3990 900 3990 {lab=#net4913}
N 810 3990 820 3990 {lab=#net4915}
N 890 3920 890 3950 {lab=A7}
N 890 3950 890 4000 {lab=A7}
N 800 3920 800 4000 {lab=N_A8}
N 720 3990 810 3990 {lab=#net4915}
N 670 3950 710 3950 {lab=A8}
N 670 3990 670 4000 {lab=VDD}
N 700 3990 720 3990 {lab=#net4915}
N 630 3990 640 3990 {lab=#net4917}
N 710 3920 710 3950 {lab=A8}
N 710 3950 710 4000 {lab=A8}
N 620 3920 620 4000 {lab=N_A9}
N 540 3990 630 3990 {lab=#net4917}
N 490 3950 530 3950 {lab=A9}
N 490 3990 490 4000 {lab=VDD}
N 520 3990 540 3990 {lab=#net4917}
N 450 3990 460 3990 {lab=#net4919}
N 530 3920 530 3950 {lab=A9}
N 530 3950 530 4000 {lab=A9}
N 440 3920 440 4000 {lab=N_A10}
N 360 3990 450 3990 {lab=#net4919}
N 350 3920 350 4000 {lab=A10}
N 270 3990 360 3990 {lab=#net4919}
N 220 3950 260 3950 {lab=N_A11}
N 220 3990 220 4000 {lab=VDD}
N 250 3990 270 3990 {lab=#net4919}
N 180 3990 190 3990 {lab=#net4921}
N 260 3920 260 3950 {lab=N_A11}
N 260 3950 260 4000 {lab=N_A11}
N 170 3920 170 4000 {lab=A11}
N 90 3990 180 3990 {lab=#net4921}
N 40 3950 80 3950 {lab=N_A12}
N 40 3990 40 4000 {lab=VDD}
N 70 3990 90 3990 {lab=#net4921}
N 0 3990 10 3990 {lab=#net4923}
N 80 3920 80 3950 {lab=N_A12}
N 80 3950 80 4000 {lab=N_A12}
N 0 3920 0 4000 { }
N 2210 4040 2220 4040 {lab=GND}
N 2220 4010 2220 4040 {lab=GND}
N 2210 4010 2220 4010 {lab=GND}
N 2170 4000 2170 4040 {lab=N_A5}
N 2170 4040 2170 4080 {lab=N_A5}
N 2160 4070 2210 4070 {lab=word50}
N 2210 4070 2250 4070 {lab=word50}
N 2080 4000 2080 4080 {lab=A5}
N 2070 4070 2160 4070 {lab=word50}
N 2030 4040 2040 4040 {lab=GND}
N 2040 4010 2040 4040 {lab=GND}
N 2030 4010 2040 4010 {lab=GND}
N 1990 4000 1990 4040 {lab=N_A4}
N 1990 4040 1990 4080 {lab=N_A4}
N 1980 4070 2030 4070 {lab=word50}
N 2030 4070 2070 4070 {lab=word50}
N 1900 4000 1900 4080 {lab=A4}
N 1890 4070 1980 4070 {lab=word50}
N 1810 4000 1810 4080 {lab=N_A3}
N 1800 4070 1890 4070 {lab=word50}
N 1760 4040 1770 4040 {lab=GND}
N 1770 4010 1770 4040 {lab=GND}
N 1760 4010 1770 4010 {lab=GND}
N 1720 4000 1720 4040 {lab=A3}
N 1720 4040 1720 4080 {lab=A3}
N 1710 4070 1760 4070 {lab=word50}
N 1760 4070 1800 4070 {lab=word50}
N 1630 4000 1630 4080 {lab=N_A2}
N 1620 4070 1710 4070 {lab=word50}
N 1580 4040 1590 4040 {lab=GND}
N 1590 4010 1590 4040 {lab=GND}
N 1580 4010 1590 4010 {lab=GND}
N 1540 4000 1540 4040 {lab=A2}
N 1540 4040 1540 4080 {lab=A2}
N 1530 4070 1580 4070 {lab=word50}
N 1580 4070 1620 4070 {lab=word50}
N 1490 4040 1500 4040 {lab=GND}
N 1500 4010 1500 4040 {lab=GND}
N 1490 4010 1500 4010 {lab=GND}
N 1450 4000 1450 4040 {lab=N_A1}
N 1450 4040 1450 4080 {lab=N_A1}
N 1440 4070 1490 4070 {lab=word50}
N 1490 4070 1530 4070 {lab=word50}
N 1360 4000 1360 4080 {lab=A1}
N 1350 4070 1440 4070 {lab=word50}
N 1270 4000 1270 4080 {lab=N_A0}
N 1260 4070 1350 4070 {lab=word50}
N 1220 4040 1230 4040 {lab=GND}
N 1230 4010 1230 4040 {lab=GND}
N 1220 4010 1230 4010 {lab=GND}
N 1180 4000 1180 4040 {lab=A0}
N 1180 4040 1180 4080 {lab=A0}
N 1170 4070 1220 4070 {lab=word50}
N 1220 4070 1260 4070 {lab=word50}
N 1080 4070 1170 4070 { }
N 1030 4030 1070 4030 {lab=A6}
N 1030 4070 1030 4080 {lab=VDD}
N 1060 4070 1080 4070 {lab=word50}
N 990 4070 1000 4070 {lab=#net5013}
N 1070 4000 1070 4030 {lab=A6}
N 1070 4030 1070 4080 {lab=A6}
N 980 4000 980 4080 {lab=N_A7}
N 900 4070 990 4070 {lab=#net5013}
N 890 4000 890 4080 {lab=A7}
N 810 4070 900 4070 {lab=#net5013}
N 760 4030 800 4030 {lab=N_A8}
N 760 4070 760 4080 {lab=VDD}
N 790 4070 810 4070 {lab=#net5013}
N 720 4070 730 4070 {lab=#net5015}
N 800 4000 800 4030 {lab=N_A8}
N 800 4030 800 4080 {lab=N_A8}
N 670 4030 710 4030 {lab=A8}
N 670 4070 670 4080 {lab=VDD}
N 700 4070 720 4070 {lab=#net5015}
N 630 4070 640 4070 {lab=#net5017}
N 710 4000 710 4030 {lab=A8}
N 710 4030 710 4080 {lab=A8}
N 620 4000 620 4080 {lab=N_A9}
N 540 4070 630 4070 {lab=#net5017}
N 490 4030 530 4030 {lab=A9}
N 490 4070 490 4080 {lab=VDD}
N 520 4070 540 4070 {lab=#net5017}
N 450 4070 460 4070 {lab=#net5019}
N 530 4000 530 4030 {lab=A9}
N 530 4030 530 4080 {lab=A9}
N 440 4000 440 4080 {lab=N_A10}
N 360 4070 450 4070 {lab=#net5019}
N 350 4000 350 4080 {lab=A10}
N 270 4070 360 4070 {lab=#net5019}
N 220 4030 260 4030 {lab=N_A11}
N 220 4070 220 4080 {lab=VDD}
N 250 4070 270 4070 {lab=#net5019}
N 180 4070 190 4070 {lab=#net5021}
N 260 4000 260 4030 {lab=N_A11}
N 260 4030 260 4080 {lab=N_A11}
N 170 4000 170 4080 {lab=A11}
N 90 4070 180 4070 {lab=#net5021}
N 40 4030 80 4030 {lab=N_A12}
N 40 4070 40 4080 {lab=VDD}
N 70 4070 90 4070 {lab=#net5021}
N 0 4070 10 4070 {lab=#net5023}
N 80 4000 80 4030 {lab=N_A12}
N 80 4030 80 4080 {lab=N_A12}
N 0 4000 0 4080 { }
N 2210 4120 2220 4120 {lab=GND}
N 2220 4090 2220 4120 {lab=GND}
N 2210 4090 2220 4090 {lab=GND}
N 2170 4080 2170 4120 {lab=N_A5}
N 2170 4120 2170 4160 {lab=N_A5}
N 2160 4150 2210 4150 {lab=word51}
N 2210 4150 2250 4150 {lab=word51}
N 2080 4080 2080 4160 {lab=A5}
N 2070 4150 2160 4150 {lab=word51}
N 2030 4120 2040 4120 {lab=GND}
N 2040 4090 2040 4120 {lab=GND}
N 2030 4090 2040 4090 {lab=GND}
N 1990 4080 1990 4120 {lab=N_A4}
N 1990 4120 1990 4160 {lab=N_A4}
N 1980 4150 2030 4150 {lab=word51}
N 2030 4150 2070 4150 {lab=word51}
N 1900 4080 1900 4160 {lab=A4}
N 1890 4150 1980 4150 {lab=word51}
N 1810 4080 1810 4160 {lab=N_A3}
N 1800 4150 1890 4150 {lab=word51}
N 1760 4120 1770 4120 {lab=GND}
N 1770 4090 1770 4120 {lab=GND}
N 1760 4090 1770 4090 {lab=GND}
N 1720 4080 1720 4120 {lab=A3}
N 1720 4120 1720 4160 {lab=A3}
N 1710 4150 1760 4150 {lab=word51}
N 1760 4150 1800 4150 {lab=word51}
N 1630 4080 1630 4160 {lab=N_A2}
N 1620 4150 1710 4150 {lab=word51}
N 1580 4120 1590 4120 {lab=GND}
N 1590 4090 1590 4120 {lab=GND}
N 1580 4090 1590 4090 {lab=GND}
N 1540 4080 1540 4120 {lab=A2}
N 1540 4120 1540 4160 {lab=A2}
N 1530 4150 1580 4150 {lab=word51}
N 1580 4150 1620 4150 {lab=word51}
N 1490 4120 1500 4120 {lab=GND}
N 1500 4090 1500 4120 {lab=GND}
N 1490 4090 1500 4090 {lab=GND}
N 1450 4080 1450 4120 {lab=N_A1}
N 1450 4120 1450 4160 {lab=N_A1}
N 1440 4150 1490 4150 {lab=word51}
N 1490 4150 1530 4150 {lab=word51}
N 1360 4080 1360 4160 {lab=A1}
N 1350 4150 1440 4150 {lab=word51}
N 1310 4120 1320 4120 {lab=GND}
N 1320 4090 1320 4120 {lab=GND}
N 1310 4090 1320 4090 {lab=GND}
N 1270 4080 1270 4120 {lab=N_A0}
N 1270 4120 1270 4160 {lab=N_A0}
N 1260 4150 1310 4150 {lab=word51}
N 1310 4150 1350 4150 {lab=word51}
N 1180 4080 1180 4160 {lab=A0}
N 1170 4150 1260 4150 {lab=word51}
N 1080 4150 1170 4150 { }
N 1070 4080 1070 4160 {lab=A6}
N 990 4150 1080 4150 {lab=word51}
N 940 4110 980 4110 {lab=N_A7}
N 940 4150 940 4160 {lab=VDD}
N 970 4150 990 4150 {lab=word51}
N 900 4150 910 4150 {lab=#net5113}
N 980 4080 980 4110 {lab=N_A7}
N 980 4110 980 4160 {lab=N_A7}
N 890 4080 890 4160 {lab=A7}
N 810 4150 900 4150 {lab=#net5113}
N 760 4110 800 4110 {lab=N_A8}
N 760 4150 760 4160 {lab=VDD}
N 790 4150 810 4150 {lab=#net5113}
N 720 4150 730 4150 {lab=#net5115}
N 800 4080 800 4110 {lab=N_A8}
N 800 4110 800 4160 {lab=N_A8}
N 670 4110 710 4110 {lab=A8}
N 670 4150 670 4160 {lab=VDD}
N 700 4150 720 4150 {lab=#net5115}
N 630 4150 640 4150 {lab=#net5117}
N 710 4080 710 4110 {lab=A8}
N 710 4110 710 4160 {lab=A8}
N 620 4080 620 4160 {lab=N_A9}
N 540 4150 630 4150 {lab=#net5117}
N 490 4110 530 4110 {lab=A9}
N 490 4150 490 4160 {lab=VDD}
N 520 4150 540 4150 {lab=#net5117}
N 450 4150 460 4150 {lab=#net5119}
N 530 4080 530 4110 {lab=A9}
N 530 4110 530 4160 {lab=A9}
N 440 4080 440 4160 {lab=N_A10}
N 360 4150 450 4150 {lab=#net5119}
N 350 4080 350 4160 {lab=A10}
N 270 4150 360 4150 {lab=#net5119}
N 220 4110 260 4110 {lab=N_A11}
N 220 4150 220 4160 {lab=VDD}
N 250 4150 270 4150 {lab=#net5119}
N 180 4150 190 4150 {lab=#net5121}
N 260 4080 260 4110 {lab=N_A11}
N 260 4110 260 4160 {lab=N_A11}
N 170 4080 170 4160 {lab=A11}
N 90 4150 180 4150 {lab=#net5121}
N 40 4110 80 4110 {lab=N_A12}
N 40 4150 40 4160 {lab=VDD}
N 70 4150 90 4150 {lab=#net5121}
N 0 4150 10 4150 {lab=#net5123}
N 80 4080 80 4110 {lab=N_A12}
N 80 4110 80 4160 {lab=N_A12}
N 0 4080 0 4160 { }
N 2210 4200 2220 4200 {lab=GND}
N 2220 4170 2220 4200 {lab=GND}
N 2210 4170 2220 4170 {lab=GND}
N 2170 4160 2170 4200 {lab=N_A5}
N 2170 4200 2170 4240 {lab=N_A5}
N 2160 4230 2210 4230 {lab=word52}
N 2210 4230 2250 4230 {lab=word52}
N 2080 4160 2080 4240 {lab=A5}
N 2070 4230 2160 4230 {lab=word52}
N 2030 4200 2040 4200 {lab=GND}
N 2040 4170 2040 4200 {lab=GND}
N 2030 4170 2040 4170 {lab=GND}
N 1990 4160 1990 4200 {lab=N_A4}
N 1990 4200 1990 4240 {lab=N_A4}
N 1980 4230 2030 4230 {lab=word52}
N 2030 4230 2070 4230 {lab=word52}
N 1900 4160 1900 4240 {lab=A4}
N 1890 4230 1980 4230 {lab=word52}
N 1810 4160 1810 4240 {lab=N_A3}
N 1800 4230 1890 4230 {lab=word52}
N 1760 4200 1770 4200 {lab=GND}
N 1770 4170 1770 4200 {lab=GND}
N 1760 4170 1770 4170 {lab=GND}
N 1720 4160 1720 4200 {lab=A3}
N 1720 4200 1720 4240 {lab=A3}
N 1710 4230 1760 4230 {lab=word52}
N 1760 4230 1800 4230 {lab=word52}
N 1670 4200 1680 4200 {lab=GND}
N 1680 4170 1680 4200 {lab=GND}
N 1670 4170 1680 4170 {lab=GND}
N 1630 4160 1630 4200 {lab=N_A2}
N 1630 4200 1630 4240 {lab=N_A2}
N 1620 4230 1670 4230 {lab=word52}
N 1670 4230 1710 4230 {lab=word52}
N 1540 4160 1540 4240 {lab=A2}
N 1530 4230 1620 4230 {lab=word52}
N 1450 4160 1450 4240 {lab=N_A1}
N 1440 4230 1530 4230 {lab=word52}
N 1400 4200 1410 4200 {lab=GND}
N 1410 4170 1410 4200 {lab=GND}
N 1400 4170 1410 4170 {lab=GND}
N 1360 4160 1360 4200 {lab=A1}
N 1360 4200 1360 4240 {lab=A1}
N 1350 4230 1400 4230 {lab=word52}
N 1400 4230 1440 4230 {lab=word52}
N 1270 4160 1270 4240 {lab=N_A0}
N 1260 4230 1350 4230 {lab=word52}
N 1220 4200 1230 4200 {lab=GND}
N 1230 4170 1230 4200 {lab=GND}
N 1220 4170 1230 4170 {lab=GND}
N 1180 4160 1180 4200 {lab=A0}
N 1180 4200 1180 4240 {lab=A0}
N 1170 4230 1220 4230 {lab=word52}
N 1220 4230 1260 4230 {lab=word52}
N 1080 4230 1170 4230 { }
N 1030 4190 1070 4190 {lab=A6}
N 1030 4230 1030 4240 {lab=VDD}
N 1060 4230 1080 4230 {lab=word52}
N 990 4230 1000 4230 {lab=#net5213}
N 1070 4160 1070 4190 {lab=A6}
N 1070 4190 1070 4240 {lab=A6}
N 980 4160 980 4240 {lab=N_A7}
N 900 4230 990 4230 {lab=#net5213}
N 850 4190 890 4190 {lab=A7}
N 850 4230 850 4240 {lab=VDD}
N 880 4230 900 4230 {lab=#net5213}
N 810 4230 820 4230 {lab=#net5215}
N 890 4160 890 4190 {lab=A7}
N 890 4190 890 4240 {lab=A7}
N 800 4160 800 4240 {lab=N_A8}
N 720 4230 810 4230 {lab=#net5215}
N 710 4160 710 4240 {lab=A8}
N 630 4230 720 4230 {lab=#net5215}
N 580 4190 620 4190 {lab=N_A9}
N 580 4230 580 4240 {lab=VDD}
N 610 4230 630 4230 {lab=#net5215}
N 540 4230 550 4230 {lab=#net5217}
N 620 4160 620 4190 {lab=N_A9}
N 620 4190 620 4240 {lab=N_A9}
N 490 4190 530 4190 {lab=A9}
N 490 4230 490 4240 {lab=VDD}
N 520 4230 540 4230 {lab=#net5217}
N 450 4230 460 4230 {lab=#net5219}
N 530 4160 530 4190 {lab=A9}
N 530 4190 530 4240 {lab=A9}
N 440 4160 440 4240 {lab=N_A10}
N 360 4230 450 4230 {lab=#net5219}
N 350 4160 350 4240 {lab=A10}
N 270 4230 360 4230 {lab=#net5219}
N 220 4190 260 4190 {lab=N_A11}
N 220 4230 220 4240 {lab=VDD}
N 250 4230 270 4230 {lab=#net5219}
N 180 4230 190 4230 {lab=#net5221}
N 260 4160 260 4190 {lab=N_A11}
N 260 4190 260 4240 {lab=N_A11}
N 170 4160 170 4240 {lab=A11}
N 90 4230 180 4230 {lab=#net5221}
N 40 4190 80 4190 {lab=N_A12}
N 40 4230 40 4240 {lab=VDD}
N 70 4230 90 4230 {lab=#net5221}
N 0 4230 10 4230 {lab=#net5223}
N 80 4160 80 4190 {lab=N_A12}
N 80 4190 80 4240 {lab=N_A12}
N 0 4160 0 4240 { }
N 2210 4280 2220 4280 {lab=GND}
N 2220 4250 2220 4280 {lab=GND}
N 2210 4250 2220 4250 {lab=GND}
N 2170 4240 2170 4280 {lab=N_A5}
N 2170 4280 2170 4320 {lab=N_A5}
N 2160 4310 2210 4310 {lab=word53}
N 2210 4310 2250 4310 {lab=word53}
N 2080 4240 2080 4320 {lab=A5}
N 2070 4310 2160 4310 {lab=word53}
N 2030 4280 2040 4280 {lab=GND}
N 2040 4250 2040 4280 {lab=GND}
N 2030 4250 2040 4250 {lab=GND}
N 1990 4240 1990 4280 {lab=N_A4}
N 1990 4280 1990 4320 {lab=N_A4}
N 1980 4310 2030 4310 {lab=word53}
N 2030 4310 2070 4310 {lab=word53}
N 1900 4240 1900 4320 {lab=A4}
N 1890 4310 1980 4310 {lab=word53}
N 1810 4240 1810 4320 {lab=N_A3}
N 1800 4310 1890 4310 {lab=word53}
N 1760 4280 1770 4280 {lab=GND}
N 1770 4250 1770 4280 {lab=GND}
N 1760 4250 1770 4250 {lab=GND}
N 1720 4240 1720 4280 {lab=A3}
N 1720 4280 1720 4320 {lab=A3}
N 1710 4310 1760 4310 {lab=word53}
N 1760 4310 1800 4310 {lab=word53}
N 1670 4280 1680 4280 {lab=GND}
N 1680 4250 1680 4280 {lab=GND}
N 1670 4250 1680 4250 {lab=GND}
N 1630 4240 1630 4280 {lab=N_A2}
N 1630 4280 1630 4320 {lab=N_A2}
N 1620 4310 1670 4310 {lab=word53}
N 1670 4310 1710 4310 {lab=word53}
N 1540 4240 1540 4320 {lab=A2}
N 1530 4310 1620 4310 {lab=word53}
N 1450 4240 1450 4320 {lab=N_A1}
N 1440 4310 1530 4310 {lab=word53}
N 1400 4280 1410 4280 {lab=GND}
N 1410 4250 1410 4280 {lab=GND}
N 1400 4250 1410 4250 {lab=GND}
N 1360 4240 1360 4280 {lab=A1}
N 1360 4280 1360 4320 {lab=A1}
N 1350 4310 1400 4310 {lab=word53}
N 1400 4310 1440 4310 {lab=word53}
N 1310 4280 1320 4280 {lab=GND}
N 1320 4250 1320 4280 {lab=GND}
N 1310 4250 1320 4250 {lab=GND}
N 1270 4240 1270 4280 {lab=N_A0}
N 1270 4280 1270 4320 {lab=N_A0}
N 1260 4310 1310 4310 {lab=word53}
N 1310 4310 1350 4310 {lab=word53}
N 1180 4240 1180 4320 {lab=A0}
N 1170 4310 1260 4310 {lab=word53}
N 1080 4310 1170 4310 { }
N 1070 4240 1070 4320 {lab=A6}
N 990 4310 1080 4310 {lab=word53}
N 940 4270 980 4270 {lab=N_A7}
N 940 4310 940 4320 {lab=VDD}
N 970 4310 990 4310 {lab=word53}
N 900 4310 910 4310 {lab=#net5313}
N 980 4240 980 4270 {lab=N_A7}
N 980 4270 980 4320 {lab=N_A7}
N 850 4270 890 4270 {lab=A7}
N 850 4310 850 4320 {lab=VDD}
N 880 4310 900 4310 {lab=#net5313}
N 810 4310 820 4310 {lab=#net5315}
N 890 4240 890 4270 {lab=A7}
N 890 4270 890 4320 {lab=A7}
N 800 4240 800 4320 {lab=N_A8}
N 720 4310 810 4310 {lab=#net5315}
N 710 4240 710 4320 {lab=A8}
N 630 4310 720 4310 {lab=#net5315}
N 580 4270 620 4270 {lab=N_A9}
N 580 4310 580 4320 {lab=VDD}
N 610 4310 630 4310 {lab=#net5315}
N 540 4310 550 4310 {lab=#net5317}
N 620 4240 620 4270 {lab=N_A9}
N 620 4270 620 4320 {lab=N_A9}
N 490 4270 530 4270 {lab=A9}
N 490 4310 490 4320 {lab=VDD}
N 520 4310 540 4310 {lab=#net5317}
N 450 4310 460 4310 {lab=#net5319}
N 530 4240 530 4270 {lab=A9}
N 530 4270 530 4320 {lab=A9}
N 440 4240 440 4320 {lab=N_A10}
N 360 4310 450 4310 {lab=#net5319}
N 350 4240 350 4320 {lab=A10}
N 270 4310 360 4310 {lab=#net5319}
N 220 4270 260 4270 {lab=N_A11}
N 220 4310 220 4320 {lab=VDD}
N 250 4310 270 4310 {lab=#net5319}
N 180 4310 190 4310 {lab=#net5321}
N 260 4240 260 4270 {lab=N_A11}
N 260 4270 260 4320 {lab=N_A11}
N 170 4240 170 4320 {lab=A11}
N 90 4310 180 4310 {lab=#net5321}
N 40 4270 80 4270 {lab=N_A12}
N 40 4310 40 4320 {lab=VDD}
N 70 4310 90 4310 {lab=#net5321}
N 0 4310 10 4310 {lab=#net5323}
N 80 4240 80 4270 {lab=N_A12}
N 80 4270 80 4320 {lab=N_A12}
N 0 4240 0 4320 { }
N 2210 4360 2220 4360 {lab=GND}
N 2220 4330 2220 4360 {lab=GND}
N 2210 4330 2220 4330 {lab=GND}
N 2170 4320 2170 4360 {lab=N_A5}
N 2170 4360 2170 4400 {lab=N_A5}
N 2160 4390 2210 4390 {lab=word54}
N 2210 4390 2250 4390 {lab=word54}
N 2080 4320 2080 4400 {lab=A5}
N 2070 4390 2160 4390 {lab=word54}
N 2030 4360 2040 4360 {lab=GND}
N 2040 4330 2040 4360 {lab=GND}
N 2030 4330 2040 4330 {lab=GND}
N 1990 4320 1990 4360 {lab=N_A4}
N 1990 4360 1990 4400 {lab=N_A4}
N 1980 4390 2030 4390 {lab=word54}
N 2030 4390 2070 4390 {lab=word54}
N 1900 4320 1900 4400 {lab=A4}
N 1890 4390 1980 4390 {lab=word54}
N 1810 4320 1810 4400 {lab=N_A3}
N 1800 4390 1890 4390 {lab=word54}
N 1760 4360 1770 4360 {lab=GND}
N 1770 4330 1770 4360 {lab=GND}
N 1760 4330 1770 4330 {lab=GND}
N 1720 4320 1720 4360 {lab=A3}
N 1720 4360 1720 4400 {lab=A3}
N 1710 4390 1760 4390 {lab=word54}
N 1760 4390 1800 4390 {lab=word54}
N 1670 4360 1680 4360 {lab=GND}
N 1680 4330 1680 4360 {lab=GND}
N 1670 4330 1680 4330 {lab=GND}
N 1630 4320 1630 4360 {lab=N_A2}
N 1630 4360 1630 4400 {lab=N_A2}
N 1620 4390 1670 4390 {lab=word54}
N 1670 4390 1710 4390 {lab=word54}
N 1540 4320 1540 4400 {lab=A2}
N 1530 4390 1620 4390 {lab=word54}
N 1490 4360 1500 4360 {lab=GND}
N 1500 4330 1500 4360 {lab=GND}
N 1490 4330 1500 4330 {lab=GND}
N 1450 4320 1450 4360 {lab=N_A1}
N 1450 4360 1450 4400 {lab=N_A1}
N 1440 4390 1490 4390 {lab=word54}
N 1490 4390 1530 4390 {lab=word54}
N 1360 4320 1360 4400 {lab=A1}
N 1350 4390 1440 4390 {lab=word54}
N 1270 4320 1270 4400 {lab=N_A0}
N 1260 4390 1350 4390 {lab=word54}
N 1220 4360 1230 4360 {lab=GND}
N 1230 4330 1230 4360 {lab=GND}
N 1220 4330 1230 4330 {lab=GND}
N 1180 4320 1180 4360 {lab=A0}
N 1180 4360 1180 4400 {lab=A0}
N 1170 4390 1220 4390 {lab=word54}
N 1220 4390 1260 4390 {lab=word54}
N 1080 4390 1170 4390 { }
N 1030 4350 1070 4350 {lab=A6}
N 1030 4390 1030 4400 {lab=VDD}
N 1060 4390 1080 4390 {lab=word54}
N 990 4390 1000 4390 {lab=#net5413}
N 1070 4320 1070 4350 {lab=A6}
N 1070 4350 1070 4400 {lab=A6}
N 980 4320 980 4400 {lab=N_A7}
N 900 4390 990 4390 {lab=#net5413}
N 890 4320 890 4400 {lab=A7}
N 810 4390 900 4390 {lab=#net5413}
N 760 4350 800 4350 {lab=N_A8}
N 760 4390 760 4400 {lab=VDD}
N 790 4390 810 4390 {lab=#net5413}
N 720 4390 730 4390 {lab=#net5415}
N 800 4320 800 4350 {lab=N_A8}
N 800 4350 800 4400 {lab=N_A8}
N 710 4320 710 4400 {lab=A8}
N 630 4390 720 4390 {lab=#net5415}
N 580 4350 620 4350 {lab=N_A9}
N 580 4390 580 4400 {lab=VDD}
N 610 4390 630 4390 {lab=#net5415}
N 540 4390 550 4390 {lab=#net5417}
N 620 4320 620 4350 {lab=N_A9}
N 620 4350 620 4400 {lab=N_A9}
N 490 4350 530 4350 {lab=A9}
N 490 4390 490 4400 {lab=VDD}
N 520 4390 540 4390 {lab=#net5417}
N 450 4390 460 4390 {lab=#net5419}
N 530 4320 530 4350 {lab=A9}
N 530 4350 530 4400 {lab=A9}
N 440 4320 440 4400 {lab=N_A10}
N 360 4390 450 4390 {lab=#net5419}
N 350 4320 350 4400 {lab=A10}
N 270 4390 360 4390 {lab=#net5419}
N 220 4350 260 4350 {lab=N_A11}
N 220 4390 220 4400 {lab=VDD}
N 250 4390 270 4390 {lab=#net5419}
N 180 4390 190 4390 {lab=#net5421}
N 260 4320 260 4350 {lab=N_A11}
N 260 4350 260 4400 {lab=N_A11}
N 170 4320 170 4400 {lab=A11}
N 90 4390 180 4390 {lab=#net5421}
N 40 4350 80 4350 {lab=N_A12}
N 40 4390 40 4400 {lab=VDD}
N 70 4390 90 4390 {lab=#net5421}
N 0 4390 10 4390 {lab=#net5423}
N 80 4320 80 4350 {lab=N_A12}
N 80 4350 80 4400 {lab=N_A12}
N 0 4320 0 4400 { }
N 2210 4440 2220 4440 {lab=GND}
N 2220 4410 2220 4440 {lab=GND}
N 2210 4410 2220 4410 {lab=GND}
N 2170 4400 2170 4440 {lab=N_A5}
N 2170 4440 2170 4480 {lab=N_A5}
N 2160 4470 2210 4470 {lab=word55}
N 2210 4470 2250 4470 {lab=word55}
N 2080 4400 2080 4480 {lab=A5}
N 2070 4470 2160 4470 {lab=word55}
N 2030 4440 2040 4440 {lab=GND}
N 2040 4410 2040 4440 {lab=GND}
N 2030 4410 2040 4410 {lab=GND}
N 1990 4400 1990 4440 {lab=N_A4}
N 1990 4440 1990 4480 {lab=N_A4}
N 1980 4470 2030 4470 {lab=word55}
N 2030 4470 2070 4470 {lab=word55}
N 1900 4400 1900 4480 {lab=A4}
N 1890 4470 1980 4470 {lab=word55}
N 1810 4400 1810 4480 {lab=N_A3}
N 1800 4470 1890 4470 {lab=word55}
N 1760 4440 1770 4440 {lab=GND}
N 1770 4410 1770 4440 {lab=GND}
N 1760 4410 1770 4410 {lab=GND}
N 1720 4400 1720 4440 {lab=A3}
N 1720 4440 1720 4480 {lab=A3}
N 1710 4470 1760 4470 {lab=word55}
N 1760 4470 1800 4470 {lab=word55}
N 1670 4440 1680 4440 {lab=GND}
N 1680 4410 1680 4440 {lab=GND}
N 1670 4410 1680 4410 {lab=GND}
N 1630 4400 1630 4440 {lab=N_A2}
N 1630 4440 1630 4480 {lab=N_A2}
N 1620 4470 1670 4470 {lab=word55}
N 1670 4470 1710 4470 {lab=word55}
N 1540 4400 1540 4480 {lab=A2}
N 1530 4470 1620 4470 {lab=word55}
N 1490 4440 1500 4440 {lab=GND}
N 1500 4410 1500 4440 {lab=GND}
N 1490 4410 1500 4410 {lab=GND}
N 1450 4400 1450 4440 {lab=N_A1}
N 1450 4440 1450 4480 {lab=N_A1}
N 1440 4470 1490 4470 {lab=word55}
N 1490 4470 1530 4470 {lab=word55}
N 1360 4400 1360 4480 {lab=A1}
N 1350 4470 1440 4470 {lab=word55}
N 1310 4440 1320 4440 {lab=GND}
N 1320 4410 1320 4440 {lab=GND}
N 1310 4410 1320 4410 {lab=GND}
N 1270 4400 1270 4440 {lab=N_A0}
N 1270 4440 1270 4480 {lab=N_A0}
N 1260 4470 1310 4470 {lab=word55}
N 1310 4470 1350 4470 {lab=word55}
N 1180 4400 1180 4480 {lab=A0}
N 1170 4470 1260 4470 {lab=word55}
N 1080 4470 1170 4470 { }
N 1070 4400 1070 4480 {lab=A6}
N 990 4470 1080 4470 {lab=word55}
N 940 4430 980 4430 {lab=N_A7}
N 940 4470 940 4480 {lab=VDD}
N 970 4470 990 4470 {lab=word55}
N 900 4470 910 4470 {lab=#net5513}
N 980 4400 980 4430 {lab=N_A7}
N 980 4430 980 4480 {lab=N_A7}
N 890 4400 890 4480 {lab=A7}
N 810 4470 900 4470 {lab=#net5513}
N 760 4430 800 4430 {lab=N_A8}
N 760 4470 760 4480 {lab=VDD}
N 790 4470 810 4470 {lab=#net5513}
N 720 4470 730 4470 {lab=#net5515}
N 800 4400 800 4430 {lab=N_A8}
N 800 4430 800 4480 {lab=N_A8}
N 710 4400 710 4480 {lab=A8}
N 630 4470 720 4470 {lab=#net5515}
N 580 4430 620 4430 {lab=N_A9}
N 580 4470 580 4480 {lab=VDD}
N 610 4470 630 4470 {lab=#net5515}
N 540 4470 550 4470 {lab=#net5517}
N 620 4400 620 4430 {lab=N_A9}
N 620 4430 620 4480 {lab=N_A9}
N 490 4430 530 4430 {lab=A9}
N 490 4470 490 4480 {lab=VDD}
N 520 4470 540 4470 {lab=#net5517}
N 450 4470 460 4470 {lab=#net5519}
N 530 4400 530 4430 {lab=A9}
N 530 4430 530 4480 {lab=A9}
N 440 4400 440 4480 {lab=N_A10}
N 360 4470 450 4470 {lab=#net5519}
N 350 4400 350 4480 {lab=A10}
N 270 4470 360 4470 {lab=#net5519}
N 220 4430 260 4430 {lab=N_A11}
N 220 4470 220 4480 {lab=VDD}
N 250 4470 270 4470 {lab=#net5519}
N 180 4470 190 4470 {lab=#net5521}
N 260 4400 260 4430 {lab=N_A11}
N 260 4430 260 4480 {lab=N_A11}
N 170 4400 170 4480 {lab=A11}
N 90 4470 180 4470 {lab=#net5521}
N 40 4430 80 4430 {lab=N_A12}
N 40 4470 40 4480 {lab=VDD}
N 70 4470 90 4470 {lab=#net5521}
N 0 4470 10 4470 {lab=#net5523}
N 80 4400 80 4430 {lab=N_A12}
N 80 4430 80 4480 {lab=N_A12}
N 0 4400 0 4480 { }
N 2210 4520 2220 4520 {lab=GND}
N 2220 4490 2220 4520 {lab=GND}
N 2210 4490 2220 4490 {lab=GND}
N 2170 4480 2170 4520 {lab=N_A5}
N 2170 4520 2170 4560 {lab=N_A5}
N 2160 4550 2210 4550 {lab=word56}
N 2210 4550 2250 4550 {lab=word56}
N 2080 4480 2080 4560 {lab=A5}
N 2070 4550 2160 4550 {lab=word56}
N 2030 4520 2040 4520 {lab=GND}
N 2040 4490 2040 4520 {lab=GND}
N 2030 4490 2040 4490 {lab=GND}
N 1990 4480 1990 4520 {lab=N_A4}
N 1990 4520 1990 4560 {lab=N_A4}
N 1980 4550 2030 4550 {lab=word56}
N 2030 4550 2070 4550 {lab=word56}
N 1900 4480 1900 4560 {lab=A4}
N 1890 4550 1980 4550 {lab=word56}
N 1850 4520 1860 4520 {lab=GND}
N 1860 4490 1860 4520 {lab=GND}
N 1850 4490 1860 4490 {lab=GND}
N 1810 4480 1810 4520 {lab=N_A3}
N 1810 4520 1810 4560 {lab=N_A3}
N 1800 4550 1850 4550 {lab=word56}
N 1850 4550 1890 4550 {lab=word56}
N 1720 4480 1720 4560 {lab=A3}
N 1710 4550 1800 4550 {lab=word56}
N 1630 4480 1630 4560 {lab=N_A2}
N 1620 4550 1710 4550 {lab=word56}
N 1580 4520 1590 4520 {lab=GND}
N 1590 4490 1590 4520 {lab=GND}
N 1580 4490 1590 4490 {lab=GND}
N 1540 4480 1540 4520 {lab=A2}
N 1540 4520 1540 4560 {lab=A2}
N 1530 4550 1580 4550 {lab=word56}
N 1580 4550 1620 4550 {lab=word56}
N 1450 4480 1450 4560 {lab=N_A1}
N 1440 4550 1530 4550 {lab=word56}
N 1400 4520 1410 4520 {lab=GND}
N 1410 4490 1410 4520 {lab=GND}
N 1400 4490 1410 4490 {lab=GND}
N 1360 4480 1360 4520 {lab=A1}
N 1360 4520 1360 4560 {lab=A1}
N 1350 4550 1400 4550 {lab=word56}
N 1400 4550 1440 4550 {lab=word56}
N 1270 4480 1270 4560 {lab=N_A0}
N 1260 4550 1350 4550 {lab=word56}
N 1220 4520 1230 4520 {lab=GND}
N 1230 4490 1230 4520 {lab=GND}
N 1220 4490 1230 4490 {lab=GND}
N 1180 4480 1180 4520 {lab=A0}
N 1180 4520 1180 4560 {lab=A0}
N 1170 4550 1220 4550 {lab=word56}
N 1220 4550 1260 4550 {lab=word56}
N 1080 4550 1170 4550 { }
N 1030 4510 1070 4510 {lab=A6}
N 1030 4550 1030 4560 {lab=VDD}
N 1060 4550 1080 4550 {lab=word56}
N 990 4550 1000 4550 {lab=#net5613}
N 1070 4480 1070 4510 {lab=A6}
N 1070 4510 1070 4560 {lab=A6}
N 980 4480 980 4560 {lab=N_A7}
N 900 4550 990 4550 {lab=#net5613}
N 850 4510 890 4510 {lab=A7}
N 850 4550 850 4560 {lab=VDD}
N 880 4550 900 4550 {lab=#net5613}
N 810 4550 820 4550 {lab=#net5615}
N 890 4480 890 4510 {lab=A7}
N 890 4510 890 4560 {lab=A7}
N 800 4480 800 4560 {lab=N_A8}
N 720 4550 810 4550 {lab=#net5615}
N 670 4510 710 4510 {lab=A8}
N 670 4550 670 4560 {lab=VDD}
N 700 4550 720 4550 {lab=#net5615}
N 630 4550 640 4550 {lab=#net5617}
N 710 4480 710 4510 {lab=A8}
N 710 4510 710 4560 {lab=A8}
N 620 4480 620 4560 {lab=N_A9}
N 540 4550 630 4550 {lab=#net5617}
N 530 4480 530 4560 {lab=A9}
N 450 4550 540 4550 {lab=#net5617}
N 400 4510 440 4510 {lab=N_A10}
N 400 4550 400 4560 {lab=VDD}
N 430 4550 450 4550 {lab=#net5617}
N 360 4550 370 4550 {lab=#net5619}
N 440 4480 440 4510 {lab=N_A10}
N 440 4510 440 4560 {lab=N_A10}
N 350 4480 350 4560 {lab=A10}
N 270 4550 360 4550 {lab=#net5619}
N 220 4510 260 4510 {lab=N_A11}
N 220 4550 220 4560 {lab=VDD}
N 250 4550 270 4550 {lab=#net5619}
N 180 4550 190 4550 {lab=#net5621}
N 260 4480 260 4510 {lab=N_A11}
N 260 4510 260 4560 {lab=N_A11}
N 170 4480 170 4560 {lab=A11}
N 90 4550 180 4550 {lab=#net5621}
N 40 4510 80 4510 {lab=N_A12}
N 40 4550 40 4560 {lab=VDD}
N 70 4550 90 4550 {lab=#net5621}
N 0 4550 10 4550 {lab=#net5623}
N 80 4480 80 4510 {lab=N_A12}
N 80 4510 80 4560 {lab=N_A12}
N 0 4480 0 4560 { }
N 2210 4600 2220 4600 {lab=GND}
N 2220 4570 2220 4600 {lab=GND}
N 2210 4570 2220 4570 {lab=GND}
N 2170 4560 2170 4600 {lab=N_A5}
N 2170 4600 2170 4640 {lab=N_A5}
N 2160 4630 2210 4630 {lab=word57}
N 2210 4630 2250 4630 {lab=word57}
N 2080 4560 2080 4640 {lab=A5}
N 2070 4630 2160 4630 {lab=word57}
N 2030 4600 2040 4600 {lab=GND}
N 2040 4570 2040 4600 {lab=GND}
N 2030 4570 2040 4570 {lab=GND}
N 1990 4560 1990 4600 {lab=N_A4}
N 1990 4600 1990 4640 {lab=N_A4}
N 1980 4630 2030 4630 {lab=word57}
N 2030 4630 2070 4630 {lab=word57}
N 1900 4560 1900 4640 {lab=A4}
N 1890 4630 1980 4630 {lab=word57}
N 1850 4600 1860 4600 {lab=GND}
N 1860 4570 1860 4600 {lab=GND}
N 1850 4570 1860 4570 {lab=GND}
N 1810 4560 1810 4600 {lab=N_A3}
N 1810 4600 1810 4640 {lab=N_A3}
N 1800 4630 1850 4630 {lab=word57}
N 1850 4630 1890 4630 {lab=word57}
N 1720 4560 1720 4640 {lab=A3}
N 1710 4630 1800 4630 {lab=word57}
N 1630 4560 1630 4640 {lab=N_A2}
N 1620 4630 1710 4630 {lab=word57}
N 1580 4600 1590 4600 {lab=GND}
N 1590 4570 1590 4600 {lab=GND}
N 1580 4570 1590 4570 {lab=GND}
N 1540 4560 1540 4600 {lab=A2}
N 1540 4600 1540 4640 {lab=A2}
N 1530 4630 1580 4630 {lab=word57}
N 1580 4630 1620 4630 {lab=word57}
N 1450 4560 1450 4640 {lab=N_A1}
N 1440 4630 1530 4630 {lab=word57}
N 1400 4600 1410 4600 {lab=GND}
N 1410 4570 1410 4600 {lab=GND}
N 1400 4570 1410 4570 {lab=GND}
N 1360 4560 1360 4600 {lab=A1}
N 1360 4600 1360 4640 {lab=A1}
N 1350 4630 1400 4630 {lab=word57}
N 1400 4630 1440 4630 {lab=word57}
N 1310 4600 1320 4600 {lab=GND}
N 1320 4570 1320 4600 {lab=GND}
N 1310 4570 1320 4570 {lab=GND}
N 1270 4560 1270 4600 {lab=N_A0}
N 1270 4600 1270 4640 {lab=N_A0}
N 1260 4630 1310 4630 {lab=word57}
N 1310 4630 1350 4630 {lab=word57}
N 1180 4560 1180 4640 {lab=A0}
N 1170 4630 1260 4630 {lab=word57}
N 1080 4630 1170 4630 { }
N 1070 4560 1070 4640 {lab=A6}
N 990 4630 1080 4630 {lab=word57}
N 940 4590 980 4590 {lab=N_A7}
N 940 4630 940 4640 {lab=VDD}
N 970 4630 990 4630 {lab=word57}
N 900 4630 910 4630 {lab=#net5713}
N 980 4560 980 4590 {lab=N_A7}
N 980 4590 980 4640 {lab=N_A7}
N 850 4590 890 4590 {lab=A7}
N 850 4630 850 4640 {lab=VDD}
N 880 4630 900 4630 {lab=#net5713}
N 810 4630 820 4630 {lab=#net5715}
N 890 4560 890 4590 {lab=A7}
N 890 4590 890 4640 {lab=A7}
N 800 4560 800 4640 {lab=N_A8}
N 720 4630 810 4630 {lab=#net5715}
N 670 4590 710 4590 {lab=A8}
N 670 4630 670 4640 {lab=VDD}
N 700 4630 720 4630 {lab=#net5715}
N 630 4630 640 4630 {lab=#net5717}
N 710 4560 710 4590 {lab=A8}
N 710 4590 710 4640 {lab=A8}
N 620 4560 620 4640 {lab=N_A9}
N 540 4630 630 4630 {lab=#net5717}
N 530 4560 530 4640 {lab=A9}
N 450 4630 540 4630 {lab=#net5717}
N 400 4590 440 4590 {lab=N_A10}
N 400 4630 400 4640 {lab=VDD}
N 430 4630 450 4630 {lab=#net5717}
N 360 4630 370 4630 {lab=#net5719}
N 440 4560 440 4590 {lab=N_A10}
N 440 4590 440 4640 {lab=N_A10}
N 350 4560 350 4640 {lab=A10}
N 270 4630 360 4630 {lab=#net5719}
N 220 4590 260 4590 {lab=N_A11}
N 220 4630 220 4640 {lab=VDD}
N 250 4630 270 4630 {lab=#net5719}
N 180 4630 190 4630 {lab=#net5721}
N 260 4560 260 4590 {lab=N_A11}
N 260 4590 260 4640 {lab=N_A11}
N 170 4560 170 4640 {lab=A11}
N 90 4630 180 4630 {lab=#net5721}
N 40 4590 80 4590 {lab=N_A12}
N 40 4630 40 4640 {lab=VDD}
N 70 4630 90 4630 {lab=#net5721}
N 0 4630 10 4630 {lab=#net5723}
N 80 4560 80 4590 {lab=N_A12}
N 80 4590 80 4640 {lab=N_A12}
N 0 4560 0 4640 { }
N 2210 4680 2220 4680 {lab=GND}
N 2220 4650 2220 4680 {lab=GND}
N 2210 4650 2220 4650 {lab=GND}
N 2170 4640 2170 4680 {lab=N_A5}
N 2170 4680 2170 4720 {lab=N_A5}
N 2160 4710 2210 4710 {lab=word58}
N 2210 4710 2250 4710 {lab=word58}
N 2080 4640 2080 4720 {lab=A5}
N 2070 4710 2160 4710 {lab=word58}
N 2030 4680 2040 4680 {lab=GND}
N 2040 4650 2040 4680 {lab=GND}
N 2030 4650 2040 4650 {lab=GND}
N 1990 4640 1990 4680 {lab=N_A4}
N 1990 4680 1990 4720 {lab=N_A4}
N 1980 4710 2030 4710 {lab=word58}
N 2030 4710 2070 4710 {lab=word58}
N 1900 4640 1900 4720 {lab=A4}
N 1890 4710 1980 4710 {lab=word58}
N 1850 4680 1860 4680 {lab=GND}
N 1860 4650 1860 4680 {lab=GND}
N 1850 4650 1860 4650 {lab=GND}
N 1810 4640 1810 4680 {lab=N_A3}
N 1810 4680 1810 4720 {lab=N_A3}
N 1800 4710 1850 4710 {lab=word58}
N 1850 4710 1890 4710 {lab=word58}
N 1720 4640 1720 4720 {lab=A3}
N 1710 4710 1800 4710 {lab=word58}
N 1630 4640 1630 4720 {lab=N_A2}
N 1620 4710 1710 4710 {lab=word58}
N 1580 4680 1590 4680 {lab=GND}
N 1590 4650 1590 4680 {lab=GND}
N 1580 4650 1590 4650 {lab=GND}
N 1540 4640 1540 4680 {lab=A2}
N 1540 4680 1540 4720 {lab=A2}
N 1530 4710 1580 4710 {lab=word58}
N 1580 4710 1620 4710 {lab=word58}
N 1490 4680 1500 4680 {lab=GND}
N 1500 4650 1500 4680 {lab=GND}
N 1490 4650 1500 4650 {lab=GND}
N 1450 4640 1450 4680 {lab=N_A1}
N 1450 4680 1450 4720 {lab=N_A1}
N 1440 4710 1490 4710 {lab=word58}
N 1490 4710 1530 4710 {lab=word58}
N 1360 4640 1360 4720 {lab=A1}
N 1350 4710 1440 4710 {lab=word58}
N 1270 4640 1270 4720 {lab=N_A0}
N 1260 4710 1350 4710 {lab=word58}
N 1220 4680 1230 4680 {lab=GND}
N 1230 4650 1230 4680 {lab=GND}
N 1220 4650 1230 4650 {lab=GND}
N 1180 4640 1180 4680 {lab=A0}
N 1180 4680 1180 4720 {lab=A0}
N 1170 4710 1220 4710 {lab=word58}
N 1220 4710 1260 4710 {lab=word58}
N 1080 4710 1170 4710 { }
N 1030 4670 1070 4670 {lab=A6}
N 1030 4710 1030 4720 {lab=VDD}
N 1060 4710 1080 4710 {lab=word58}
N 990 4710 1000 4710 {lab=#net5813}
N 1070 4640 1070 4670 {lab=A6}
N 1070 4670 1070 4720 {lab=A6}
N 980 4640 980 4720 {lab=N_A7}
N 900 4710 990 4710 {lab=#net5813}
N 890 4640 890 4720 {lab=A7}
N 810 4710 900 4710 {lab=#net5813}
N 760 4670 800 4670 {lab=N_A8}
N 760 4710 760 4720 {lab=VDD}
N 790 4710 810 4710 {lab=#net5813}
N 720 4710 730 4710 {lab=#net5815}
N 800 4640 800 4670 {lab=N_A8}
N 800 4670 800 4720 {lab=N_A8}
N 670 4670 710 4670 {lab=A8}
N 670 4710 670 4720 {lab=VDD}
N 700 4710 720 4710 {lab=#net5815}
N 630 4710 640 4710 {lab=#net5817}
N 710 4640 710 4670 {lab=A8}
N 710 4670 710 4720 {lab=A8}
N 620 4640 620 4720 {lab=N_A9}
N 540 4710 630 4710 {lab=#net5817}
N 530 4640 530 4720 {lab=A9}
N 450 4710 540 4710 {lab=#net5817}
N 400 4670 440 4670 {lab=N_A10}
N 400 4710 400 4720 {lab=VDD}
N 430 4710 450 4710 {lab=#net5817}
N 360 4710 370 4710 {lab=#net5819}
N 440 4640 440 4670 {lab=N_A10}
N 440 4670 440 4720 {lab=N_A10}
N 350 4640 350 4720 {lab=A10}
N 270 4710 360 4710 {lab=#net5819}
N 220 4670 260 4670 {lab=N_A11}
N 220 4710 220 4720 {lab=VDD}
N 250 4710 270 4710 {lab=#net5819}
N 180 4710 190 4710 {lab=#net5821}
N 260 4640 260 4670 {lab=N_A11}
N 260 4670 260 4720 {lab=N_A11}
N 170 4640 170 4720 {lab=A11}
N 90 4710 180 4710 {lab=#net5821}
N 40 4670 80 4670 {lab=N_A12}
N 40 4710 40 4720 {lab=VDD}
N 70 4710 90 4710 {lab=#net5821}
N 0 4710 10 4710 {lab=#net5823}
N 80 4640 80 4670 {lab=N_A12}
N 80 4670 80 4720 {lab=N_A12}
N 0 4640 0 4720 { }
N 2210 4760 2220 4760 {lab=GND}
N 2220 4730 2220 4760 {lab=GND}
N 2210 4730 2220 4730 {lab=GND}
N 2170 4720 2170 4760 {lab=N_A5}
N 2170 4760 2170 4800 {lab=N_A5}
N 2160 4790 2210 4790 {lab=word59}
N 2210 4790 2250 4790 {lab=word59}
N 2080 4720 2080 4800 {lab=A5}
N 2070 4790 2160 4790 {lab=word59}
N 2030 4760 2040 4760 {lab=GND}
N 2040 4730 2040 4760 {lab=GND}
N 2030 4730 2040 4730 {lab=GND}
N 1990 4720 1990 4760 {lab=N_A4}
N 1990 4760 1990 4800 {lab=N_A4}
N 1980 4790 2030 4790 {lab=word59}
N 2030 4790 2070 4790 {lab=word59}
N 1900 4720 1900 4800 {lab=A4}
N 1890 4790 1980 4790 {lab=word59}
N 1850 4760 1860 4760 {lab=GND}
N 1860 4730 1860 4760 {lab=GND}
N 1850 4730 1860 4730 {lab=GND}
N 1810 4720 1810 4760 {lab=N_A3}
N 1810 4760 1810 4800 {lab=N_A3}
N 1800 4790 1850 4790 {lab=word59}
N 1850 4790 1890 4790 {lab=word59}
N 1720 4720 1720 4800 {lab=A3}
N 1710 4790 1800 4790 {lab=word59}
N 1630 4720 1630 4800 {lab=N_A2}
N 1620 4790 1710 4790 {lab=word59}
N 1580 4760 1590 4760 {lab=GND}
N 1590 4730 1590 4760 {lab=GND}
N 1580 4730 1590 4730 {lab=GND}
N 1540 4720 1540 4760 {lab=A2}
N 1540 4760 1540 4800 {lab=A2}
N 1530 4790 1580 4790 {lab=word59}
N 1580 4790 1620 4790 {lab=word59}
N 1490 4760 1500 4760 {lab=GND}
N 1500 4730 1500 4760 {lab=GND}
N 1490 4730 1500 4730 {lab=GND}
N 1450 4720 1450 4760 {lab=N_A1}
N 1450 4760 1450 4800 {lab=N_A1}
N 1440 4790 1490 4790 {lab=word59}
N 1490 4790 1530 4790 {lab=word59}
N 1360 4720 1360 4800 {lab=A1}
N 1350 4790 1440 4790 {lab=word59}
N 1310 4760 1320 4760 {lab=GND}
N 1320 4730 1320 4760 {lab=GND}
N 1310 4730 1320 4730 {lab=GND}
N 1270 4720 1270 4760 {lab=N_A0}
N 1270 4760 1270 4800 {lab=N_A0}
N 1260 4790 1310 4790 {lab=word59}
N 1310 4790 1350 4790 {lab=word59}
N 1180 4720 1180 4800 {lab=A0}
N 1170 4790 1260 4790 {lab=word59}
N 1080 4790 1170 4790 { }
N 1070 4720 1070 4800 {lab=A6}
N 990 4790 1080 4790 {lab=word59}
N 940 4750 980 4750 {lab=N_A7}
N 940 4790 940 4800 {lab=VDD}
N 970 4790 990 4790 {lab=word59}
N 900 4790 910 4790 {lab=#net5913}
N 980 4720 980 4750 {lab=N_A7}
N 980 4750 980 4800 {lab=N_A7}
N 890 4720 890 4800 {lab=A7}
N 810 4790 900 4790 {lab=#net5913}
N 760 4750 800 4750 {lab=N_A8}
N 760 4790 760 4800 {lab=VDD}
N 790 4790 810 4790 {lab=#net5913}
N 720 4790 730 4790 {lab=#net5915}
N 800 4720 800 4750 {lab=N_A8}
N 800 4750 800 4800 {lab=N_A8}
N 670 4750 710 4750 {lab=A8}
N 670 4790 670 4800 {lab=VDD}
N 700 4790 720 4790 {lab=#net5915}
N 630 4790 640 4790 {lab=#net5917}
N 710 4720 710 4750 {lab=A8}
N 710 4750 710 4800 {lab=A8}
N 620 4720 620 4800 {lab=N_A9}
N 540 4790 630 4790 {lab=#net5917}
N 530 4720 530 4800 {lab=A9}
N 450 4790 540 4790 {lab=#net5917}
N 400 4750 440 4750 {lab=N_A10}
N 400 4790 400 4800 {lab=VDD}
N 430 4790 450 4790 {lab=#net5917}
N 360 4790 370 4790 {lab=#net5919}
N 440 4720 440 4750 {lab=N_A10}
N 440 4750 440 4800 {lab=N_A10}
N 350 4720 350 4800 {lab=A10}
N 270 4790 360 4790 {lab=#net5919}
N 220 4750 260 4750 {lab=N_A11}
N 220 4790 220 4800 {lab=VDD}
N 250 4790 270 4790 {lab=#net5919}
N 180 4790 190 4790 {lab=#net5921}
N 260 4720 260 4750 {lab=N_A11}
N 260 4750 260 4800 {lab=N_A11}
N 170 4720 170 4800 {lab=A11}
N 90 4790 180 4790 {lab=#net5921}
N 40 4750 80 4750 {lab=N_A12}
N 40 4790 40 4800 {lab=VDD}
N 70 4790 90 4790 {lab=#net5921}
N 0 4790 10 4790 {lab=#net5923}
N 80 4720 80 4750 {lab=N_A12}
N 80 4750 80 4800 {lab=N_A12}
N 0 4720 0 4800 { }
N 2210 4840 2220 4840 {lab=GND}
N 2220 4810 2220 4840 {lab=GND}
N 2210 4810 2220 4810 {lab=GND}
N 2170 4800 2170 4840 {lab=N_A5}
N 2170 4840 2170 4880 {lab=N_A5}
N 2160 4870 2210 4870 {lab=word60}
N 2210 4870 2250 4870 {lab=word60}
N 2080 4800 2080 4880 {lab=A5}
N 2070 4870 2160 4870 {lab=word60}
N 2030 4840 2040 4840 {lab=GND}
N 2040 4810 2040 4840 {lab=GND}
N 2030 4810 2040 4810 {lab=GND}
N 1990 4800 1990 4840 {lab=N_A4}
N 1990 4840 1990 4880 {lab=N_A4}
N 1980 4870 2030 4870 {lab=word60}
N 2030 4870 2070 4870 {lab=word60}
N 1900 4800 1900 4880 {lab=A4}
N 1890 4870 1980 4870 {lab=word60}
N 1850 4840 1860 4840 {lab=GND}
N 1860 4810 1860 4840 {lab=GND}
N 1850 4810 1860 4810 {lab=GND}
N 1810 4800 1810 4840 {lab=N_A3}
N 1810 4840 1810 4880 {lab=N_A3}
N 1800 4870 1850 4870 {lab=word60}
N 1850 4870 1890 4870 {lab=word60}
N 1720 4800 1720 4880 {lab=A3}
N 1710 4870 1800 4870 {lab=word60}
N 1670 4840 1680 4840 {lab=GND}
N 1680 4810 1680 4840 {lab=GND}
N 1670 4810 1680 4810 {lab=GND}
N 1630 4800 1630 4840 {lab=N_A2}
N 1630 4840 1630 4880 {lab=N_A2}
N 1620 4870 1670 4870 {lab=word60}
N 1670 4870 1710 4870 {lab=word60}
N 1540 4800 1540 4880 {lab=A2}
N 1530 4870 1620 4870 {lab=word60}
N 1450 4800 1450 4880 {lab=N_A1}
N 1440 4870 1530 4870 {lab=word60}
N 1400 4840 1410 4840 {lab=GND}
N 1410 4810 1410 4840 {lab=GND}
N 1400 4810 1410 4810 {lab=GND}
N 1360 4800 1360 4840 {lab=A1}
N 1360 4840 1360 4880 {lab=A1}
N 1350 4870 1400 4870 {lab=word60}
N 1400 4870 1440 4870 {lab=word60}
N 1270 4800 1270 4880 {lab=N_A0}
N 1260 4870 1350 4870 {lab=word60}
N 1220 4840 1230 4840 {lab=GND}
N 1230 4810 1230 4840 {lab=GND}
N 1220 4810 1230 4810 {lab=GND}
N 1180 4800 1180 4840 {lab=A0}
N 1180 4840 1180 4880 {lab=A0}
N 1170 4870 1220 4870 {lab=word60}
N 1220 4870 1260 4870 {lab=word60}
N 1080 4870 1170 4870 { }
N 1030 4830 1070 4830 {lab=A6}
N 1030 4870 1030 4880 {lab=VDD}
N 1060 4870 1080 4870 {lab=word60}
N 990 4870 1000 4870 {lab=#net6013}
N 1070 4800 1070 4830 {lab=A6}
N 1070 4830 1070 4880 {lab=A6}
N 980 4800 980 4880 {lab=N_A7}
N 900 4870 990 4870 {lab=#net6013}
N 850 4830 890 4830 {lab=A7}
N 850 4870 850 4880 {lab=VDD}
N 880 4870 900 4870 {lab=#net6013}
N 810 4870 820 4870 {lab=#net6015}
N 890 4800 890 4830 {lab=A7}
N 890 4830 890 4880 {lab=A7}
N 800 4800 800 4880 {lab=N_A8}
N 720 4870 810 4870 {lab=#net6015}
N 710 4800 710 4880 {lab=A8}
N 630 4870 720 4870 {lab=#net6015}
N 580 4830 620 4830 {lab=N_A9}
N 580 4870 580 4880 {lab=VDD}
N 610 4870 630 4870 {lab=#net6015}
N 540 4870 550 4870 {lab=#net6017}
N 620 4800 620 4830 {lab=N_A9}
N 620 4830 620 4880 {lab=N_A9}
N 530 4800 530 4880 {lab=A9}
N 450 4870 540 4870 {lab=#net6017}
N 400 4830 440 4830 {lab=N_A10}
N 400 4870 400 4880 {lab=VDD}
N 430 4870 450 4870 {lab=#net6017}
N 360 4870 370 4870 {lab=#net6019}
N 440 4800 440 4830 {lab=N_A10}
N 440 4830 440 4880 {lab=N_A10}
N 350 4800 350 4880 {lab=A10}
N 270 4870 360 4870 {lab=#net6019}
N 220 4830 260 4830 {lab=N_A11}
N 220 4870 220 4880 {lab=VDD}
N 250 4870 270 4870 {lab=#net6019}
N 180 4870 190 4870 {lab=#net6021}
N 260 4800 260 4830 {lab=N_A11}
N 260 4830 260 4880 {lab=N_A11}
N 170 4800 170 4880 {lab=A11}
N 90 4870 180 4870 {lab=#net6021}
N 40 4830 80 4830 {lab=N_A12}
N 40 4870 40 4880 {lab=VDD}
N 70 4870 90 4870 {lab=#net6021}
N 0 4870 10 4870 {lab=#net6023}
N 80 4800 80 4830 {lab=N_A12}
N 80 4830 80 4880 {lab=N_A12}
N 0 4800 0 4880 { }
N 2210 4920 2220 4920 {lab=GND}
N 2220 4890 2220 4920 {lab=GND}
N 2210 4890 2220 4890 {lab=GND}
N 2170 4880 2170 4920 {lab=N_A5}
N 2170 4920 2170 4960 {lab=N_A5}
N 2160 4950 2210 4950 {lab=word61}
N 2210 4950 2250 4950 {lab=word61}
N 2080 4880 2080 4960 {lab=A5}
N 2070 4950 2160 4950 {lab=word61}
N 2030 4920 2040 4920 {lab=GND}
N 2040 4890 2040 4920 {lab=GND}
N 2030 4890 2040 4890 {lab=GND}
N 1990 4880 1990 4920 {lab=N_A4}
N 1990 4920 1990 4960 {lab=N_A4}
N 1980 4950 2030 4950 {lab=word61}
N 2030 4950 2070 4950 {lab=word61}
N 1900 4880 1900 4960 {lab=A4}
N 1890 4950 1980 4950 {lab=word61}
N 1850 4920 1860 4920 {lab=GND}
N 1860 4890 1860 4920 {lab=GND}
N 1850 4890 1860 4890 {lab=GND}
N 1810 4880 1810 4920 {lab=N_A3}
N 1810 4920 1810 4960 {lab=N_A3}
N 1800 4950 1850 4950 {lab=word61}
N 1850 4950 1890 4950 {lab=word61}
N 1720 4880 1720 4960 {lab=A3}
N 1710 4950 1800 4950 {lab=word61}
N 1670 4920 1680 4920 {lab=GND}
N 1680 4890 1680 4920 {lab=GND}
N 1670 4890 1680 4890 {lab=GND}
N 1630 4880 1630 4920 {lab=N_A2}
N 1630 4920 1630 4960 {lab=N_A2}
N 1620 4950 1670 4950 {lab=word61}
N 1670 4950 1710 4950 {lab=word61}
N 1540 4880 1540 4960 {lab=A2}
N 1530 4950 1620 4950 {lab=word61}
N 1450 4880 1450 4960 {lab=N_A1}
N 1440 4950 1530 4950 {lab=word61}
N 1400 4920 1410 4920 {lab=GND}
N 1410 4890 1410 4920 {lab=GND}
N 1400 4890 1410 4890 {lab=GND}
N 1360 4880 1360 4920 {lab=A1}
N 1360 4920 1360 4960 {lab=A1}
N 1350 4950 1400 4950 {lab=word61}
N 1400 4950 1440 4950 {lab=word61}
N 1310 4920 1320 4920 {lab=GND}
N 1320 4890 1320 4920 {lab=GND}
N 1310 4890 1320 4890 {lab=GND}
N 1270 4880 1270 4920 {lab=N_A0}
N 1270 4920 1270 4960 {lab=N_A0}
N 1260 4950 1310 4950 {lab=word61}
N 1310 4950 1350 4950 {lab=word61}
N 1180 4880 1180 4960 {lab=A0}
N 1170 4950 1260 4950 {lab=word61}
N 1080 4950 1170 4950 { }
N 1070 4880 1070 4960 {lab=A6}
N 990 4950 1080 4950 {lab=word61}
N 940 4910 980 4910 {lab=N_A7}
N 940 4950 940 4960 {lab=VDD}
N 970 4950 990 4950 {lab=word61}
N 900 4950 910 4950 {lab=#net6113}
N 980 4880 980 4910 {lab=N_A7}
N 980 4910 980 4960 {lab=N_A7}
N 850 4910 890 4910 {lab=A7}
N 850 4950 850 4960 {lab=VDD}
N 880 4950 900 4950 {lab=#net6113}
N 810 4950 820 4950 {lab=#net6115}
N 890 4880 890 4910 {lab=A7}
N 890 4910 890 4960 {lab=A7}
N 800 4880 800 4960 {lab=N_A8}
N 720 4950 810 4950 {lab=#net6115}
N 710 4880 710 4960 {lab=A8}
N 630 4950 720 4950 {lab=#net6115}
N 580 4910 620 4910 {lab=N_A9}
N 580 4950 580 4960 {lab=VDD}
N 610 4950 630 4950 {lab=#net6115}
N 540 4950 550 4950 {lab=#net6117}
N 620 4880 620 4910 {lab=N_A9}
N 620 4910 620 4960 {lab=N_A9}
N 530 4880 530 4960 {lab=A9}
N 450 4950 540 4950 {lab=#net6117}
N 400 4910 440 4910 {lab=N_A10}
N 400 4950 400 4960 {lab=VDD}
N 430 4950 450 4950 {lab=#net6117}
N 360 4950 370 4950 {lab=#net6119}
N 440 4880 440 4910 {lab=N_A10}
N 440 4910 440 4960 {lab=N_A10}
N 350 4880 350 4960 {lab=A10}
N 270 4950 360 4950 {lab=#net6119}
N 220 4910 260 4910 {lab=N_A11}
N 220 4950 220 4960 {lab=VDD}
N 250 4950 270 4950 {lab=#net6119}
N 180 4950 190 4950 {lab=#net6121}
N 260 4880 260 4910 {lab=N_A11}
N 260 4910 260 4960 {lab=N_A11}
N 170 4880 170 4960 {lab=A11}
N 90 4950 180 4950 {lab=#net6121}
N 40 4910 80 4910 {lab=N_A12}
N 40 4950 40 4960 {lab=VDD}
N 70 4950 90 4950 {lab=#net6121}
N 0 4950 10 4950 {lab=#net6123}
N 80 4880 80 4910 {lab=N_A12}
N 80 4910 80 4960 {lab=N_A12}
N 0 4880 0 4960 { }
N 2210 5000 2220 5000 {lab=GND}
N 2220 4970 2220 5000 {lab=GND}
N 2210 4970 2220 4970 {lab=GND}
N 2170 4960 2170 5000 {lab=N_A5}
N 2170 5000 2170 5040 {lab=N_A5}
N 2160 5030 2210 5030 {lab=word62}
N 2210 5030 2250 5030 {lab=word62}
N 2080 4960 2080 5040 {lab=A5}
N 2070 5030 2160 5030 {lab=word62}
N 2030 5000 2040 5000 {lab=GND}
N 2040 4970 2040 5000 {lab=GND}
N 2030 4970 2040 4970 {lab=GND}
N 1990 4960 1990 5000 {lab=N_A4}
N 1990 5000 1990 5040 {lab=N_A4}
N 1980 5030 2030 5030 {lab=word62}
N 2030 5030 2070 5030 {lab=word62}
N 1900 4960 1900 5040 {lab=A4}
N 1890 5030 1980 5030 {lab=word62}
N 1850 5000 1860 5000 {lab=GND}
N 1860 4970 1860 5000 {lab=GND}
N 1850 4970 1860 4970 {lab=GND}
N 1810 4960 1810 5000 {lab=N_A3}
N 1810 5000 1810 5040 {lab=N_A3}
N 1800 5030 1850 5030 {lab=word62}
N 1850 5030 1890 5030 {lab=word62}
N 1720 4960 1720 5040 {lab=A3}
N 1710 5030 1800 5030 {lab=word62}
N 1670 5000 1680 5000 {lab=GND}
N 1680 4970 1680 5000 {lab=GND}
N 1670 4970 1680 4970 {lab=GND}
N 1630 4960 1630 5000 {lab=N_A2}
N 1630 5000 1630 5040 {lab=N_A2}
N 1620 5030 1670 5030 {lab=word62}
N 1670 5030 1710 5030 {lab=word62}
N 1540 4960 1540 5040 {lab=A2}
N 1530 5030 1620 5030 {lab=word62}
N 1490 5000 1500 5000 {lab=GND}
N 1500 4970 1500 5000 {lab=GND}
N 1490 4970 1500 4970 {lab=GND}
N 1450 4960 1450 5000 {lab=N_A1}
N 1450 5000 1450 5040 {lab=N_A1}
N 1440 5030 1490 5030 {lab=word62}
N 1490 5030 1530 5030 {lab=word62}
N 1360 4960 1360 5040 {lab=A1}
N 1350 5030 1440 5030 {lab=word62}
N 1270 4960 1270 5040 {lab=N_A0}
N 1260 5030 1350 5030 {lab=word62}
N 1220 5000 1230 5000 {lab=GND}
N 1230 4970 1230 5000 {lab=GND}
N 1220 4970 1230 4970 {lab=GND}
N 1180 4960 1180 5000 {lab=A0}
N 1180 5000 1180 5040 {lab=A0}
N 1170 5030 1220 5030 {lab=word62}
N 1220 5030 1260 5030 {lab=word62}
N 1080 5030 1170 5030 { }
N 1030 4990 1070 4990 {lab=A6}
N 1030 5030 1030 5040 {lab=VDD}
N 1060 5030 1080 5030 {lab=word62}
N 990 5030 1000 5030 {lab=#net6213}
N 1070 4960 1070 4990 {lab=A6}
N 1070 4990 1070 5040 {lab=A6}
N 980 4960 980 5040 {lab=N_A7}
N 900 5030 990 5030 {lab=#net6213}
N 890 4960 890 5040 {lab=A7}
N 810 5030 900 5030 {lab=#net6213}
N 760 4990 800 4990 {lab=N_A8}
N 760 5030 760 5040 {lab=VDD}
N 790 5030 810 5030 {lab=#net6213}
N 720 5030 730 5030 {lab=#net6215}
N 800 4960 800 4990 {lab=N_A8}
N 800 4990 800 5040 {lab=N_A8}
N 710 4960 710 5040 {lab=A8}
N 630 5030 720 5030 {lab=#net6215}
N 580 4990 620 4990 {lab=N_A9}
N 580 5030 580 5040 {lab=VDD}
N 610 5030 630 5030 {lab=#net6215}
N 540 5030 550 5030 {lab=#net6217}
N 620 4960 620 4990 {lab=N_A9}
N 620 4990 620 5040 {lab=N_A9}
N 530 4960 530 5040 {lab=A9}
N 450 5030 540 5030 {lab=#net6217}
N 400 4990 440 4990 {lab=N_A10}
N 400 5030 400 5040 {lab=VDD}
N 430 5030 450 5030 {lab=#net6217}
N 360 5030 370 5030 {lab=#net6219}
N 440 4960 440 4990 {lab=N_A10}
N 440 4990 440 5040 {lab=N_A10}
N 350 4960 350 5040 {lab=A10}
N 270 5030 360 5030 {lab=#net6219}
N 220 4990 260 4990 {lab=N_A11}
N 220 5030 220 5040 {lab=VDD}
N 250 5030 270 5030 {lab=#net6219}
N 180 5030 190 5030 {lab=#net6221}
N 260 4960 260 4990 {lab=N_A11}
N 260 4990 260 5040 {lab=N_A11}
N 170 4960 170 5040 {lab=A11}
N 90 5030 180 5030 {lab=#net6221}
N 40 4990 80 4990 {lab=N_A12}
N 40 5030 40 5040 {lab=VDD}
N 70 5030 90 5030 {lab=#net6221}
N 0 5030 10 5030 {lab=#net6223}
N 80 4960 80 4990 {lab=N_A12}
N 80 4990 80 5040 {lab=N_A12}
N 0 4960 0 5040 { }
N 2210 5080 2220 5080 {lab=GND}
N 2220 5050 2220 5080 {lab=GND}
N 2210 5050 2220 5050 {lab=GND}
N 2170 5040 2170 5080 {lab=N_A5}
N 2170 5080 2170 5120 {lab=N_A5}
N 2160 5110 2210 5110 {lab=word63}
N 2210 5110 2250 5110 {lab=word63}
N 2080 5040 2080 5120 {lab=A5}
N 2070 5110 2160 5110 {lab=word63}
N 2030 5080 2040 5080 {lab=GND}
N 2040 5050 2040 5080 {lab=GND}
N 2030 5050 2040 5050 {lab=GND}
N 1990 5040 1990 5080 {lab=N_A4}
N 1990 5080 1990 5120 {lab=N_A4}
N 1980 5110 2030 5110 {lab=word63}
N 2030 5110 2070 5110 {lab=word63}
N 1900 5040 1900 5120 {lab=A4}
N 1890 5110 1980 5110 {lab=word63}
N 1850 5080 1860 5080 {lab=GND}
N 1860 5050 1860 5080 {lab=GND}
N 1850 5050 1860 5050 {lab=GND}
N 1810 5040 1810 5080 {lab=N_A3}
N 1810 5080 1810 5120 {lab=N_A3}
N 1800 5110 1850 5110 {lab=word63}
N 1850 5110 1890 5110 {lab=word63}
N 1720 5040 1720 5120 {lab=A3}
N 1710 5110 1800 5110 {lab=word63}
N 1670 5080 1680 5080 {lab=GND}
N 1680 5050 1680 5080 {lab=GND}
N 1670 5050 1680 5050 {lab=GND}
N 1630 5040 1630 5080 {lab=N_A2}
N 1630 5080 1630 5120 {lab=N_A2}
N 1620 5110 1670 5110 {lab=word63}
N 1670 5110 1710 5110 {lab=word63}
N 1540 5040 1540 5120 {lab=A2}
N 1530 5110 1620 5110 {lab=word63}
N 1490 5080 1500 5080 {lab=GND}
N 1500 5050 1500 5080 {lab=GND}
N 1490 5050 1500 5050 {lab=GND}
N 1450 5040 1450 5080 {lab=N_A1}
N 1450 5080 1450 5120 {lab=N_A1}
N 1440 5110 1490 5110 {lab=word63}
N 1490 5110 1530 5110 {lab=word63}
N 1360 5040 1360 5120 {lab=A1}
N 1350 5110 1440 5110 {lab=word63}
N 1310 5080 1320 5080 {lab=GND}
N 1320 5050 1320 5080 {lab=GND}
N 1310 5050 1320 5050 {lab=GND}
N 1270 5040 1270 5080 {lab=N_A0}
N 1270 5080 1270 5120 {lab=N_A0}
N 1260 5110 1310 5110 {lab=word63}
N 1310 5110 1350 5110 {lab=word63}
N 1180 5040 1180 5120 {lab=A0}
N 1170 5110 1260 5110 {lab=word63}
N 1080 5110 1170 5110 { }
N 1070 5040 1070 5120 {lab=A6}
N 990 5110 1080 5110 {lab=word63}
N 940 5070 980 5070 {lab=N_A7}
N 940 5110 940 5120 {lab=VDD}
N 970 5110 990 5110 {lab=word63}
N 900 5110 910 5110 {lab=#net6313}
N 980 5040 980 5070 {lab=N_A7}
N 980 5070 980 5120 {lab=N_A7}
N 890 5040 890 5120 {lab=A7}
N 810 5110 900 5110 {lab=#net6313}
N 760 5070 800 5070 {lab=N_A8}
N 760 5110 760 5120 {lab=VDD}
N 790 5110 810 5110 {lab=#net6313}
N 720 5110 730 5110 {lab=#net6315}
N 800 5040 800 5070 {lab=N_A8}
N 800 5070 800 5120 {lab=N_A8}
N 710 5040 710 5120 {lab=A8}
N 630 5110 720 5110 {lab=#net6315}
N 580 5070 620 5070 {lab=N_A9}
N 580 5110 580 5120 {lab=VDD}
N 610 5110 630 5110 {lab=#net6315}
N 540 5110 550 5110 {lab=#net6317}
N 620 5040 620 5070 {lab=N_A9}
N 620 5070 620 5120 {lab=N_A9}
N 530 5040 530 5120 {lab=A9}
N 450 5110 540 5110 {lab=#net6317}
N 400 5070 440 5070 {lab=N_A10}
N 400 5110 400 5120 {lab=VDD}
N 430 5110 450 5110 {lab=#net6317}
N 360 5110 370 5110 {lab=#net6319}
N 440 5040 440 5070 {lab=N_A10}
N 440 5070 440 5120 {lab=N_A10}
N 350 5040 350 5120 {lab=A10}
N 270 5110 360 5110 {lab=#net6319}
N 220 5070 260 5070 {lab=N_A11}
N 220 5110 220 5120 {lab=VDD}
N 250 5110 270 5110 {lab=#net6319}
N 180 5110 190 5110 {lab=#net6321}
N 260 5040 260 5070 {lab=N_A11}
N 260 5070 260 5120 {lab=N_A11}
N 170 5040 170 5120 {lab=A11}
N 90 5110 180 5110 {lab=#net6321}
N 40 5070 80 5070 {lab=N_A12}
N 40 5110 40 5120 {lab=VDD}
N 70 5110 90 5110 {lab=#net6321}
N 0 5110 10 5110 {lab=#net6323}
N 80 5040 80 5070 {lab=N_A12}
N 80 5070 80 5120 {lab=N_A12}
N 0 5040 0 5120 { }
C {devices/vdd.sym} 0 0 0 0 {lab=VDD}
C {devices/lab_wire.sym} 1270 -30 0 0 {name=p0 lab=N_A0}
C {devices/lab_wire.sym} 1180 -30 0 0 {name=p1 lab=A0}
C {devices/lab_wire.sym} 1450 -30 0 0 {name=p2 lab=N_A1}
C {devices/lab_wire.sym} 1360 -30 0 0 {name=p3 lab=A1}
C {devices/lab_wire.sym} 1630 -30 0 0 {name=p4 lab=N_A2}
C {devices/lab_wire.sym} 1540 -30 0 0 {name=p5 lab=A2}
C {devices/lab_wire.sym} 1810 -30 0 0 {name=p6 lab=N_A3}
C {devices/lab_wire.sym} 1720 -30 0 0 {name=p7 lab=A3}
C {devices/lab_wire.sym} 1990 -30 0 0 {name=p8 lab=N_A4}
C {devices/lab_wire.sym} 1900 -30 0 0 {name=p9 lab=A4}
C {devices/lab_wire.sym} 2170 -30 0 0 {name=p10 lab=N_A5}
C {devices/lab_wire.sym} 2080 -30 0 0 {name=p11 lab=A5}
C {lab1/inv.sym} 1070 -90 2 0 {name=x0}
C {devices/ipin.sym} 1070 -60 3 1 {name=p12 lab=A0}
C {devices/lab_wire.sym} 980 -20 0 0 {name=p13 sig_type=std_logic lab=N_A0}
C {lab1/inv.sym} 890 -90 2 0 {name=x1}
C {devices/ipin.sym} 890 -60 3 1 {name=p14 lab=A1}
C {devices/lab_wire.sym} 800 -20 0 0 {name=p15 sig_type=std_logic lab=N_A1}
C {lab1/inv.sym} 710 -90 2 0 {name=x2}
C {devices/ipin.sym} 710 -60 3 1 {name=p16 lab=A2}
C {devices/lab_wire.sym} 620 -20 0 0 {name=p17 sig_type=std_logic lab=N_A2}
C {lab1/inv.sym} 530 -90 2 0 {name=x3}
C {devices/ipin.sym} 530 -60 3 1 {name=p18 lab=A3}
C {devices/lab_wire.sym} 440 -20 0 0 {name=p19 sig_type=std_logic lab=N_A3}
C {lab1/inv.sym} 350 -90 2 0 {name=x4}
C {devices/ipin.sym} 350 -60 3 1 {name=p20 lab=A4}
C {devices/lab_wire.sym} 260 -20 0 0 {name=p21 sig_type=std_logic lab=N_A4}
C {lab1/inv.sym} 170 -90 2 0 {name=x5}
C {devices/ipin.sym} 170 -60 3 1 {name=p22 lab=A5}
C {devices/lab_wire.sym} 80 -20 0 0 {name=p23 sig_type=std_logic lab=N_A5}
C {devices/opin.sym} 2250 70 0 0 {name=p24 lab=word0}
C {sky130_fd_pr/nfet_01v8.sym} 2100 40 2 1 {name=M0
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 40 3 0 {name=l0 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 40 2 1 {name=M1
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 40 3 0 {name=l1 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 40 2 1 {name=M2
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 40 3 0 {name=l2 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 40 2 1 {name=M3
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 40 3 0 {name=l3 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 40 2 1 {name=M4
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 40 3 0 {name=l4 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 40 2 1 {name=M5
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 40 3 0 {name=l5 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 50 3 1 {name=M6
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 80 3 0 {name=l6 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 50 3 1 {name=M7
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 80 3 0 {name=l7 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 50 3 1 {name=M8
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 80 3 0 {name=l8 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 50 3 1 {name=M9
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 80 3 0 {name=l9 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 50 3 1 {name=M10
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 80 3 0 {name=l10 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 50 3 1 {name=M11
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 80 3 0 {name=l11 lab=VDD}
C {devices/opin.sym} 2250 150 0 0 {name=p25 lab=word1}
C {sky130_fd_pr/nfet_01v8.sym} 2100 120 2 1 {name=M12
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 120 3 0 {name=l12 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 120 2 1 {name=M13
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 120 3 0 {name=l13 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 120 2 1 {name=M14
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 120 3 0 {name=l14 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 120 2 1 {name=M15
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 120 3 0 {name=l15 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 120 2 1 {name=M16
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 120 3 0 {name=l16 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 120 2 1 {name=M17
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 120 3 0 {name=l17 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 130 3 1 {name=M18
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 160 3 0 {name=l18 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 130 3 1 {name=M19
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 160 3 0 {name=l19 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 130 3 1 {name=M20
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 160 3 0 {name=l20 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 130 3 1 {name=M21
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 160 3 0 {name=l21 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 130 3 1 {name=M22
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 160 3 0 {name=l22 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 130 3 1 {name=M23
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 160 3 0 {name=l23 lab=VDD}
C {devices/opin.sym} 2250 230 0 0 {name=p26 lab=word2}
C {sky130_fd_pr/nfet_01v8.sym} 2100 200 2 1 {name=M24
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 200 3 0 {name=l24 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 200 2 1 {name=M25
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 200 3 0 {name=l25 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 200 2 1 {name=M26
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 200 3 0 {name=l26 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 200 2 1 {name=M27
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 200 3 0 {name=l27 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 200 2 1 {name=M28
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 200 3 0 {name=l28 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 200 2 1 {name=M29
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 200 3 0 {name=l29 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 210 3 1 {name=M30
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 240 3 0 {name=l30 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 210 3 1 {name=M31
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 240 3 0 {name=l31 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 210 3 1 {name=M32
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 240 3 0 {name=l32 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 210 3 1 {name=M33
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 240 3 0 {name=l33 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 210 3 1 {name=M34
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 240 3 0 {name=l34 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 210 3 1 {name=M35
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 240 3 0 {name=l35 lab=VDD}
C {devices/opin.sym} 2250 310 0 0 {name=p27 lab=word3}
C {sky130_fd_pr/nfet_01v8.sym} 2100 280 2 1 {name=M36
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 280 3 0 {name=l36 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 280 2 1 {name=M37
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 280 3 0 {name=l37 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 280 2 1 {name=M38
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 280 3 0 {name=l38 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 280 2 1 {name=M39
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 280 3 0 {name=l39 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 280 2 1 {name=M40
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 280 3 0 {name=l40 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 280 2 1 {name=M41
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 280 3 0 {name=l41 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 290 3 1 {name=M42
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 320 3 0 {name=l42 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 290 3 1 {name=M43
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 320 3 0 {name=l43 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 290 3 1 {name=M44
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 320 3 0 {name=l44 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 290 3 1 {name=M45
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 320 3 0 {name=l45 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 290 3 1 {name=M46
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 320 3 0 {name=l46 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 290 3 1 {name=M47
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 320 3 0 {name=l47 lab=VDD}
C {devices/opin.sym} 2250 390 0 0 {name=p28 lab=word4}
C {sky130_fd_pr/nfet_01v8.sym} 2100 360 2 1 {name=M48
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 360 3 0 {name=l48 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 360 2 1 {name=M49
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 360 3 0 {name=l49 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 360 2 1 {name=M50
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 360 3 0 {name=l50 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 360 2 1 {name=M51
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 360 3 0 {name=l51 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 360 2 1 {name=M52
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 360 3 0 {name=l52 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 360 2 1 {name=M53
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 360 3 0 {name=l53 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 370 3 1 {name=M54
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 400 3 0 {name=l54 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 370 3 1 {name=M55
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 400 3 0 {name=l55 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 370 3 1 {name=M56
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 400 3 0 {name=l56 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 370 3 1 {name=M57
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 400 3 0 {name=l57 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 370 3 1 {name=M58
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 400 3 0 {name=l58 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 370 3 1 {name=M59
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 400 3 0 {name=l59 lab=VDD}
C {devices/opin.sym} 2250 470 0 0 {name=p29 lab=word5}
C {sky130_fd_pr/nfet_01v8.sym} 2100 440 2 1 {name=M60
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 440 3 0 {name=l60 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 440 2 1 {name=M61
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 440 3 0 {name=l61 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 440 2 1 {name=M62
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 440 3 0 {name=l62 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 440 2 1 {name=M63
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 440 3 0 {name=l63 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 440 2 1 {name=M64
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 440 3 0 {name=l64 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 440 2 1 {name=M65
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 440 3 0 {name=l65 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 450 3 1 {name=M66
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 480 3 0 {name=l66 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 450 3 1 {name=M67
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 480 3 0 {name=l67 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 450 3 1 {name=M68
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 480 3 0 {name=l68 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 450 3 1 {name=M69
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 480 3 0 {name=l69 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 450 3 1 {name=M70
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 480 3 0 {name=l70 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 450 3 1 {name=M71
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 480 3 0 {name=l71 lab=VDD}
C {devices/opin.sym} 2250 550 0 0 {name=p30 lab=word6}
C {sky130_fd_pr/nfet_01v8.sym} 2100 520 2 1 {name=M72
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 520 3 0 {name=l72 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 520 2 1 {name=M73
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 520 3 0 {name=l73 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 520 2 1 {name=M74
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 520 3 0 {name=l74 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 520 2 1 {name=M75
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 520 3 0 {name=l75 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 520 2 1 {name=M76
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 520 3 0 {name=l76 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 520 2 1 {name=M77
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 520 3 0 {name=l77 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 530 3 1 {name=M78
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 560 3 0 {name=l78 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 530 3 1 {name=M79
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 560 3 0 {name=l79 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 530 3 1 {name=M80
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 560 3 0 {name=l80 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 530 3 1 {name=M81
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 560 3 0 {name=l81 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 530 3 1 {name=M82
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 560 3 0 {name=l82 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 530 3 1 {name=M83
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 560 3 0 {name=l83 lab=VDD}
C {devices/opin.sym} 2250 630 0 0 {name=p31 lab=word7}
C {sky130_fd_pr/nfet_01v8.sym} 2100 600 2 1 {name=M84
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 600 3 0 {name=l84 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 600 2 1 {name=M85
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 600 3 0 {name=l85 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 600 2 1 {name=M86
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 600 3 0 {name=l86 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 600 2 1 {name=M87
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 600 3 0 {name=l87 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 600 2 1 {name=M88
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 600 3 0 {name=l88 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 600 2 1 {name=M89
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 600 3 0 {name=l89 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 610 3 1 {name=M90
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 640 3 0 {name=l90 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 610 3 1 {name=M91
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 640 3 0 {name=l91 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 610 3 1 {name=M92
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 640 3 0 {name=l92 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 610 3 1 {name=M93
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 640 3 0 {name=l93 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 610 3 1 {name=M94
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 640 3 0 {name=l94 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 610 3 1 {name=M95
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 640 3 0 {name=l95 lab=VDD}
C {devices/opin.sym} 2250 710 0 0 {name=p32 lab=word8}
C {sky130_fd_pr/nfet_01v8.sym} 2100 680 2 1 {name=M96
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 680 3 0 {name=l96 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 680 2 1 {name=M97
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 680 3 0 {name=l97 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 680 2 1 {name=M98
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 680 3 0 {name=l98 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 680 2 1 {name=M99
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 680 3 0 {name=l99 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 680 2 1 {name=M100
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 680 3 0 {name=l100 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 680 2 1 {name=M101
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 680 3 0 {name=l101 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 690 3 1 {name=M102
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 720 3 0 {name=l102 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 690 3 1 {name=M103
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 720 3 0 {name=l103 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 690 3 1 {name=M104
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 720 3 0 {name=l104 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 690 3 1 {name=M105
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 720 3 0 {name=l105 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 690 3 1 {name=M106
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 720 3 0 {name=l106 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 690 3 1 {name=M107
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 720 3 0 {name=l107 lab=VDD}
C {devices/opin.sym} 2250 790 0 0 {name=p33 lab=word9}
C {sky130_fd_pr/nfet_01v8.sym} 2100 760 2 1 {name=M108
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 760 3 0 {name=l108 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 760 2 1 {name=M109
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 760 3 0 {name=l109 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 760 2 1 {name=M110
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 760 3 0 {name=l110 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 760 2 1 {name=M111
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 760 3 0 {name=l111 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 760 2 1 {name=M112
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 760 3 0 {name=l112 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 760 2 1 {name=M113
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 760 3 0 {name=l113 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 770 3 1 {name=M114
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 800 3 0 {name=l114 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 770 3 1 {name=M115
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 800 3 0 {name=l115 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 770 3 1 {name=M116
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 800 3 0 {name=l116 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 770 3 1 {name=M117
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 800 3 0 {name=l117 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 770 3 1 {name=M118
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 800 3 0 {name=l118 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 770 3 1 {name=M119
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 800 3 0 {name=l119 lab=VDD}
C {devices/opin.sym} 2250 870 0 0 {name=p34 lab=word10}
C {sky130_fd_pr/nfet_01v8.sym} 2100 840 2 1 {name=M120
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 840 3 0 {name=l120 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 840 2 1 {name=M121
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 840 3 0 {name=l121 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 840 2 1 {name=M122
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 840 3 0 {name=l122 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 840 2 1 {name=M123
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 840 3 0 {name=l123 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 840 2 1 {name=M124
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 840 3 0 {name=l124 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 840 2 1 {name=M125
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 840 3 0 {name=l125 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 850 3 1 {name=M126
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 880 3 0 {name=l126 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 850 3 1 {name=M127
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 880 3 0 {name=l127 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 850 3 1 {name=M128
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 880 3 0 {name=l128 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 850 3 1 {name=M129
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 880 3 0 {name=l129 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 850 3 1 {name=M130
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 880 3 0 {name=l130 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 850 3 1 {name=M131
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 880 3 0 {name=l131 lab=VDD}
C {devices/opin.sym} 2250 950 0 0 {name=p35 lab=word11}
C {sky130_fd_pr/nfet_01v8.sym} 2100 920 2 1 {name=M132
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 920 3 0 {name=l132 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 920 2 1 {name=M133
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 920 3 0 {name=l133 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 920 2 1 {name=M134
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 920 3 0 {name=l134 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 920 2 1 {name=M135
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 920 3 0 {name=l135 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 920 2 1 {name=M136
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 920 3 0 {name=l136 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 920 2 1 {name=M137
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 920 3 0 {name=l137 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 930 3 1 {name=M138
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 960 3 0 {name=l138 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 930 3 1 {name=M139
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 960 3 0 {name=l139 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 930 3 1 {name=M140
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 960 3 0 {name=l140 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 930 3 1 {name=M141
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 960 3 0 {name=l141 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 930 3 1 {name=M142
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 960 3 0 {name=l142 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 930 3 1 {name=M143
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 960 3 0 {name=l143 lab=VDD}
C {devices/opin.sym} 2250 1030 0 0 {name=p36 lab=word12}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1000 2 1 {name=M144
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1000 3 0 {name=l144 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 1000 2 1 {name=M145
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 1000 3 0 {name=l145 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1000 2 1 {name=M146
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1000 3 0 {name=l146 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1000 2 1 {name=M147
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1000 3 0 {name=l147 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1000 2 1 {name=M148
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1000 3 0 {name=l148 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 1000 2 1 {name=M149
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 1000 3 0 {name=l149 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1010 3 1 {name=M150
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 1040 3 0 {name=l150 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 1010 3 1 {name=M151
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 1040 3 0 {name=l151 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1010 3 1 {name=M152
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 1040 3 0 {name=l152 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1010 3 1 {name=M153
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 1040 3 0 {name=l153 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1010 3 1 {name=M154
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1040 3 0 {name=l154 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1010 3 1 {name=M155
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1040 3 0 {name=l155 lab=VDD}
C {devices/opin.sym} 2250 1110 0 0 {name=p37 lab=word13}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1080 2 1 {name=M156
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1080 3 0 {name=l156 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 1080 2 1 {name=M157
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 1080 3 0 {name=l157 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1080 2 1 {name=M158
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1080 3 0 {name=l158 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1080 2 1 {name=M159
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1080 3 0 {name=l159 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1080 2 1 {name=M160
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1080 3 0 {name=l160 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 1080 2 1 {name=M161
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 1080 3 0 {name=l161 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 1090 3 1 {name=M162
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 1120 3 0 {name=l162 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 1090 3 1 {name=M163
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 1120 3 0 {name=l163 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1090 3 1 {name=M164
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 1120 3 0 {name=l164 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1090 3 1 {name=M165
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 1120 3 0 {name=l165 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1090 3 1 {name=M166
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1120 3 0 {name=l166 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1090 3 1 {name=M167
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1120 3 0 {name=l167 lab=VDD}
C {devices/opin.sym} 2250 1190 0 0 {name=p38 lab=word14}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1160 2 1 {name=M168
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1160 3 0 {name=l168 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 1160 2 1 {name=M169
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 1160 3 0 {name=l169 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1160 2 1 {name=M170
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1160 3 0 {name=l170 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1160 2 1 {name=M171
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1160 3 0 {name=l171 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1160 2 1 {name=M172
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 1160 3 0 {name=l172 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 1160 2 1 {name=M173
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 1160 3 0 {name=l173 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1170 3 1 {name=M174
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 1200 3 0 {name=l174 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1170 3 1 {name=M175
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1200 3 0 {name=l175 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1170 3 1 {name=M176
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 1200 3 0 {name=l176 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1170 3 1 {name=M177
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 1200 3 0 {name=l177 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1170 3 1 {name=M178
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1200 3 0 {name=l178 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1170 3 1 {name=M179
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1200 3 0 {name=l179 lab=VDD}
C {devices/opin.sym} 2250 1270 0 0 {name=p39 lab=word15}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1240 2 1 {name=M180
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1240 3 0 {name=l180 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 1240 2 1 {name=M181
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 1240 3 0 {name=l181 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1240 2 1 {name=M182
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1240 3 0 {name=l182 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1240 2 1 {name=M183
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1240 3 0 {name=l183 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1240 2 1 {name=M184
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 1240 3 0 {name=l184 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 1240 2 1 {name=M185
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 1240 3 0 {name=l185 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 1250 3 1 {name=M186
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 1280 3 0 {name=l186 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1250 3 1 {name=M187
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1280 3 0 {name=l187 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1250 3 1 {name=M188
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 1280 3 0 {name=l188 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1250 3 1 {name=M189
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 1280 3 0 {name=l189 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1250 3 1 {name=M190
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1280 3 0 {name=l190 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1250 3 1 {name=M191
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1280 3 0 {name=l191 lab=VDD}
C {devices/opin.sym} 2250 1350 0 0 {name=p40 lab=word16}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1320 2 1 {name=M192
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1320 3 0 {name=l192 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1320 2 1 {name=M193
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1320 3 0 {name=l193 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1320 2 1 {name=M194
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1320 3 0 {name=l194 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 1320 2 1 {name=M195
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 1320 3 0 {name=l195 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1320 2 1 {name=M196
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1320 3 0 {name=l196 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 1320 2 1 {name=M197
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 1320 3 0 {name=l197 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1330 3 1 {name=M198
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 1360 3 0 {name=l198 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 1330 3 1 {name=M199
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 1360 3 0 {name=l199 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1330 3 1 {name=M200
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 1360 3 0 {name=l200 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 1330 3 1 {name=M201
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 1360 3 0 {name=l201 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 1330 3 1 {name=M202
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 1360 3 0 {name=l202 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1330 3 1 {name=M203
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1360 3 0 {name=l203 lab=VDD}
C {devices/opin.sym} 2250 1430 0 0 {name=p41 lab=word17}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1400 2 1 {name=M204
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1400 3 0 {name=l204 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1400 2 1 {name=M205
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1400 3 0 {name=l205 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1400 2 1 {name=M206
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1400 3 0 {name=l206 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 1400 2 1 {name=M207
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 1400 3 0 {name=l207 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1400 2 1 {name=M208
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1400 3 0 {name=l208 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 1400 2 1 {name=M209
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 1400 3 0 {name=l209 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 1410 3 1 {name=M210
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 1440 3 0 {name=l210 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 1410 3 1 {name=M211
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 1440 3 0 {name=l211 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1410 3 1 {name=M212
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 1440 3 0 {name=l212 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 1410 3 1 {name=M213
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 1440 3 0 {name=l213 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 1410 3 1 {name=M214
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 1440 3 0 {name=l214 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1410 3 1 {name=M215
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1440 3 0 {name=l215 lab=VDD}
C {devices/opin.sym} 2250 1510 0 0 {name=p42 lab=word18}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1480 2 1 {name=M216
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1480 3 0 {name=l216 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1480 2 1 {name=M217
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1480 3 0 {name=l217 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1480 2 1 {name=M218
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1480 3 0 {name=l218 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 1480 2 1 {name=M219
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 1480 3 0 {name=l219 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1480 2 1 {name=M220
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 1480 3 0 {name=l220 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 1480 2 1 {name=M221
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 1480 3 0 {name=l221 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1490 3 1 {name=M222
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 1520 3 0 {name=l222 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1490 3 1 {name=M223
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1520 3 0 {name=l223 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1490 3 1 {name=M224
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 1520 3 0 {name=l224 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 1490 3 1 {name=M225
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 1520 3 0 {name=l225 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 1490 3 1 {name=M226
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 1520 3 0 {name=l226 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1490 3 1 {name=M227
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1520 3 0 {name=l227 lab=VDD}
C {devices/opin.sym} 2250 1590 0 0 {name=p43 lab=word19}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1560 2 1 {name=M228
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1560 3 0 {name=l228 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1560 2 1 {name=M229
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1560 3 0 {name=l229 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1560 2 1 {name=M230
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1560 3 0 {name=l230 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 1560 2 1 {name=M231
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 1560 3 0 {name=l231 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1560 2 1 {name=M232
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 1560 3 0 {name=l232 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 1560 2 1 {name=M233
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 1560 3 0 {name=l233 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 1570 3 1 {name=M234
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 1600 3 0 {name=l234 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1570 3 1 {name=M235
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1600 3 0 {name=l235 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1570 3 1 {name=M236
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 1600 3 0 {name=l236 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 1570 3 1 {name=M237
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 1600 3 0 {name=l237 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 1570 3 1 {name=M238
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 1600 3 0 {name=l238 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1570 3 1 {name=M239
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1600 3 0 {name=l239 lab=VDD}
C {devices/opin.sym} 2250 1670 0 0 {name=p44 lab=word20}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1640 2 1 {name=M240
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1640 3 0 {name=l240 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1640 2 1 {name=M241
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1640 3 0 {name=l241 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1640 2 1 {name=M242
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1640 3 0 {name=l242 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1640 2 1 {name=M243
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1640 3 0 {name=l243 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1640 2 1 {name=M244
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1640 3 0 {name=l244 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 1640 2 1 {name=M245
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 1640 3 0 {name=l245 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1650 3 1 {name=M246
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 1680 3 0 {name=l246 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 1650 3 1 {name=M247
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 1680 3 0 {name=l247 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1650 3 1 {name=M248
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 1680 3 0 {name=l248 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 1650 3 1 {name=M249
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 1680 3 0 {name=l249 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 1650 3 1 {name=M250
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 1680 3 0 {name=l250 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1650 3 1 {name=M251
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1680 3 0 {name=l251 lab=VDD}
C {devices/opin.sym} 2250 1750 0 0 {name=p45 lab=word21}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1720 2 1 {name=M252
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1720 3 0 {name=l252 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1720 2 1 {name=M253
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1720 3 0 {name=l253 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1720 2 1 {name=M254
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1720 3 0 {name=l254 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1720 2 1 {name=M255
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1720 3 0 {name=l255 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1720 2 1 {name=M256
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1720 3 0 {name=l256 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 1720 2 1 {name=M257
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 1720 3 0 {name=l257 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 1730 3 1 {name=M258
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 1760 3 0 {name=l258 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 1730 3 1 {name=M259
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 1760 3 0 {name=l259 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1730 3 1 {name=M260
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 1760 3 0 {name=l260 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 1730 3 1 {name=M261
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 1760 3 0 {name=l261 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 1730 3 1 {name=M262
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 1760 3 0 {name=l262 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1730 3 1 {name=M263
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1760 3 0 {name=l263 lab=VDD}
C {devices/opin.sym} 2250 1830 0 0 {name=p46 lab=word22}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1800 2 1 {name=M264
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1800 3 0 {name=l264 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1800 2 1 {name=M265
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1800 3 0 {name=l265 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1800 2 1 {name=M266
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1800 3 0 {name=l266 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1800 2 1 {name=M267
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1800 3 0 {name=l267 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1800 2 1 {name=M268
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 1800 3 0 {name=l268 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 1800 2 1 {name=M269
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 1800 3 0 {name=l269 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1810 3 1 {name=M270
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 1840 3 0 {name=l270 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1810 3 1 {name=M271
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1840 3 0 {name=l271 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1810 3 1 {name=M272
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 1840 3 0 {name=l272 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 1810 3 1 {name=M273
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 1840 3 0 {name=l273 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 1810 3 1 {name=M274
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 1840 3 0 {name=l274 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1810 3 1 {name=M275
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1840 3 0 {name=l275 lab=VDD}
C {devices/opin.sym} 2250 1910 0 0 {name=p47 lab=word23}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1880 2 1 {name=M276
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1880 3 0 {name=l276 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1880 2 1 {name=M277
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1880 3 0 {name=l277 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1880 2 1 {name=M278
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1880 3 0 {name=l278 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1880 2 1 {name=M279
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1880 3 0 {name=l279 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1880 2 1 {name=M280
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 1880 3 0 {name=l280 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 1880 2 1 {name=M281
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 1880 3 0 {name=l281 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 1890 3 1 {name=M282
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 1920 3 0 {name=l282 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1890 3 1 {name=M283
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1920 3 0 {name=l283 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1890 3 1 {name=M284
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 1920 3 0 {name=l284 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 1890 3 1 {name=M285
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 1920 3 0 {name=l285 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 1890 3 1 {name=M286
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 1920 3 0 {name=l286 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1890 3 1 {name=M287
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1920 3 0 {name=l287 lab=VDD}
C {devices/opin.sym} 2250 1990 0 0 {name=p48 lab=word24}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1960 2 1 {name=M288
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1960 3 0 {name=l288 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1960 2 1 {name=M289
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1960 3 0 {name=l289 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1960 2 1 {name=M290
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1960 3 0 {name=l290 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 1960 2 1 {name=M291
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 1960 3 0 {name=l291 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1960 2 1 {name=M292
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1960 3 0 {name=l292 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 1960 2 1 {name=M293
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 1960 3 0 {name=l293 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1970 3 1 {name=M294
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2000 3 0 {name=l294 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 1970 3 1 {name=M295
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2000 3 0 {name=l295 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1970 3 1 {name=M296
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2000 3 0 {name=l296 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1970 3 1 {name=M297
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2000 3 0 {name=l297 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 1970 3 1 {name=M298
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2000 3 0 {name=l298 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1970 3 1 {name=M299
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2000 3 0 {name=l299 lab=VDD}
C {devices/opin.sym} 2250 2070 0 0 {name=p49 lab=word25}
C {sky130_fd_pr/nfet_01v8.sym} 2100 2040 2 1 {name=M300
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 2040 3 0 {name=l300 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2040 2 1 {name=M301
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2040 3 0 {name=l301 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 2040 2 1 {name=M302
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 2040 3 0 {name=l302 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2040 2 1 {name=M303
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2040 3 0 {name=l303 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 2040 2 1 {name=M304
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 2040 3 0 {name=l304 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 2040 2 1 {name=M305
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 2040 3 0 {name=l305 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 2050 3 1 {name=M306
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 2080 3 0 {name=l306 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2050 3 1 {name=M307
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2080 3 0 {name=l307 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 2050 3 1 {name=M308
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2080 3 0 {name=l308 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2050 3 1 {name=M309
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2080 3 0 {name=l309 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 2050 3 1 {name=M310
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2080 3 0 {name=l310 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2050 3 1 {name=M311
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2080 3 0 {name=l311 lab=VDD}
C {devices/opin.sym} 2250 2150 0 0 {name=p50 lab=word26}
C {sky130_fd_pr/nfet_01v8.sym} 2100 2120 2 1 {name=M312
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 2120 3 0 {name=l312 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2120 2 1 {name=M313
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2120 3 0 {name=l313 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 2120 2 1 {name=M314
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 2120 3 0 {name=l314 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2120 2 1 {name=M315
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2120 3 0 {name=l315 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 2120 2 1 {name=M316
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 2120 3 0 {name=l316 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 2120 2 1 {name=M317
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 2120 3 0 {name=l317 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 2130 3 1 {name=M318
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2160 3 0 {name=l318 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 2130 3 1 {name=M319
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 2160 3 0 {name=l319 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 2130 3 1 {name=M320
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2160 3 0 {name=l320 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2130 3 1 {name=M321
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2160 3 0 {name=l321 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 2130 3 1 {name=M322
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2160 3 0 {name=l322 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2130 3 1 {name=M323
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2160 3 0 {name=l323 lab=VDD}
C {devices/opin.sym} 2250 2230 0 0 {name=p51 lab=word27}
C {sky130_fd_pr/nfet_01v8.sym} 2100 2200 2 1 {name=M324
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 2200 3 0 {name=l324 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2200 2 1 {name=M325
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2200 3 0 {name=l325 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 2200 2 1 {name=M326
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 2200 3 0 {name=l326 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2200 2 1 {name=M327
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2200 3 0 {name=l327 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 2200 2 1 {name=M328
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 2200 3 0 {name=l328 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 2200 2 1 {name=M329
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 2200 3 0 {name=l329 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 2210 3 1 {name=M330
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 2240 3 0 {name=l330 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 2210 3 1 {name=M331
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 2240 3 0 {name=l331 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 2210 3 1 {name=M332
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2240 3 0 {name=l332 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2210 3 1 {name=M333
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2240 3 0 {name=l333 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 2210 3 1 {name=M334
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2240 3 0 {name=l334 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2210 3 1 {name=M335
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2240 3 0 {name=l335 lab=VDD}
C {devices/opin.sym} 2250 2310 0 0 {name=p52 lab=word28}
C {sky130_fd_pr/nfet_01v8.sym} 2100 2280 2 1 {name=M336
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 2280 3 0 {name=l336 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2280 2 1 {name=M337
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2280 3 0 {name=l337 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 2280 2 1 {name=M338
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 2280 3 0 {name=l338 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 2280 2 1 {name=M339
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 2280 3 0 {name=l339 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 2280 2 1 {name=M340
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 2280 3 0 {name=l340 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 2280 2 1 {name=M341
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 2280 3 0 {name=l341 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 2290 3 1 {name=M342
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2320 3 0 {name=l342 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2290 3 1 {name=M343
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2320 3 0 {name=l343 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 2290 3 1 {name=M344
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2320 3 0 {name=l344 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2290 3 1 {name=M345
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2320 3 0 {name=l345 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 2290 3 1 {name=M346
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2320 3 0 {name=l346 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2290 3 1 {name=M347
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2320 3 0 {name=l347 lab=VDD}
C {devices/opin.sym} 2250 2390 0 0 {name=p53 lab=word29}
C {sky130_fd_pr/nfet_01v8.sym} 2100 2360 2 1 {name=M348
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 2360 3 0 {name=l348 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2360 2 1 {name=M349
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2360 3 0 {name=l349 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 2360 2 1 {name=M350
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 2360 3 0 {name=l350 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 2360 2 1 {name=M351
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 2360 3 0 {name=l351 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 2360 2 1 {name=M352
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 2360 3 0 {name=l352 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 2360 2 1 {name=M353
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 2360 3 0 {name=l353 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 2370 3 1 {name=M354
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 2400 3 0 {name=l354 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2370 3 1 {name=M355
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2400 3 0 {name=l355 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 2370 3 1 {name=M356
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2400 3 0 {name=l356 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2370 3 1 {name=M357
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2400 3 0 {name=l357 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 2370 3 1 {name=M358
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2400 3 0 {name=l358 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2370 3 1 {name=M359
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2400 3 0 {name=l359 lab=VDD}
C {devices/opin.sym} 2250 2470 0 0 {name=p54 lab=word30}
C {sky130_fd_pr/nfet_01v8.sym} 2100 2440 2 1 {name=M360
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 2440 3 0 {name=l360 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2440 2 1 {name=M361
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2440 3 0 {name=l361 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 2440 2 1 {name=M362
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 2440 3 0 {name=l362 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 2440 2 1 {name=M363
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 2440 3 0 {name=l363 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 2440 2 1 {name=M364
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 2440 3 0 {name=l364 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 2440 2 1 {name=M365
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 2440 3 0 {name=l365 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 2450 3 1 {name=M366
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2480 3 0 {name=l366 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 2450 3 1 {name=M367
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 2480 3 0 {name=l367 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 2450 3 1 {name=M368
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2480 3 0 {name=l368 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2450 3 1 {name=M369
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2480 3 0 {name=l369 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 2450 3 1 {name=M370
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2480 3 0 {name=l370 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2450 3 1 {name=M371
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2480 3 0 {name=l371 lab=VDD}
C {devices/opin.sym} 2250 2550 0 0 {name=p55 lab=word31}
C {sky130_fd_pr/nfet_01v8.sym} 2100 2520 2 1 {name=M372
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 2520 3 0 {name=l372 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2520 2 1 {name=M373
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2520 3 0 {name=l373 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 2520 2 1 {name=M374
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 2520 3 0 {name=l374 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 2520 2 1 {name=M375
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 2520 3 0 {name=l375 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 2520 2 1 {name=M376
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 2520 3 0 {name=l376 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 2520 2 1 {name=M377
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 2520 3 0 {name=l377 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 2530 3 1 {name=M378
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 2560 3 0 {name=l378 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 2530 3 1 {name=M379
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 2560 3 0 {name=l379 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 2530 3 1 {name=M380
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2560 3 0 {name=l380 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2530 3 1 {name=M381
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2560 3 0 {name=l381 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 2530 3 1 {name=M382
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2560 3 0 {name=l382 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2530 3 1 {name=M383
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2560 3 0 {name=l383 lab=VDD}
C {devices/opin.sym} 2250 2630 0 0 {name=p56 lab=word32}
C {sky130_fd_pr/nfet_01v8.sym} 2190 2600 2 1 {name=M384
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 2600 3 0 {name=l384 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 2600 2 1 {name=M385
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 2600 3 0 {name=l385 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 2600 2 1 {name=M386
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 2600 3 0 {name=l386 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2600 2 1 {name=M387
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2600 3 0 {name=l387 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 2600 2 1 {name=M388
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 2600 3 0 {name=l388 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 2600 2 1 {name=M389
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 2600 3 0 {name=l389 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 2610 3 1 {name=M390
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2640 3 0 {name=l390 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2610 3 1 {name=M391
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2640 3 0 {name=l391 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 2610 3 1 {name=M392
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2640 3 0 {name=l392 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 2610 3 1 {name=M393
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 2640 3 0 {name=l393 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 2610 3 1 {name=M394
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2640 3 0 {name=l394 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 40 2610 3 1 {name=M395
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 40 2640 3 0 {name=l395 lab=VDD}
C {devices/opin.sym} 2250 2710 0 0 {name=p57 lab=word33}
C {sky130_fd_pr/nfet_01v8.sym} 2190 2680 2 1 {name=M396
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 2680 3 0 {name=l396 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 2680 2 1 {name=M397
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 2680 3 0 {name=l397 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 2680 2 1 {name=M398
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 2680 3 0 {name=l398 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2680 2 1 {name=M399
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2680 3 0 {name=l399 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 2680 2 1 {name=M400
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 2680 3 0 {name=l400 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 2680 2 1 {name=M401
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 2680 3 0 {name=l401 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 2690 3 1 {name=M402
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 2720 3 0 {name=l402 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2690 3 1 {name=M403
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2720 3 0 {name=l403 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 2690 3 1 {name=M404
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2720 3 0 {name=l404 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 2690 3 1 {name=M405
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 2720 3 0 {name=l405 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 2690 3 1 {name=M406
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2720 3 0 {name=l406 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 40 2690 3 1 {name=M407
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 40 2720 3 0 {name=l407 lab=VDD}
C {devices/opin.sym} 2250 2790 0 0 {name=p58 lab=word34}
C {sky130_fd_pr/nfet_01v8.sym} 2190 2760 2 1 {name=M408
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 2760 3 0 {name=l408 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 2760 2 1 {name=M409
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 2760 3 0 {name=l409 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 2760 2 1 {name=M410
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 2760 3 0 {name=l410 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2760 2 1 {name=M411
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2760 3 0 {name=l411 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 2760 2 1 {name=M412
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 2760 3 0 {name=l412 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 2760 2 1 {name=M413
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 2760 3 0 {name=l413 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 2770 3 1 {name=M414
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2800 3 0 {name=l414 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 2770 3 1 {name=M415
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 2800 3 0 {name=l415 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 2770 3 1 {name=M416
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2800 3 0 {name=l416 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 2770 3 1 {name=M417
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 2800 3 0 {name=l417 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 2770 3 1 {name=M418
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2800 3 0 {name=l418 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 40 2770 3 1 {name=M419
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 40 2800 3 0 {name=l419 lab=VDD}
C {devices/opin.sym} 2250 2870 0 0 {name=p59 lab=word35}
C {sky130_fd_pr/nfet_01v8.sym} 2190 2840 2 1 {name=M420
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 2840 3 0 {name=l420 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 2840 2 1 {name=M421
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 2840 3 0 {name=l421 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 2840 2 1 {name=M422
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 2840 3 0 {name=l422 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2840 2 1 {name=M423
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2840 3 0 {name=l423 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 2840 2 1 {name=M424
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 2840 3 0 {name=l424 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 2840 2 1 {name=M425
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 2840 3 0 {name=l425 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 2850 3 1 {name=M426
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 2880 3 0 {name=l426 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 2850 3 1 {name=M427
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 2880 3 0 {name=l427 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 2850 3 1 {name=M428
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2880 3 0 {name=l428 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 2850 3 1 {name=M429
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 2880 3 0 {name=l429 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 2850 3 1 {name=M430
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2880 3 0 {name=l430 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 40 2850 3 1 {name=M431
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 40 2880 3 0 {name=l431 lab=VDD}
C {devices/opin.sym} 2250 2950 0 0 {name=p60 lab=word36}
C {sky130_fd_pr/nfet_01v8.sym} 2190 2920 2 1 {name=M432
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 2920 3 0 {name=l432 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 2920 2 1 {name=M433
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 2920 3 0 {name=l433 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 2920 2 1 {name=M434
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 2920 3 0 {name=l434 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 2920 2 1 {name=M435
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 2920 3 0 {name=l435 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 2920 2 1 {name=M436
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 2920 3 0 {name=l436 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 2920 2 1 {name=M437
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 2920 3 0 {name=l437 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 2930 3 1 {name=M438
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2960 3 0 {name=l438 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2930 3 1 {name=M439
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2960 3 0 {name=l439 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 2930 3 1 {name=M440
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2960 3 0 {name=l440 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 2930 3 1 {name=M441
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 2960 3 0 {name=l441 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 2930 3 1 {name=M442
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2960 3 0 {name=l442 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 40 2930 3 1 {name=M443
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 40 2960 3 0 {name=l443 lab=VDD}
C {devices/opin.sym} 2250 3030 0 0 {name=p61 lab=word37}
C {sky130_fd_pr/nfet_01v8.sym} 2190 3000 2 1 {name=M444
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 3000 3 0 {name=l444 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 3000 2 1 {name=M445
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 3000 3 0 {name=l445 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 3000 2 1 {name=M446
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 3000 3 0 {name=l446 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 3000 2 1 {name=M447
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 3000 3 0 {name=l447 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 3000 2 1 {name=M448
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 3000 3 0 {name=l448 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 3000 2 1 {name=M449
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 3000 3 0 {name=l449 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 3010 3 1 {name=M450
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 3040 3 0 {name=l450 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 3010 3 1 {name=M451
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 3040 3 0 {name=l451 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 3010 3 1 {name=M452
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 3040 3 0 {name=l452 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3010 3 1 {name=M453
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3040 3 0 {name=l453 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 3010 3 1 {name=M454
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 3040 3 0 {name=l454 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 40 3010 3 1 {name=M455
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 40 3040 3 0 {name=l455 lab=VDD}
C {devices/opin.sym} 2250 3110 0 0 {name=p62 lab=word38}
C {sky130_fd_pr/nfet_01v8.sym} 2190 3080 2 1 {name=M456
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 3080 3 0 {name=l456 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 3080 2 1 {name=M457
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 3080 3 0 {name=l457 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 3080 2 1 {name=M458
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 3080 3 0 {name=l458 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 3080 2 1 {name=M459
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 3080 3 0 {name=l459 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 3080 2 1 {name=M460
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 3080 3 0 {name=l460 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 3080 2 1 {name=M461
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 3080 3 0 {name=l461 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 3090 3 1 {name=M462
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 3120 3 0 {name=l462 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 3090 3 1 {name=M463
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 3120 3 0 {name=l463 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 3090 3 1 {name=M464
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 3120 3 0 {name=l464 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3090 3 1 {name=M465
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3120 3 0 {name=l465 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 3090 3 1 {name=M466
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 3120 3 0 {name=l466 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 40 3090 3 1 {name=M467
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 40 3120 3 0 {name=l467 lab=VDD}
C {devices/opin.sym} 2250 3190 0 0 {name=p63 lab=word39}
C {sky130_fd_pr/nfet_01v8.sym} 2190 3160 2 1 {name=M468
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 3160 3 0 {name=l468 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 3160 2 1 {name=M469
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 3160 3 0 {name=l469 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 3160 2 1 {name=M470
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 3160 3 0 {name=l470 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 3160 2 1 {name=M471
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 3160 3 0 {name=l471 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 3160 2 1 {name=M472
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 3160 3 0 {name=l472 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 3160 2 1 {name=M473
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 3160 3 0 {name=l473 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 3170 3 1 {name=M474
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 3200 3 0 {name=l474 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 3170 3 1 {name=M475
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 3200 3 0 {name=l475 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 3170 3 1 {name=M476
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 3200 3 0 {name=l476 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3170 3 1 {name=M477
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3200 3 0 {name=l477 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 3170 3 1 {name=M478
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 3200 3 0 {name=l478 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 40 3170 3 1 {name=M479
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 40 3200 3 0 {name=l479 lab=VDD}
C {devices/opin.sym} 2250 3270 0 0 {name=p64 lab=word40}
C {sky130_fd_pr/nfet_01v8.sym} 2190 3240 2 1 {name=M480
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 3240 3 0 {name=l480 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 3240 2 1 {name=M481
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 3240 3 0 {name=l481 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 3240 2 1 {name=M482
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 3240 3 0 {name=l482 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 3240 2 1 {name=M483
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 3240 3 0 {name=l483 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 3240 2 1 {name=M484
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 3240 3 0 {name=l484 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1200 3240 2 1 {name=M485
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1230 3240 3 0 {name=l485 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1030 3250 3 1 {name=M486
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 3280 3 0 {name=l486 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 3250 3 1 {name=M487
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 3280 3 0 {name=l487 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 3250 3 1 {name=M488
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 3280 3 0 {name=l488 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 3250 3 1 {name=M489
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 3280 3 0 {name=l489 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 3250 3 1 {name=M490
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 3280 3 0 {name=l490 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 40 3250 3 1 {name=M491
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 40 3280 3 0 {name=l491 lab=VDD}
C {devices/opin.sym} 2250 3350 0 0 {name=p65 lab=word41}
C {sky130_fd_pr/nfet_01v8.sym} 2190 3320 2 1 {name=M492
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 3320 3 0 {name=l492 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 3320 2 1 {name=M493
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 3320 3 0 {name=l493 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 3320 2 1 {name=M494
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 3320 3 0 {name=l494 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 3320 2 1 {name=M495
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 3320 3 0 {name=l495 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 3320 2 1 {name=M496
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 3320 3 0 {name=l496 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1290 3320 2 1 {name=M497
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1320 3320 3 0 {name=l497 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 940 3330 3 1 {name=M498
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 3360 3 0 {name=l498 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 3330 3 1 {name=M499
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 3360 3 0 {name=l499 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 3330 3 1 {name=M500
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 3360 3 0 {name=l500 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 3330 3 1 {name=M501
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 3360 3 0 {name=l501 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 3330 3 1 {name=M502
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 3360 3 0 {name=l502 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 40 3330 3 1 {name=M503
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 40 3360 3 0 {name=l503 lab=VDD}
C {devices/opin.sym} 2250 3430 0 0 {name=p66 lab=word42}
C {sky130_fd_pr/nfet_01v8.sym} 2190 3400 2 1 {name=M504
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
