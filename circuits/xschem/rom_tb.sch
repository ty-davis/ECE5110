v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 980 -110 980 -10 {
lab=Y1}
N 980 50 980 80 {
lab=GND}
N -70 -70 -70 -10 {
lab=GND}
N -70 -170 -70 -130 {
lab=VDD}
N 980 -120 980 -110 {lab=Y1}
N 920 -120 980 -120 {lab=Y1}
N 1050 -130 1050 -30 {
lab=Y0}
N 1050 30 1050 60 {
lab=GND}
N 1050 -140 1050 -130 {lab=Y0}
N 990 -140 1050 -140 {lab=Y0}
N 870 -140 990 -140 {
lab=Y0}
N 870 -120 920 -120 {
lab=Y1}
N 860 -70 860 30 {
lab=Y3}
N 860 90 860 120 {
lab=GND}
N 860 -80 860 -70 {lab=Y3}
N 800 -80 860 -80 {lab=Y3}
N 930 -90 930 10 {
lab=Y2}
N 930 70 930 100 {
lab=GND}
N 930 -100 930 -90 {lab=Y2}
N 870 -100 930 -100 {lab=Y2}
N 750 -100 870 -100 {
lab=Y2}
N 750 -80 800 -80 {
lab=Y3}
N 730 -30 730 70 {
lab=Y5}
N 730 130 730 160 {
lab=GND}
N 730 -40 730 -30 {lab=Y5}
N 800 -50 800 50 {
lab=Y4}
N 800 110 800 140 {
lab=GND}
N 800 -60 800 -50 {lab=Y4}
N 740 -60 800 -60 {lab=Y4}
N 610 10 610 110 {
lab=Y7}
N 610 170 610 200 {
lab=GND}
N 610 0 610 10 {lab=Y7}
N 680 -10 680 90 {
lab=Y6}
N 680 150 680 180 {
lab=GND}
N 680 -20 680 -10 {lab=Y6}
N 610 0 620 0 {
lab=Y7}
N 620 -40 620 0 {
lab=Y7}
N 680 -60 680 -20 {
lab=Y6}
N 620 -60 680 -60 {
lab=Y6}
N 700 -40 730 -40 {
lab=Y5}
N 700 -80 700 -40 {
lab=Y5}
N 620 -80 700 -80 {
lab=Y5}
N 720 -60 740 -60 {
lab=Y4}
N 720 -100 720 -60 {
lab=Y4}
N 620 -100 720 -100 {
lab=Y4}
N 730 -80 750 -80 {
lab=Y3}
N 730 -120 730 -80 {
lab=Y3}
N 620 -120 730 -120 {
lab=Y3}
N 740 -100 750 -100 {
lab=Y2}
N 740 -140 740 -100 {
lab=Y2}
N 620 -140 740 -140 {
lab=Y2}
N 760 -120 870 -120 {
lab=Y1}
N 760 -160 760 -120 {
lab=Y1}
N 620 -160 760 -160 {
lab=Y1}
N 780 -140 870 -140 {
lab=Y0}
N 780 -180 780 -140 {
lab=Y0}
N 620 -180 780 -180 {
lab=Y0}
N 300 -180 320 -180 {lab=GND}
N 300 -160 320 -160 {lab=GND}
N 300 -140 320 -140 {lab=GND}
N 300 -120 320 -120 {lab=GND}
N 300 -100 320 -100 {lab=GND}
N 300 -80 320 -80 {lab=GND}
N 300 -60 320 -60 {lab=GND}
N 300 -40 320 -40 {lab=GND}
N 300 -20 320 -20 {lab=GND}
N 300 0 320 0 {lab=GND}
N 300 20 320 20 {lab=GND}
N 300 40 320 40 {lab=GND}
N 300 60 320 60 {lab=GND}
N 300 80 320 80 {lab=GND}
N 300 100 320 100 {lab=GND}
N 300 120 320 120 {lab=GND}
N 300 140 320 140 {lab=GND}
N 300 160 320 160 {lab=GND}
N 300 180 320 180 {lab=GND}
N 300 200 320 200 {lab=GND}
N 300 220 320 220 {lab=GND}
N 300 240 320 240 {lab=GND}
N 300 260 320 260 {lab=GND}
N 300 280 320 280 {lab=GND}
N 300 300 320 300 {lab=GND}
N 300 320 320 320 {lab=GND}
N 300 340 320 340 {lab=GND}
N 300 360 320 360 {lab=GND}
N 300 380 320 380 {lab=GND}
N 300 400 320 400 {lab=GND}
N 300 420 320 420 {lab=GND}
N 300 440 320 440 {lab=GND}
N 300 460 320 460 {lab=GND}
N 300 480 320 480 {lab=GND}
N 300 500 320 500 {lab=GND}
N 300 520 320 520 {lab=GND}
N 300 540 320 540 {lab=GND}
N 300 560 320 560 {lab=GND}
N 300 580 320 580 {lab=GND}
N 300 600 320 600 {lab=GND}
N 300 620 320 620 {lab=GND}
N 300 640 320 640 {lab=GND}
N 300 660 320 660 {lab=GND}
N 300 680 320 680 {lab=GND}
N 300 700 320 700 {lab=GND}
N 300 720 320 720 {lab=GND}
N 300 740 320 740 {lab=GND}
N 300 760 320 760 {lab=GND}
N 300 780 320 780 {lab=GND}
N 300 800 320 800 {lab=GND}
N 300 820 320 820 {lab=GND}
N 300 840 320 840 {lab=GND}
N 300 860 320 860 {lab=GND}
N 300 880 320 880 {lab=GND}
N 300 900 320 900 {lab=GND}
N 300 920 320 920 {lab=GND}
N 300 940 320 940 {lab=GND}
N 300 960 320 960 {lab=GND}
N 300 980 320 980 {lab=GND}
N 300 1000 320 1000 {lab=GND}
N 300 1020 320 1020 {lab=GND}
N 300 1040 320 1040 {lab=GND}
N 300 1060 320 1060 {lab=GND}
N 300 1080 320 1080 {lab=GND}
N 300 1100 320 1100 {lab=GND}
N 300 1120 320 1120 {lab=GND}
N 300 1140 320 1140 {lab=GND}
N 300 1160 320 1160 {lab=GND}
N 300 1180 320 1180 {lab=GND}
N 300 1200 320 1200 {lab=GND}
N 300 1220 320 1220 {lab=GND}
N 300 1240 320 1240 {lab=GND}
N 300 1260 320 1260 {lab=GND}
N 300 1280 320 1280 {lab=GND}
N 300 1300 320 1300 {lab=GND}
N 300 1320 320 1320 {lab=GND}
N 300 1340 320 1340 {lab=GND}
N 300 1360 320 1360 {lab=GND}
N 300 1380 320 1380 {lab=GND}
N 300 1400 320 1400 {lab=GND}
N 300 1420 320 1420 {lab=GND}
N 300 1440 320 1440 {lab=GND}
N 300 1460 320 1460 {lab=GND}
N 300 1480 320 1480 {lab=GND}
N 300 1500 320 1500 {lab=GND}
N 300 1520 320 1520 {lab=GND}
N 300 1540 320 1540 {lab=GND}
N 300 1560 320 1560 {lab=GND}
N 300 1580 320 1580 {lab=GND}
N 300 1600 320 1600 {lab=VDD}
N 300 1620 320 1620 {lab=GND}
N 300 1640 320 1640 {lab=GND}
N 300 1660 320 1660 {lab=GND}
N 300 1680 320 1680 {lab=GND}
N 300 1700 320 1700 {lab=GND}
N 300 1720 320 1720 {lab=GND}
N 300 1740 320 1740 {lab=GND}
N 300 1760 320 1760 {lab=GND}
N 300 1780 320 1780 {lab=GND}
N 300 1800 320 1800 {lab=GND}
N 300 1820 320 1820 {lab=GND}
N 300 1840 320 1840 {lab=GND}
N 300 1860 320 1860 {lab=GND}
N 300 1880 320 1880 {lab=GND}
N 300 1900 320 1900 {lab=GND}
N 300 1920 320 1920 {lab=GND}
N 300 1940 320 1940 {lab=GND}
N 300 1960 320 1960 {lab=GND}
N 300 1980 320 1980 {lab=GND}
N 300 2000 320 2000 {lab=GND}
N 300 2020 320 2020 {lab=GND}
N 300 2040 320 2040 {lab=GND}
N 300 2060 320 2060 {lab=GND}
N 300 2080 320 2080 {lab=GND}
N 300 2100 320 2100 {lab=GND}
N 300 2120 320 2120 {lab=GND}
N 300 2140 320 2140 {lab=GND}
N 300 2160 320 2160 {lab=GND}
N 300 2180 320 2180 {lab=GND}
N 300 2200 320 2200 {lab=GND}
N 300 2220 320 2220 {lab=GND}
N 300 2240 320 2240 {lab=GND}
N 300 2260 320 2260 {lab=GND}
N 300 2280 320 2280 {lab=GND}
N 300 2300 320 2300 {lab=GND}
N 300 2320 320 2320 {lab=GND}
N 300 2340 320 2340 {lab=GND}
N 300 2360 320 2360 {lab=GND}
N 300 2380 320 2380 {lab=GND}
N 300 2400 320 2400 {lab=GND}
N 300 2420 320 2420 {lab=GND}
N 300 2440 320 2440 {lab=GND}
N 300 2460 320 2460 {lab=GND}
N 300 2480 320 2480 {lab=GND}
N 300 2500 320 2500 {lab=GND}
N 300 2520 320 2520 {lab=GND}
N 300 2540 320 2540 {lab=GND}
N 300 2560 320 2560 {lab=GND}
N 300 2580 320 2580 {lab=GND}
N 300 2600 320 2600 {lab=GND}
N 300 2620 320 2620 {lab=GND}
N 300 2640 320 2640 {lab=GND}
N 300 2660 320 2660 {lab=GND}
N 300 2680 320 2680 {lab=GND}
N 300 2700 320 2700 {lab=GND}
N 300 2720 320 2720 {lab=GND}
N 300 2740 320 2740 {lab=GND}
N 300 2760 320 2760 {lab=GND}
N 300 2780 320 2780 {lab=GND}
N 300 2800 320 2800 {lab=GND}
N 300 2820 320 2820 {lab=GND}
N 300 2840 320 2840 {lab=GND}
N 300 2860 320 2860 {lab=GND}
N 300 2880 320 2880 {lab=GND}
N 300 2900 320 2900 {lab=GND}
N 300 2920 320 2920 {lab=GND}
N 300 2940 320 2940 {lab=GND}
N 300 2960 320 2960 {lab=GND}
N 300 2980 320 2980 {lab=GND}
N 300 3000 320 3000 {lab=GND}
N 300 3020 320 3020 {lab=GND}
N 300 3040 320 3040 {lab=GND}
N 300 3060 320 3060 {lab=GND}
N 300 3080 320 3080 {lab=GND}
N 300 3100 320 3100 {lab=GND}
N 300 3120 320 3120 {lab=GND}
N 300 3140 320 3140 {lab=GND}
N 300 3160 320 3160 {lab=GND}
N 300 3180 320 3180 {lab=GND}
N 300 3200 320 3200 {lab=GND}
N 300 3220 320 3220 {lab=GND}
N 300 3240 320 3240 {lab=GND}
N 300 3260 320 3260 {lab=GND}
N 300 3280 320 3280 {lab=GND}
N 300 3300 320 3300 {lab=GND}
N 300 3320 320 3320 {lab=GND}
N 300 3340 320 3340 {lab=GND}
N 300 3360 320 3360 {lab=GND}
N 300 3380 320 3380 {lab=GND}
N 300 3400 320 3400 {lab=GND}
N 300 3420 320 3420 {lab=GND}
N 300 3440 320 3440 {lab=GND}
N 300 3460 320 3460 {lab=GND}
N 300 3480 320 3480 {lab=GND}
N 300 3500 320 3500 {lab=GND}
N 300 3520 320 3520 {lab=GND}
N 300 3540 320 3540 {lab=GND}
N 300 3560 320 3560 {lab=GND}
N 300 3580 320 3580 {lab=GND}
N 300 3600 320 3600 {lab=GND}
N 300 3620 320 3620 {lab=GND}
N 300 3640 320 3640 {lab=GND}
N 300 3660 320 3660 {lab=GND}
N 300 3680 320 3680 {lab=GND}
N 300 3700 320 3700 {lab=GND}
N 300 3720 320 3720 {lab=GND}
N 300 3740 320 3740 {lab=GND}
N 300 3760 320 3760 {lab=GND}
N 300 3780 320 3780 {lab=GND}
N 300 3800 320 3800 {lab=GND}
N 300 3820 320 3820 {lab=GND}
N 300 3840 320 3840 {lab=GND}
N 300 3860 320 3860 {lab=GND}
N 300 3880 320 3880 {lab=GND}
N 300 3900 320 3900 {lab=GND}
N 300 3920 320 3920 {lab=GND}
N 300 3940 320 3940 {lab=GND}
N 300 3960 320 3960 {lab=GND}
N 300 3980 320 3980 {lab=GND}
N 300 4000 320 4000 {lab=GND}
N 300 4020 320 4020 {lab=GND}
N 300 4040 320 4040 {lab=GND}
N 300 4060 320 4060 {lab=GND}
N 300 4080 320 4080 {lab=GND}
N 300 4100 320 4100 {lab=GND}
N 300 4120 320 4120 {lab=GND}
N 300 4140 320 4140 {lab=GND}
N 300 4160 320 4160 {lab=GND}
N 300 4180 320 4180 {lab=GND}
N 300 4200 320 4200 {lab=GND}
N 300 4220 320 4220 {lab=GND}
N 300 4240 320 4240 {lab=GND}
N 300 4260 320 4260 {lab=GND}
N 300 4280 320 4280 {lab=GND}
N 300 4300 320 4300 {lab=GND}
N 300 4320 320 4320 {lab=GND}
N 300 4340 320 4340 {lab=GND}
N 300 4360 320 4360 {lab=GND}
N 300 4380 320 4380 {lab=GND}
N 300 4400 320 4400 {lab=GND}
N 300 4420 320 4420 {lab=GND}
N 300 4440 320 4440 {lab=GND}
N 300 4460 320 4460 {lab=GND}
N 300 4480 320 4480 {lab=GND}
N 300 4500 320 4500 {lab=GND}
N 300 4520 320 4520 {lab=GND}
N 300 4540 320 4540 {lab=GND}
N 300 4560 320 4560 {lab=GND}
N 300 4580 320 4580 {lab=GND}
N 300 4600 320 4600 {lab=GND}
N 300 4620 320 4620 {lab=GND}
N 300 4640 320 4640 {lab=GND}
N 300 4660 320 4660 {lab=GND}
N 300 4680 320 4680 {lab=GND}
N 300 4700 320 4700 {lab=GND}
N 300 4720 320 4720 {lab=GND}
N 300 4740 320 4740 {lab=GND}
N 300 4760 320 4760 {lab=GND}
N 300 4780 320 4780 {lab=GND}
N 300 4800 320 4800 {lab=GND}
N 300 4820 320 4820 {lab=GND}
N 300 4840 320 4840 {lab=GND}
N 300 4860 320 4860 {lab=GND}
N 300 4880 320 4880 {lab=GND}
N 300 4900 320 4900 {lab=GND}
N 300 4920 320 4920 {lab=GND}
N 250 1600 300 1600 {lab=VDD}
C {devices/vdd.sym} -70 -170 0 0 {name=l1 lab=VDD}
C {devices/vsource.sym} -70 -100 0 0 {name=V1 value=1.8 savecurrent=false}
C {devices/gnd.sym} -70 -10 0 0 {name=l2 lab=GND}
C {devices/capa.sym} 980 20 0 0 {name=C1
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 980 80 0 0 {name=l4 lab=GND}
C {devices/code.sym} 60 -360 0 0 {name=s1 only_toplevel=false value="
.control
save all
tran 1n 2u
plot V(Y0)+4 V(Y1)+6 V(Y2)+8 V(Y3)+10 V(Y4)+12 V(Y5)+14 V(Y6)+16 V(Y7)+18
.endc
"}
C {devices/code.sym} 480 -320 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false
}
C {devices/lab_pin.sym} 980 -110 0 0 {name=p2 sig_type=std_logic lab=Y1}
C {devices/capa.sym} 1050 0 0 0 {name=C2
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1050 60 0 0 {name=l6 lab=GND}
C {devices/lab_pin.sym} 1050 -130 0 0 {name=p4 sig_type=std_logic lab=Y0}
C {devices/capa.sym} 860 60 0 0 {name=C3
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 860 120 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 860 -70 0 0 {name=p5 sig_type=std_logic lab=Y3}
C {devices/capa.sym} 930 40 0 0 {name=C4
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 930 100 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 930 -90 0 0 {name=p6 sig_type=std_logic lab=Y2}
C {devices/capa.sym} 730 100 0 0 {name=C5
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 730 160 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 730 -30 0 0 {name=p7 sig_type=std_logic lab=Y5}
C {devices/capa.sym} 800 80 0 0 {name=C6
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 800 140 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 800 -50 0 0 {name=p8 sig_type=std_logic lab=Y4}
C {devices/capa.sym} 610 140 0 0 {name=C7
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 610 200 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 610 10 0 0 {name=p9 sig_type=std_logic lab=Y7}
C {devices/capa.sym} 680 120 0 0 {name=C8
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 680 180 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} 680 -10 0 0 {name=p10 sig_type=std_logic lab=Y6}
C {rom.sym} 470 2370 0 0 {name=x1}
C {devices/gnd.sym} 300 -180 1 0 {name=l3 lab=GND}
C {devices/gnd.sym} 300 -140 1 0 {name=l13 lab=GND}
C {devices/gnd.sym} 300 -120 1 0 {name=l14 lab=GND}
C {devices/gnd.sym} 300 -100 1 0 {name=l15 lab=GND}
C {devices/gnd.sym} 300 -80 1 0 {name=l16 lab=GND}
C {devices/gnd.sym} 300 -60 1 0 {name=l17 lab=GND}
C {devices/gnd.sym} 300 -40 1 0 {name=l18 lab=GND}
C {devices/gnd.sym} 300 -20 1 0 {name=l19 lab=GND}
C {devices/gnd.sym} 300 0 1 0 {name=l20 lab=GND}
C {devices/gnd.sym} 300 20 1 0 {name=l21 lab=GND}
C {devices/gnd.sym} 300 40 1 0 {name=l22 lab=GND}
C {devices/gnd.sym} 300 60 1 0 {name=l23 lab=GND}
C {devices/gnd.sym} 300 80 1 0 {name=l24 lab=GND}
C {devices/gnd.sym} 300 100 1 0 {name=l25 lab=GND}
C {devices/gnd.sym} 300 120 1 0 {name=l26 lab=GND}
C {devices/gnd.sym} 300 140 1 0 {name=l27 lab=GND}
C {devices/gnd.sym} 300 160 1 0 {name=l28 lab=GND}
C {devices/gnd.sym} 300 180 1 0 {name=l29 lab=GND}
C {devices/gnd.sym} 300 200 1 0 {name=l30 lab=GND}
C {devices/gnd.sym} 300 220 1 0 {name=l31 lab=GND}
C {devices/gnd.sym} 300 240 1 0 {name=l32 lab=GND}
C {devices/gnd.sym} 300 260 1 0 {name=l33 lab=GND}
C {devices/gnd.sym} 300 280 1 0 {name=l34 lab=GND}
C {devices/gnd.sym} 300 300 1 0 {name=l35 lab=GND}
C {devices/gnd.sym} 300 320 1 0 {name=l36 lab=GND}
C {devices/gnd.sym} 300 340 1 0 {name=l37 lab=GND}
C {devices/gnd.sym} 300 360 1 0 {name=l38 lab=GND}
C {devices/gnd.sym} 300 380 1 0 {name=l39 lab=GND}
C {devices/gnd.sym} 300 400 1 0 {name=l40 lab=GND}
C {devices/gnd.sym} 300 420 1 0 {name=l41 lab=GND}
C {devices/gnd.sym} 300 440 1 0 {name=l42 lab=GND}
C {devices/gnd.sym} 300 460 1 0 {name=l43 lab=GND}
C {devices/gnd.sym} 300 480 1 0 {name=l44 lab=GND}
C {devices/gnd.sym} 300 500 1 0 {name=l45 lab=GND}
C {devices/gnd.sym} 300 520 1 0 {name=l46 lab=GND}
C {devices/gnd.sym} 300 540 1 0 {name=l47 lab=GND}
C {devices/gnd.sym} 300 560 1 0 {name=l48 lab=GND}
C {devices/gnd.sym} 300 580 1 0 {name=l49 lab=GND}
C {devices/gnd.sym} 300 600 1 0 {name=l50 lab=GND}
C {devices/gnd.sym} 300 620 1 0 {name=l51 lab=GND}
C {devices/gnd.sym} 300 640 1 0 {name=l52 lab=GND}
C {devices/gnd.sym} 300 660 1 0 {name=l53 lab=GND}
C {devices/gnd.sym} 300 680 1 0 {name=l54 lab=GND}
C {devices/gnd.sym} 300 700 1 0 {name=l55 lab=GND}
C {devices/gnd.sym} 300 720 1 0 {name=l56 lab=GND}
C {devices/gnd.sym} 300 740 1 0 {name=l57 lab=GND}
C {devices/gnd.sym} 300 760 1 0 {name=l58 lab=GND}
C {devices/gnd.sym} 300 780 1 0 {name=l59 lab=GND}
C {devices/gnd.sym} 300 800 1 0 {name=l60 lab=GND}
C {devices/gnd.sym} 300 820 1 0 {name=l61 lab=GND}
C {devices/gnd.sym} 300 840 1 0 {name=l62 lab=GND}
C {devices/gnd.sym} 300 860 1 0 {name=l63 lab=GND}
C {devices/gnd.sym} 300 880 1 0 {name=l64 lab=GND}
C {devices/gnd.sym} 300 900 1 0 {name=l65 lab=GND}
C {devices/gnd.sym} 300 920 1 0 {name=l66 lab=GND}
C {devices/gnd.sym} 300 940 1 0 {name=l67 lab=GND}
C {devices/gnd.sym} 300 960 1 0 {name=l68 lab=GND}
C {devices/gnd.sym} 300 980 1 0 {name=l69 lab=GND}
C {devices/gnd.sym} 300 1000 1 0 {name=l70 lab=GND}
C {devices/gnd.sym} 300 1020 1 0 {name=l71 lab=GND}
C {devices/gnd.sym} 300 1040 1 0 {name=l72 lab=GND}
C {devices/gnd.sym} 300 1060 1 0 {name=l73 lab=GND}
C {devices/gnd.sym} 300 1100 1 0 {name=l75 lab=GND}
C {devices/gnd.sym} 300 1120 1 0 {name=l76 lab=GND}
C {devices/gnd.sym} 300 1140 1 0 {name=l77 lab=GND}
C {devices/gnd.sym} 300 1160 1 0 {name=l78 lab=GND}
C {devices/gnd.sym} 300 1180 1 0 {name=l79 lab=GND}
C {devices/gnd.sym} 300 1200 1 0 {name=l80 lab=GND}
C {devices/gnd.sym} 300 1220 1 0 {name=l81 lab=GND}
C {devices/gnd.sym} 300 1240 1 0 {name=l82 lab=GND}
C {devices/gnd.sym} 300 1260 1 0 {name=l83 lab=GND}
C {devices/gnd.sym} 300 1280 1 0 {name=l84 lab=GND}
C {devices/gnd.sym} 300 1300 1 0 {name=l85 lab=GND}
C {devices/gnd.sym} 300 1320 1 0 {name=l86 lab=GND}
C {devices/gnd.sym} 300 1340 1 0 {name=l87 lab=GND}
C {devices/gnd.sym} 300 1360 1 0 {name=l88 lab=GND}
C {devices/gnd.sym} 300 1380 1 0 {name=l89 lab=GND}
C {devices/gnd.sym} 300 1400 1 0 {name=l90 lab=GND}
C {devices/gnd.sym} 300 1420 1 0 {name=l91 lab=GND}
C {devices/gnd.sym} 300 1440 1 0 {name=l92 lab=GND}
C {devices/gnd.sym} 300 1460 1 0 {name=l93 lab=GND}
C {devices/gnd.sym} 300 1480 1 0 {name=l94 lab=GND}
C {devices/gnd.sym} 300 1500 1 0 {name=l95 lab=GND}
C {devices/gnd.sym} 300 1520 1 0 {name=l96 lab=GND}
C {devices/gnd.sym} 300 1540 1 0 {name=l97 lab=GND}
C {devices/gnd.sym} 300 1560 1 0 {name=l98 lab=GND}
C {devices/gnd.sym} 300 1580 1 0 {name=l100 lab=GND}
C {devices/gnd.sym} 300 1620 1 0 {name=l101 lab=GND}
C {devices/gnd.sym} 300 1640 1 0 {name=l102 lab=GND}
C {devices/gnd.sym} 300 1660 1 0 {name=l103 lab=GND}
C {devices/gnd.sym} 300 1680 1 0 {name=l104 lab=GND}
C {devices/gnd.sym} 300 1700 1 0 {name=l105 lab=GND}
C {devices/gnd.sym} 300 1720 1 0 {name=l106 lab=GND}
C {devices/gnd.sym} 300 1740 1 0 {name=l107 lab=GND}
C {devices/gnd.sym} 300 1760 1 0 {name=l108 lab=GND}
C {devices/gnd.sym} 300 1780 1 0 {name=l109 lab=GND}
C {devices/gnd.sym} 300 1800 1 0 {name=l110 lab=GND}
C {devices/gnd.sym} 300 1820 1 0 {name=l111 lab=GND}
C {devices/gnd.sym} 300 1840 1 0 {name=l112 lab=GND}
C {devices/gnd.sym} 300 1860 1 0 {name=l113 lab=GND}
C {devices/gnd.sym} 300 1880 1 0 {name=l114 lab=GND}
C {devices/gnd.sym} 300 1900 1 0 {name=l115 lab=GND}
C {devices/gnd.sym} 300 1920 1 0 {name=l116 lab=GND}
C {devices/gnd.sym} 300 1940 1 0 {name=l117 lab=GND}
C {devices/gnd.sym} 300 1960 1 0 {name=l118 lab=GND}
C {devices/gnd.sym} 300 1980 1 0 {name=l119 lab=GND}
C {devices/gnd.sym} 300 2000 1 0 {name=l120 lab=GND}
C {devices/gnd.sym} 300 2020 1 0 {name=l121 lab=GND}
C {devices/gnd.sym} 300 2040 1 0 {name=l122 lab=GND}
C {devices/gnd.sym} 300 2060 1 0 {name=l123 lab=GND}
C {devices/gnd.sym} 300 2080 1 0 {name=l124 lab=GND}
C {devices/gnd.sym} 300 2100 1 0 {name=l125 lab=GND}
C {devices/gnd.sym} 300 2120 1 0 {name=l126 lab=GND}
C {devices/gnd.sym} 300 2140 1 0 {name=l127 lab=GND}
C {devices/gnd.sym} 300 2160 1 0 {name=l128 lab=GND}
C {devices/gnd.sym} 300 2180 1 0 {name=l129 lab=GND}
C {devices/gnd.sym} 300 2200 1 0 {name=l130 lab=GND}
C {devices/gnd.sym} 300 2220 1 0 {name=l131 lab=GND}
C {devices/gnd.sym} 300 2240 1 0 {name=l132 lab=GND}
C {devices/gnd.sym} 300 2260 1 0 {name=l133 lab=GND}
C {devices/gnd.sym} 300 2280 1 0 {name=l134 lab=GND}
C {devices/gnd.sym} 300 2300 1 0 {name=l135 lab=GND}
C {devices/gnd.sym} 300 2320 1 0 {name=l136 lab=GND}
C {devices/gnd.sym} 300 2340 1 0 {name=l137 lab=GND}
C {devices/gnd.sym} 300 2360 1 0 {name=l138 lab=GND}
C {devices/gnd.sym} 300 2380 1 0 {name=l139 lab=GND}
C {devices/gnd.sym} 300 2400 1 0 {name=l140 lab=GND}
C {devices/gnd.sym} 300 2420 1 0 {name=l141 lab=GND}
C {devices/gnd.sym} 300 2440 1 0 {name=l142 lab=GND}
C {devices/gnd.sym} 300 2460 1 0 {name=l143 lab=GND}
C {devices/gnd.sym} 300 2480 1 0 {name=l144 lab=GND}
C {devices/gnd.sym} 300 2500 1 0 {name=l145 lab=GND}
C {devices/gnd.sym} 300 2520 1 0 {name=l146 lab=GND}
C {devices/gnd.sym} 300 2540 1 0 {name=l147 lab=GND}
C {devices/gnd.sym} 300 2560 1 0 {name=l148 lab=GND}
C {devices/gnd.sym} 300 2580 1 0 {name=l149 lab=GND}
C {devices/gnd.sym} 300 2600 1 0 {name=l150 lab=GND}
C {devices/gnd.sym} 300 2620 1 0 {name=l151 lab=GND}
C {devices/gnd.sym} 300 2640 1 0 {name=l152 lab=GND}
C {devices/gnd.sym} 300 2660 1 0 {name=l153 lab=GND}
C {devices/gnd.sym} 300 2680 1 0 {name=l154 lab=GND}
C {devices/gnd.sym} 300 2700 1 0 {name=l155 lab=GND}
C {devices/gnd.sym} 300 2720 1 0 {name=l156 lab=GND}
C {devices/gnd.sym} 300 2740 1 0 {name=l157 lab=GND}
C {devices/gnd.sym} 300 2760 1 0 {name=l158 lab=GND}
C {devices/gnd.sym} 300 2780 1 0 {name=l159 lab=GND}
C {devices/gnd.sym} 300 2800 1 0 {name=l160 lab=GND}
C {devices/gnd.sym} 300 2820 1 0 {name=l161 lab=GND}
C {devices/gnd.sym} 300 2840 1 0 {name=l162 lab=GND}
C {devices/gnd.sym} 300 2860 1 0 {name=l163 lab=GND}
C {devices/gnd.sym} 300 2880 1 0 {name=l164 lab=GND}
C {devices/gnd.sym} 300 2900 1 0 {name=l165 lab=GND}
C {devices/gnd.sym} 300 2920 1 0 {name=l166 lab=GND}
C {devices/gnd.sym} 300 2940 1 0 {name=l167 lab=GND}
C {devices/gnd.sym} 300 2960 1 0 {name=l168 lab=GND}
C {devices/gnd.sym} 300 2980 1 0 {name=l169 lab=GND}
C {devices/gnd.sym} 300 3000 1 0 {name=l170 lab=GND}
C {devices/gnd.sym} 300 3020 1 0 {name=l171 lab=GND}
C {devices/gnd.sym} 300 3040 1 0 {name=l172 lab=GND}
C {devices/gnd.sym} 300 3060 1 0 {name=l173 lab=GND}
C {devices/gnd.sym} 300 3080 1 0 {name=l174 lab=GND}
C {devices/gnd.sym} 300 3100 1 0 {name=l175 lab=GND}
C {devices/gnd.sym} 300 3120 1 0 {name=l176 lab=GND}
C {devices/gnd.sym} 300 3140 1 0 {name=l177 lab=GND}
C {devices/gnd.sym} 300 3160 1 0 {name=l178 lab=GND}
C {devices/gnd.sym} 300 3180 1 0 {name=l179 lab=GND}
C {devices/gnd.sym} 300 3200 1 0 {name=l180 lab=GND}
C {devices/gnd.sym} 300 3220 1 0 {name=l181 lab=GND}
C {devices/gnd.sym} 300 3240 1 0 {name=l182 lab=GND}
C {devices/gnd.sym} 300 3260 1 0 {name=l183 lab=GND}
C {devices/gnd.sym} 300 3280 1 0 {name=l184 lab=GND}
C {devices/gnd.sym} 300 3300 1 0 {name=l185 lab=GND}
C {devices/gnd.sym} 300 3320 1 0 {name=l186 lab=GND}
C {devices/gnd.sym} 300 3340 1 0 {name=l187 lab=GND}
C {devices/gnd.sym} 300 3360 1 0 {name=l188 lab=GND}
C {devices/gnd.sym} 300 3380 1 0 {name=l189 lab=GND}
C {devices/gnd.sym} 300 3400 1 0 {name=l190 lab=GND}
C {devices/gnd.sym} 300 3420 1 0 {name=l191 lab=GND}
C {devices/gnd.sym} 300 3440 1 0 {name=l192 lab=GND}
C {devices/gnd.sym} 300 3460 1 0 {name=l193 lab=GND}
C {devices/gnd.sym} 300 3480 1 0 {name=l194 lab=GND}
C {devices/gnd.sym} 300 3500 1 0 {name=l195 lab=GND}
C {devices/gnd.sym} 300 3520 1 0 {name=l196 lab=GND}
C {devices/gnd.sym} 300 3540 1 0 {name=l197 lab=GND}
C {devices/gnd.sym} 300 3560 1 0 {name=l198 lab=GND}
C {devices/gnd.sym} 300 3580 1 0 {name=l199 lab=GND}
C {devices/gnd.sym} 300 3600 1 0 {name=l200 lab=GND}
C {devices/gnd.sym} 300 3620 1 0 {name=l201 lab=GND}
C {devices/gnd.sym} 300 3640 1 0 {name=l202 lab=GND}
C {devices/gnd.sym} 300 3660 1 0 {name=l203 lab=GND}
C {devices/gnd.sym} 300 3680 1 0 {name=l204 lab=GND}
C {devices/gnd.sym} 300 3700 1 0 {name=l205 lab=GND}
C {devices/gnd.sym} 300 3720 1 0 {name=l206 lab=GND}
C {devices/gnd.sym} 300 3740 1 0 {name=l207 lab=GND}
C {devices/gnd.sym} 300 3760 1 0 {name=l208 lab=GND}
C {devices/gnd.sym} 300 3780 1 0 {name=l209 lab=GND}
C {devices/gnd.sym} 300 3800 1 0 {name=l210 lab=GND}
C {devices/gnd.sym} 300 3820 1 0 {name=l211 lab=GND}
C {devices/gnd.sym} 300 3840 1 0 {name=l212 lab=GND}
C {devices/gnd.sym} 300 3860 1 0 {name=l213 lab=GND}
C {devices/gnd.sym} 300 3880 1 0 {name=l214 lab=GND}
C {devices/gnd.sym} 300 3900 1 0 {name=l215 lab=GND}
C {devices/gnd.sym} 300 3920 1 0 {name=l216 lab=GND}
C {devices/gnd.sym} 300 3940 1 0 {name=l217 lab=GND}
C {devices/gnd.sym} 300 3960 1 0 {name=l218 lab=GND}
C {devices/gnd.sym} 300 3980 1 0 {name=l219 lab=GND}
C {devices/gnd.sym} 300 4000 1 0 {name=l220 lab=GND}
C {devices/gnd.sym} 300 4020 1 0 {name=l221 lab=GND}
C {devices/gnd.sym} 300 4040 1 0 {name=l222 lab=GND}
C {devices/gnd.sym} 300 4060 1 0 {name=l223 lab=GND}
C {devices/gnd.sym} 300 4080 1 0 {name=l224 lab=GND}
C {devices/gnd.sym} 300 4100 1 0 {name=l225 lab=GND}
C {devices/gnd.sym} 300 4120 1 0 {name=l226 lab=GND}
C {devices/gnd.sym} 300 4140 1 0 {name=l227 lab=GND}
C {devices/gnd.sym} 300 4160 1 0 {name=l228 lab=GND}
C {devices/gnd.sym} 300 4180 1 0 {name=l229 lab=GND}
C {devices/gnd.sym} 300 4200 1 0 {name=l230 lab=GND}
C {devices/gnd.sym} 300 4220 1 0 {name=l231 lab=GND}
C {devices/gnd.sym} 300 4240 1 0 {name=l232 lab=GND}
C {devices/gnd.sym} 300 4260 1 0 {name=l233 lab=GND}
C {devices/gnd.sym} 300 4280 1 0 {name=l234 lab=GND}
C {devices/gnd.sym} 300 4300 1 0 {name=l235 lab=GND}
C {devices/gnd.sym} 300 4320 1 0 {name=l236 lab=GND}
C {devices/gnd.sym} 300 4340 1 0 {name=l237 lab=GND}
C {devices/gnd.sym} 300 4360 1 0 {name=l238 lab=GND}
C {devices/gnd.sym} 300 4380 1 0 {name=l239 lab=GND}
C {devices/gnd.sym} 300 4400 1 0 {name=l240 lab=GND}
C {devices/gnd.sym} 300 4420 1 0 {name=l241 lab=GND}
C {devices/gnd.sym} 300 4440 1 0 {name=l242 lab=GND}
C {devices/gnd.sym} 300 4460 1 0 {name=l243 lab=GND}
C {devices/gnd.sym} 300 4480 1 0 {name=l244 lab=GND}
C {devices/gnd.sym} 300 4500 1 0 {name=l245 lab=GND}
C {devices/gnd.sym} 300 4520 1 0 {name=l246 lab=GND}
C {devices/gnd.sym} 300 4540 1 0 {name=l247 lab=GND}
C {devices/gnd.sym} 300 4560 1 0 {name=l248 lab=GND}
C {devices/gnd.sym} 300 4580 1 0 {name=l249 lab=GND}
C {devices/gnd.sym} 300 4600 1 0 {name=l250 lab=GND}
C {devices/gnd.sym} 300 4620 1 0 {name=l251 lab=GND}
C {devices/gnd.sym} 300 4640 1 0 {name=l252 lab=GND}
C {devices/gnd.sym} 300 4660 1 0 {name=l253 lab=GND}
C {devices/gnd.sym} 300 4680 1 0 {name=l254 lab=GND}
C {devices/gnd.sym} 300 4700 1 0 {name=l255 lab=GND}
C {devices/gnd.sym} 300 4720 1 0 {name=l256 lab=GND}
C {devices/gnd.sym} 300 4740 1 0 {name=l257 lab=GND}
C {devices/gnd.sym} 300 4760 1 0 {name=l258 lab=GND}
C {devices/gnd.sym} 300 4780 1 0 {name=l259 lab=GND}
C {devices/gnd.sym} 300 4800 1 0 {name=l260 lab=GND}
C {devices/gnd.sym} 300 4820 1 0 {name=l261 lab=GND}
C {devices/gnd.sym} 300 4840 1 0 {name=l262 lab=GND}
C {devices/gnd.sym} 300 4860 1 0 {name=l263 lab=GND}
C {devices/gnd.sym} 300 4880 1 0 {name=l264 lab=GND}
C {devices/gnd.sym} 300 4900 1 0 {name=l265 lab=GND}
C {devices/gnd.sym} 300 4920 1 0 {name=l266 lab=GND}
C {devices/gnd.sym} 300 -160 1 0 {name=l5 lab=GND}
C {devices/vdd.sym} 250 1600 0 0 {name=l267 lab=VDD}
C {devices/gnd.sym} 300 1080 1 0 {name=l74 lab=GND}
