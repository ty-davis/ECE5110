N 520 51710 520 51720 {
lab=GND}
N 480 51670 520 51670 {
lab=word861}
N 520 51670 560 51670 {
lab=word861}
N 490 51660 490 51710 {
lab=GND}
N 490 51710 490 51720 {
lab=GND}
N 550 51660 550 51710 {
lab=Y6}
N 550 51710 550 51720 {
lab=Y6}
N 570 51720 600 51720 {
lab=GND}
N 600 51710 600 51720 {
lab=GND}
N 560 51670 600 51670 {
lab=word861}
N 600 51670 640 51670 {
lab=word861}
N 570 51660 570 51710 {
lab=GND}
N 570 51710 570 51720 {
lab=GND}
N 630 51660 630 51710 {
lab=Y7}
N 630 51710 630 51720 {
lab=Y7}
N 10 51780 40 51780 {
lab=GND}
N 40 51770 40 51780 {
lab=GND}
N 0 51730 40 51730 {
lab=word862}
N 40 51730 80 51730 {
lab=word862}
N 10 51720 10 51770 {
lab=GND}
N 10 51770 10 51780 {
lab=GND}
N 70 51720 70 51770 {
lab=Y0}
N 70 51770 70 51780 {
lab=Y0}
N 90 51780 120 51780 {
lab=GND}
N 120 51770 120 51780 {
lab=GND}
N 80 51730 120 51730 {
lab=word862}
N 120 51730 160 51730 {
lab=word862}
N 90 51720 90 51770 {
lab=GND}
N 90 51770 90 51780 {
lab=GND}
N 150 51720 150 51770 {
lab=Y1}
N 150 51770 150 51780 {
lab=Y1}
N 160 51730 200 51730 {
lab=word862}
N 200 51730 240 51730 {
lab=word862}
N 170 51720 170 51770 {
lab=GND}
N 170 51770 170 51780 {
lab=GND}
N 230 51720 230 51770 {
lab=Y2}
N 230 51770 230 51780 {
lab=Y2}
N 250 51780 280 51780 {
lab=GND}
N 280 51770 280 51780 {
lab=GND}
N 240 51730 280 51730 {
lab=word862}
N 280 51730 320 51730 {
lab=word862}
N 250 51720 250 51770 {
lab=GND}
N 250 51770 250 51780 {
lab=GND}
N 310 51720 310 51770 {
lab=Y3}
N 310 51770 310 51780 {
lab=Y3}
N 320 51730 360 51730 {
lab=word862}
N 360 51730 400 51730 {
lab=word862}
N 330 51720 330 51770 {
lab=GND}
N 330 51770 330 51780 {
lab=GND}
N 390 51720 390 51770 {
lab=Y4}
N 390 51770 390 51780 {
lab=Y4}
N 410 51780 440 51780 {
lab=GND}
N 440 51770 440 51780 {
lab=GND}
N 400 51730 440 51730 {
lab=word862}
N 440 51730 480 51730 {
lab=word862}
N 410 51720 410 51770 {
lab=GND}
N 410 51770 410 51780 {
lab=GND}
N 470 51720 470 51770 {
lab=Y5}
N 470 51770 470 51780 {
lab=Y5}
N 480 51730 520 51730 {
lab=word862}
N 520 51730 560 51730 {
lab=word862}
N 490 51720 490 51770 {
lab=GND}
N 490 51770 490 51780 {
lab=GND}
N 550 51720 550 51770 {
lab=Y6}
N 550 51770 550 51780 {
lab=Y6}
N 570 51780 600 51780 {
lab=GND}
N 600 51770 600 51780 {
lab=GND}
N 560 51730 600 51730 {
lab=word862}
N 600 51730 640 51730 {
lab=word862}
N 570 51720 570 51770 {
lab=GND}
N 570 51770 570 51780 {
lab=GND}
N 630 51720 630 51770 {
lab=Y7}
N 630 51770 630 51780 {
lab=Y7}
N 10 51840 40 51840 {
lab=GND}
N 40 51830 40 51840 {
lab=GND}
N 0 51790 40 51790 {
lab=word863}
N 40 51790 80 51790 {
lab=word863}
N 10 51780 10 51830 {
lab=GND}
N 10 51830 10 51840 {
lab=GND}
N 70 51780 70 51830 {
lab=Y0}
N 70 51830 70 51840 {
lab=Y0}
N 90 51840 120 51840 {
lab=GND}
N 120 51830 120 51840 {
lab=GND}
N 80 51790 120 51790 {
lab=word863}
N 120 51790 160 51790 {
lab=word863}
N 90 51780 90 51830 {
lab=GND}
N 90 51830 90 51840 {
lab=GND}
N 150 51780 150 51830 {
lab=Y1}
N 150 51830 150 51840 {
lab=Y1}
N 160 51790 200 51790 {
lab=word863}
N 200 51790 240 51790 {
lab=word863}
N 170 51780 170 51830 {
lab=GND}
N 170 51830 170 51840 {
lab=GND}
N 230 51780 230 51830 {
lab=Y2}
N 230 51830 230 51840 {
lab=Y2}
N 250 51840 280 51840 {
lab=GND}
N 280 51830 280 51840 {
lab=GND}
N 240 51790 280 51790 {
lab=word863}
N 280 51790 320 51790 {
lab=word863}
N 250 51780 250 51830 {
lab=GND}
N 250 51830 250 51840 {
lab=GND}
N 310 51780 310 51830 {
lab=Y3}
N 310 51830 310 51840 {
lab=Y3}
N 320 51790 360 51790 {
lab=word863}
N 360 51790 400 51790 {
lab=word863}
N 330 51780 330 51830 {
lab=GND}
N 330 51830 330 51840 {
lab=GND}
N 390 51780 390 51830 {
lab=Y4}
N 390 51830 390 51840 {
lab=Y4}
N 410 51840 440 51840 {
lab=GND}
N 440 51830 440 51840 {
lab=GND}
N 400 51790 440 51790 {
lab=word863}
N 440 51790 480 51790 {
lab=word863}
N 410 51780 410 51830 {
lab=GND}
N 410 51830 410 51840 {
lab=GND}
N 470 51780 470 51830 {
lab=Y5}
N 470 51830 470 51840 {
lab=Y5}
N 490 51840 520 51840 {
lab=GND}
N 520 51830 520 51840 {
lab=GND}
N 480 51790 520 51790 {
lab=word863}
N 520 51790 560 51790 {
lab=word863}
N 490 51780 490 51830 {
lab=GND}
N 490 51830 490 51840 {
lab=GND}
N 550 51780 550 51830 {
lab=Y6}
N 550 51830 550 51840 {
lab=Y6}
N 570 51840 600 51840 {
lab=GND}
N 600 51830 600 51840 {
lab=GND}
N 560 51790 600 51790 {
lab=word863}
N 600 51790 640 51790 {
lab=word863}
N 570 51780 570 51830 {
lab=GND}
N 570 51830 570 51840 {
lab=GND}
N 630 51780 630 51830 {
lab=Y7}
N 630 51830 630 51840 {
lab=Y7}
N 10 51900 40 51900 {
lab=GND}
N 40 51890 40 51900 {
lab=GND}
N 0 51850 40 51850 {
lab=word864}
N 40 51850 80 51850 {
lab=word864}
N 10 51840 10 51890 {
lab=GND}
N 10 51890 10 51900 {
lab=GND}
N 70 51840 70 51890 {
lab=Y0}
N 70 51890 70 51900 {
lab=Y0}
N 90 51900 120 51900 {
lab=GND}
N 120 51890 120 51900 {
lab=GND}
N 80 51850 120 51850 {
lab=word864}
N 120 51850 160 51850 {
lab=word864}
N 90 51840 90 51890 {
lab=GND}
N 90 51890 90 51900 {
lab=GND}
N 150 51840 150 51890 {
lab=Y1}
N 150 51890 150 51900 {
lab=Y1}
N 160 51850 200 51850 {
lab=word864}
N 200 51850 240 51850 {
lab=word864}
N 170 51840 170 51890 {
lab=GND}
N 170 51890 170 51900 {
lab=GND}
N 230 51840 230 51890 {
lab=Y2}
N 230 51890 230 51900 {
lab=Y2}
N 250 51900 280 51900 {
lab=GND}
N 280 51890 280 51900 {
lab=GND}
N 240 51850 280 51850 {
lab=word864}
N 280 51850 320 51850 {
lab=word864}
N 250 51840 250 51890 {
lab=GND}
N 250 51890 250 51900 {
lab=GND}
N 310 51840 310 51890 {
lab=Y3}
N 310 51890 310 51900 {
lab=Y3}
N 330 51900 360 51900 {
lab=GND}
N 360 51890 360 51900 {
lab=GND}
N 320 51850 360 51850 {
lab=word864}
N 360 51850 400 51850 {
lab=word864}
N 330 51840 330 51890 {
lab=GND}
N 330 51890 330 51900 {
lab=GND}
N 390 51840 390 51890 {
lab=Y4}
N 390 51890 390 51900 {
lab=Y4}
N 400 51850 440 51850 {
lab=word864}
N 440 51850 480 51850 {
lab=word864}
N 410 51840 410 51890 {
lab=GND}
N 410 51890 410 51900 {
lab=GND}
N 470 51840 470 51890 {
lab=Y5}
N 470 51890 470 51900 {
lab=Y5}
N 490 51900 520 51900 {
lab=GND}
N 520 51890 520 51900 {
lab=GND}
N 480 51850 520 51850 {
lab=word864}
N 520 51850 560 51850 {
lab=word864}
N 490 51840 490 51890 {
lab=GND}
N 490 51890 490 51900 {
lab=GND}
N 550 51840 550 51890 {
lab=Y6}
N 550 51890 550 51900 {
lab=Y6}
N 560 51850 600 51850 {
lab=word864}
N 600 51850 640 51850 {
lab=word864}
N 570 51840 570 51890 {
lab=GND}
N 570 51890 570 51900 {
lab=GND}
N 630 51840 630 51890 {
lab=Y7}
N 630 51890 630 51900 {
lab=Y7}
N 10 51960 40 51960 {
lab=GND}
N 40 51950 40 51960 {
lab=GND}
N 0 51910 40 51910 {
lab=word865}
N 40 51910 80 51910 {
lab=word865}
N 10 51900 10 51950 {
lab=GND}
N 10 51950 10 51960 {
lab=GND}
N 70 51900 70 51950 {
lab=Y0}
N 70 51950 70 51960 {
lab=Y0}
N 90 51960 120 51960 {
lab=GND}
N 120 51950 120 51960 {
lab=GND}
N 80 51910 120 51910 {
lab=word865}
N 120 51910 160 51910 {
lab=word865}
N 90 51900 90 51950 {
lab=GND}
N 90 51950 90 51960 {
lab=GND}
N 150 51900 150 51950 {
lab=Y1}
N 150 51950 150 51960 {
lab=Y1}
N 160 51910 200 51910 {
lab=word865}
N 200 51910 240 51910 {
lab=word865}
N 170 51900 170 51950 {
lab=GND}
N 170 51950 170 51960 {
lab=GND}
N 230 51900 230 51950 {
lab=Y2}
N 230 51950 230 51960 {
lab=Y2}
N 250 51960 280 51960 {
lab=GND}
N 280 51950 280 51960 {
lab=GND}
N 240 51910 280 51910 {
lab=word865}
N 280 51910 320 51910 {
lab=word865}
N 250 51900 250 51950 {
lab=GND}
N 250 51950 250 51960 {
lab=GND}
N 310 51900 310 51950 {
lab=Y3}
N 310 51950 310 51960 {
lab=Y3}
N 330 51960 360 51960 {
lab=GND}
N 360 51950 360 51960 {
lab=GND}
N 320 51910 360 51910 {
lab=word865}
N 360 51910 400 51910 {
lab=word865}
N 330 51900 330 51950 {
lab=GND}
N 330 51950 330 51960 {
lab=GND}
N 390 51900 390 51950 {
lab=Y4}
N 390 51950 390 51960 {
lab=Y4}
N 410 51960 440 51960 {
lab=GND}
N 440 51950 440 51960 {
lab=GND}
N 400 51910 440 51910 {
lab=word865}
N 440 51910 480 51910 {
lab=word865}
N 410 51900 410 51950 {
lab=GND}
N 410 51950 410 51960 {
lab=GND}
N 470 51900 470 51950 {
lab=Y5}
N 470 51950 470 51960 {
lab=Y5}
N 480 51910 520 51910 {
lab=word865}
N 520 51910 560 51910 {
lab=word865}
N 490 51900 490 51950 {
lab=GND}
N 490 51950 490 51960 {
lab=GND}
N 550 51900 550 51950 {
lab=Y6}
N 550 51950 550 51960 {
lab=Y6}
N 560 51910 600 51910 {
lab=word865}
N 600 51910 640 51910 {
lab=word865}
N 570 51900 570 51950 {
lab=GND}
N 570 51950 570 51960 {
lab=GND}
N 630 51900 630 51950 {
lab=Y7}
N 630 51950 630 51960 {
lab=Y7}
N 10 52020 40 52020 {
lab=GND}
N 40 52010 40 52020 {
lab=GND}
N 0 51970 40 51970 {
lab=word866}
N 40 51970 80 51970 {
lab=word866}
N 10 51960 10 52010 {
lab=GND}
N 10 52010 10 52020 {
lab=GND}
N 70 51960 70 52010 {
lab=Y0}
N 70 52010 70 52020 {
lab=Y0}
N 90 52020 120 52020 {
lab=GND}
N 120 52010 120 52020 {
lab=GND}
N 80 51970 120 51970 {
lab=word866}
N 120 51970 160 51970 {
lab=word866}
N 90 51960 90 52010 {
lab=GND}
N 90 52010 90 52020 {
lab=GND}
N 150 51960 150 52010 {
lab=Y1}
N 150 52010 150 52020 {
lab=Y1}
N 160 51970 200 51970 {
lab=word866}
N 200 51970 240 51970 {
lab=word866}
N 170 51960 170 52010 {
lab=GND}
N 170 52010 170 52020 {
lab=GND}
N 230 51960 230 52010 {
lab=Y2}
N 230 52010 230 52020 {
lab=Y2}
N 250 52020 280 52020 {
lab=GND}
N 280 52010 280 52020 {
lab=GND}
N 240 51970 280 51970 {
lab=word866}
N 280 51970 320 51970 {
lab=word866}
N 250 51960 250 52010 {
lab=GND}
N 250 52010 250 52020 {
lab=GND}
N 310 51960 310 52010 {
lab=Y3}
N 310 52010 310 52020 {
lab=Y3}
N 330 52020 360 52020 {
lab=GND}
N 360 52010 360 52020 {
lab=GND}
N 320 51970 360 51970 {
lab=word866}
N 360 51970 400 51970 {
lab=word866}
N 330 51960 330 52010 {
lab=GND}
N 330 52010 330 52020 {
lab=GND}
N 390 51960 390 52010 {
lab=Y4}
N 390 52010 390 52020 {
lab=Y4}
N 410 52020 440 52020 {
lab=GND}
N 440 52010 440 52020 {
lab=GND}
N 400 51970 440 51970 {
lab=word866}
N 440 51970 480 51970 {
lab=word866}
N 410 51960 410 52010 {
lab=GND}
N 410 52010 410 52020 {
lab=GND}
N 470 51960 470 52010 {
lab=Y5}
N 470 52010 470 52020 {
lab=Y5}
N 490 52020 520 52020 {
lab=GND}
N 520 52010 520 52020 {
lab=GND}
N 480 51970 520 51970 {
lab=word866}
N 520 51970 560 51970 {
lab=word866}
N 490 51960 490 52010 {
lab=GND}
N 490 52010 490 52020 {
lab=GND}
N 550 51960 550 52010 {
lab=Y6}
N 550 52010 550 52020 {
lab=Y6}
N 560 51970 600 51970 {
lab=word866}
N 600 51970 640 51970 {
lab=word866}
N 570 51960 570 52010 {
lab=GND}
N 570 52010 570 52020 {
lab=GND}
N 630 51960 630 52010 {
lab=Y7}
N 630 52010 630 52020 {
lab=Y7}
N 10 52080 40 52080 {
lab=GND}
N 40 52070 40 52080 {
lab=GND}
N 0 52030 40 52030 {
lab=word867}
N 40 52030 80 52030 {
lab=word867}
N 10 52020 10 52070 {
lab=GND}
N 10 52070 10 52080 {
lab=GND}
N 70 52020 70 52070 {
lab=Y0}
N 70 52070 70 52080 {
lab=Y0}
N 90 52080 120 52080 {
lab=GND}
N 120 52070 120 52080 {
lab=GND}
N 80 52030 120 52030 {
lab=word867}
N 120 52030 160 52030 {
lab=word867}
N 90 52020 90 52070 {
lab=GND}
N 90 52070 90 52080 {
lab=GND}
N 150 52020 150 52070 {
lab=Y1}
N 150 52070 150 52080 {
lab=Y1}
N 170 52080 200 52080 {
lab=GND}
N 200 52070 200 52080 {
lab=GND}
N 160 52030 200 52030 {
lab=word867}
N 200 52030 240 52030 {
lab=word867}
N 170 52020 170 52070 {
lab=GND}
N 170 52070 170 52080 {
lab=GND}
N 230 52020 230 52070 {
lab=Y2}
N 230 52070 230 52080 {
lab=Y2}
N 240 52030 280 52030 {
lab=word867}
N 280 52030 320 52030 {
lab=word867}
N 250 52020 250 52070 {
lab=GND}
N 250 52070 250 52080 {
lab=GND}
N 310 52020 310 52070 {
lab=Y3}
N 310 52070 310 52080 {
lab=Y3}
N 320 52030 360 52030 {
lab=word867}
N 360 52030 400 52030 {
lab=word867}
N 330 52020 330 52070 {
lab=GND}
N 330 52070 330 52080 {
lab=GND}
N 390 52020 390 52070 {
lab=Y4}
N 390 52070 390 52080 {
lab=Y4}
N 400 52030 440 52030 {
lab=word867}
N 440 52030 480 52030 {
lab=word867}
N 410 52020 410 52070 {
lab=GND}
N 410 52070 410 52080 {
lab=GND}
N 470 52020 470 52070 {
lab=Y5}
N 470 52070 470 52080 {
lab=Y5}
N 480 52030 520 52030 {
lab=word867}
N 520 52030 560 52030 {
lab=word867}
N 490 52020 490 52070 {
lab=GND}
N 490 52070 490 52080 {
lab=GND}
N 550 52020 550 52070 {
lab=Y6}
N 550 52070 550 52080 {
lab=Y6}
N 560 52030 600 52030 {
lab=word867}
N 600 52030 640 52030 {
lab=word867}
N 570 52020 570 52070 {
lab=GND}
N 570 52070 570 52080 {
lab=GND}
N 630 52020 630 52070 {
lab=Y7}
N 630 52070 630 52080 {
lab=Y7}
N 10 52140 40 52140 {
lab=GND}
N 40 52130 40 52140 {
lab=GND}
N 0 52090 40 52090 {
lab=word868}
N 40 52090 80 52090 {
lab=word868}
N 10 52080 10 52130 {
lab=GND}
N 10 52130 10 52140 {
lab=GND}
N 70 52080 70 52130 {
lab=Y0}
N 70 52130 70 52140 {
lab=Y0}
N 90 52140 120 52140 {
lab=GND}
N 120 52130 120 52140 {
lab=GND}
N 80 52090 120 52090 {
lab=word868}
N 120 52090 160 52090 {
lab=word868}
N 90 52080 90 52130 {
lab=GND}
N 90 52130 90 52140 {
lab=GND}
N 150 52080 150 52130 {
lab=Y1}
N 150 52130 150 52140 {
lab=Y1}
N 170 52140 200 52140 {
lab=GND}
N 200 52130 200 52140 {
lab=GND}
N 160 52090 200 52090 {
lab=word868}
N 200 52090 240 52090 {
lab=word868}
N 170 52080 170 52130 {
lab=GND}
N 170 52130 170 52140 {
lab=GND}
N 230 52080 230 52130 {
lab=Y2}
N 230 52130 230 52140 {
lab=Y2}
N 240 52090 280 52090 {
lab=word868}
N 280 52090 320 52090 {
lab=word868}
N 250 52080 250 52130 {
lab=GND}
N 250 52130 250 52140 {
lab=GND}
N 310 52080 310 52130 {
lab=Y3}
N 310 52130 310 52140 {
lab=Y3}
N 320 52090 360 52090 {
lab=word868}
N 360 52090 400 52090 {
lab=word868}
N 330 52080 330 52130 {
lab=GND}
N 330 52130 330 52140 {
lab=GND}
N 390 52080 390 52130 {
lab=Y4}
N 390 52130 390 52140 {
lab=Y4}
N 400 52090 440 52090 {
lab=word868}
N 440 52090 480 52090 {
lab=word868}
N 410 52080 410 52130 {
lab=GND}
N 410 52130 410 52140 {
lab=GND}
N 470 52080 470 52130 {
lab=Y5}
N 470 52130 470 52140 {
lab=Y5}
N 490 52140 520 52140 {
lab=GND}
N 520 52130 520 52140 {
lab=GND}
N 480 52090 520 52090 {
lab=word868}
N 520 52090 560 52090 {
lab=word868}
N 490 52080 490 52130 {
lab=GND}
N 490 52130 490 52140 {
lab=GND}
N 550 52080 550 52130 {
lab=Y6}
N 550 52130 550 52140 {
lab=Y6}
N 560 52090 600 52090 {
lab=word868}
N 600 52090 640 52090 {
lab=word868}
N 570 52080 570 52130 {
lab=GND}
N 570 52130 570 52140 {
lab=GND}
N 630 52080 630 52130 {
lab=Y7}
N 630 52130 630 52140 {
lab=Y7}
N 10 52200 40 52200 {
lab=GND}
N 40 52190 40 52200 {
lab=GND}
N 0 52150 40 52150 {
lab=word869}
N 40 52150 80 52150 {
lab=word869}
N 10 52140 10 52190 {
lab=GND}
N 10 52190 10 52200 {
lab=GND}
N 70 52140 70 52190 {
lab=Y0}
N 70 52190 70 52200 {
lab=Y0}
N 90 52200 120 52200 {
lab=GND}
N 120 52190 120 52200 {
lab=GND}
N 80 52150 120 52150 {
lab=word869}
N 120 52150 160 52150 {
lab=word869}
N 90 52140 90 52190 {
lab=GND}
N 90 52190 90 52200 {
lab=GND}
N 150 52140 150 52190 {
lab=Y1}
N 150 52190 150 52200 {
lab=Y1}
N 170 52200 200 52200 {
lab=GND}
N 200 52190 200 52200 {
lab=GND}
N 160 52150 200 52150 {
lab=word869}
N 200 52150 240 52150 {
lab=word869}
N 170 52140 170 52190 {
lab=GND}
N 170 52190 170 52200 {
lab=GND}
N 230 52140 230 52190 {
lab=Y2}
N 230 52190 230 52200 {
lab=Y2}
N 240 52150 280 52150 {
lab=word869}
N 280 52150 320 52150 {
lab=word869}
N 250 52140 250 52190 {
lab=GND}
N 250 52190 250 52200 {
lab=GND}
N 310 52140 310 52190 {
lab=Y3}
N 310 52190 310 52200 {
lab=Y3}
N 320 52150 360 52150 {
lab=word869}
N 360 52150 400 52150 {
lab=word869}
N 330 52140 330 52190 {
lab=GND}
N 330 52190 330 52200 {
lab=GND}
N 390 52140 390 52190 {
lab=Y4}
N 390 52190 390 52200 {
lab=Y4}
N 410 52200 440 52200 {
lab=GND}
N 440 52190 440 52200 {
lab=GND}
N 400 52150 440 52150 {
lab=word869}
N 440 52150 480 52150 {
lab=word869}
N 410 52140 410 52190 {
lab=GND}
N 410 52190 410 52200 {
lab=GND}
N 470 52140 470 52190 {
lab=Y5}
N 470 52190 470 52200 {
lab=Y5}
N 480 52150 520 52150 {
lab=word869}
N 520 52150 560 52150 {
lab=word869}
N 490 52140 490 52190 {
lab=GND}
N 490 52190 490 52200 {
lab=GND}
N 550 52140 550 52190 {
lab=Y6}
N 550 52190 550 52200 {
lab=Y6}
N 560 52150 600 52150 {
lab=word869}
N 600 52150 640 52150 {
lab=word869}
N 570 52140 570 52190 {
lab=GND}
N 570 52190 570 52200 {
lab=GND}
N 630 52140 630 52190 {
lab=Y7}
N 630 52190 630 52200 {
lab=Y7}
N 10 52260 40 52260 {
lab=GND}
N 40 52250 40 52260 {
lab=GND}
N 0 52210 40 52210 {
lab=word870}
N 40 52210 80 52210 {
lab=word870}
N 10 52200 10 52250 {
lab=GND}
N 10 52250 10 52260 {
lab=GND}
N 70 52200 70 52250 {
lab=Y0}
N 70 52250 70 52260 {
lab=Y0}
N 90 52260 120 52260 {
lab=GND}
N 120 52250 120 52260 {
lab=GND}
N 80 52210 120 52210 {
lab=word870}
N 120 52210 160 52210 {
lab=word870}
N 90 52200 90 52250 {
lab=GND}
N 90 52250 90 52260 {
lab=GND}
N 150 52200 150 52250 {
lab=Y1}
N 150 52250 150 52260 {
lab=Y1}
N 170 52260 200 52260 {
lab=GND}
N 200 52250 200 52260 {
lab=GND}
N 160 52210 200 52210 {
lab=word870}
N 200 52210 240 52210 {
lab=word870}
N 170 52200 170 52250 {
lab=GND}
N 170 52250 170 52260 {
lab=GND}
N 230 52200 230 52250 {
lab=Y2}
N 230 52250 230 52260 {
lab=Y2}
N 240 52210 280 52210 {
lab=word870}
N 280 52210 320 52210 {
lab=word870}
N 250 52200 250 52250 {
lab=GND}
N 250 52250 250 52260 {
lab=GND}
N 310 52200 310 52250 {
lab=Y3}
N 310 52250 310 52260 {
lab=Y3}
N 320 52210 360 52210 {
lab=word870}
N 360 52210 400 52210 {
lab=word870}
N 330 52200 330 52250 {
lab=GND}
N 330 52250 330 52260 {
lab=GND}
N 390 52200 390 52250 {
lab=Y4}
N 390 52250 390 52260 {
lab=Y4}
N 410 52260 440 52260 {
lab=GND}
N 440 52250 440 52260 {
lab=GND}
N 400 52210 440 52210 {
lab=word870}
N 440 52210 480 52210 {
lab=word870}
N 410 52200 410 52250 {
lab=GND}
N 410 52250 410 52260 {
lab=GND}
N 470 52200 470 52250 {
lab=Y5}
N 470 52250 470 52260 {
lab=Y5}
N 490 52260 520 52260 {
lab=GND}
N 520 52250 520 52260 {
lab=GND}
N 480 52210 520 52210 {
lab=word870}
N 520 52210 560 52210 {
lab=word870}
N 490 52200 490 52250 {
lab=GND}
N 490 52250 490 52260 {
lab=GND}
N 550 52200 550 52250 {
lab=Y6}
N 550 52250 550 52260 {
lab=Y6}
N 560 52210 600 52210 {
lab=word870}
N 600 52210 640 52210 {
lab=word870}
N 570 52200 570 52250 {
lab=GND}
N 570 52250 570 52260 {
lab=GND}
N 630 52200 630 52250 {
lab=Y7}
N 630 52250 630 52260 {
lab=Y7}
N 10 52320 40 52320 {
lab=GND}
N 40 52310 40 52320 {
lab=GND}
N 0 52270 40 52270 {
lab=word871}
N 40 52270 80 52270 {
lab=word871}
N 10 52260 10 52310 {
lab=GND}
N 10 52310 10 52320 {
lab=GND}
N 70 52260 70 52310 {
lab=Y0}
N 70 52310 70 52320 {
lab=Y0}
N 90 52320 120 52320 {
lab=GND}
N 120 52310 120 52320 {
lab=GND}
N 80 52270 120 52270 {
lab=word871}
N 120 52270 160 52270 {
lab=word871}
N 90 52260 90 52310 {
lab=GND}
N 90 52310 90 52320 {
lab=GND}
N 150 52260 150 52310 {
lab=Y1}
N 150 52310 150 52320 {
lab=Y1}
N 170 52320 200 52320 {
lab=GND}
N 200 52310 200 52320 {
lab=GND}
N 160 52270 200 52270 {
lab=word871}
N 200 52270 240 52270 {
lab=word871}
N 170 52260 170 52310 {
lab=GND}
N 170 52310 170 52320 {
lab=GND}
N 230 52260 230 52310 {
lab=Y2}
N 230 52310 230 52320 {
lab=Y2}
N 240 52270 280 52270 {
lab=word871}
N 280 52270 320 52270 {
lab=word871}
N 250 52260 250 52310 {
lab=GND}
N 250 52310 250 52320 {
lab=GND}
N 310 52260 310 52310 {
lab=Y3}
N 310 52310 310 52320 {
lab=Y3}
N 330 52320 360 52320 {
lab=GND}
N 360 52310 360 52320 {
lab=GND}
N 320 52270 360 52270 {
lab=word871}
N 360 52270 400 52270 {
lab=word871}
N 330 52260 330 52310 {
lab=GND}
N 330 52310 330 52320 {
lab=GND}
N 390 52260 390 52310 {
lab=Y4}
N 390 52310 390 52320 {
lab=Y4}
N 400 52270 440 52270 {
lab=word871}
N 440 52270 480 52270 {
lab=word871}
N 410 52260 410 52310 {
lab=GND}
N 410 52310 410 52320 {
lab=GND}
N 470 52260 470 52310 {
lab=Y5}
N 470 52310 470 52320 {
lab=Y5}
N 480 52270 520 52270 {
lab=word871}
N 520 52270 560 52270 {
lab=word871}
N 490 52260 490 52310 {
lab=GND}
N 490 52310 490 52320 {
lab=GND}
N 550 52260 550 52310 {
lab=Y6}
N 550 52310 550 52320 {
lab=Y6}
N 560 52270 600 52270 {
lab=word871}
N 600 52270 640 52270 {
lab=word871}
N 570 52260 570 52310 {
lab=GND}
N 570 52310 570 52320 {
lab=GND}
N 630 52260 630 52310 {
lab=Y7}
N 630 52310 630 52320 {
lab=Y7}
N 10 52380 40 52380 {
lab=GND}
N 40 52370 40 52380 {
lab=GND}
N 0 52330 40 52330 {
lab=word872}
N 40 52330 80 52330 {
lab=word872}
N 10 52320 10 52370 {
lab=GND}
N 10 52370 10 52380 {
lab=GND}
N 70 52320 70 52370 {
lab=Y0}
N 70 52370 70 52380 {
lab=Y0}
N 90 52380 120 52380 {
lab=GND}
N 120 52370 120 52380 {
lab=GND}
N 80 52330 120 52330 {
lab=word872}
N 120 52330 160 52330 {
lab=word872}
N 90 52320 90 52370 {
lab=GND}
N 90 52370 90 52380 {
lab=GND}
N 150 52320 150 52370 {
lab=Y1}
N 150 52370 150 52380 {
lab=Y1}
N 170 52380 200 52380 {
lab=GND}
N 200 52370 200 52380 {
lab=GND}
N 160 52330 200 52330 {
lab=word872}
N 200 52330 240 52330 {
lab=word872}
N 170 52320 170 52370 {
lab=GND}
N 170 52370 170 52380 {
lab=GND}
N 230 52320 230 52370 {
lab=Y2}
N 230 52370 230 52380 {
lab=Y2}
N 240 52330 280 52330 {
lab=word872}
N 280 52330 320 52330 {
lab=word872}
N 250 52320 250 52370 {
lab=GND}
N 250 52370 250 52380 {
lab=GND}
N 310 52320 310 52370 {
lab=Y3}
N 310 52370 310 52380 {
lab=Y3}
N 330 52380 360 52380 {
lab=GND}
N 360 52370 360 52380 {
lab=GND}
N 320 52330 360 52330 {
lab=word872}
N 360 52330 400 52330 {
lab=word872}
N 330 52320 330 52370 {
lab=GND}
N 330 52370 330 52380 {
lab=GND}
N 390 52320 390 52370 {
lab=Y4}
N 390 52370 390 52380 {
lab=Y4}
N 400 52330 440 52330 {
lab=word872}
N 440 52330 480 52330 {
lab=word872}
N 410 52320 410 52370 {
lab=GND}
N 410 52370 410 52380 {
lab=GND}
N 470 52320 470 52370 {
lab=Y5}
N 470 52370 470 52380 {
lab=Y5}
N 490 52380 520 52380 {
lab=GND}
N 520 52370 520 52380 {
lab=GND}
N 480 52330 520 52330 {
lab=word872}
N 520 52330 560 52330 {
lab=word872}
N 490 52320 490 52370 {
lab=GND}
N 490 52370 490 52380 {
lab=GND}
N 550 52320 550 52370 {
lab=Y6}
N 550 52370 550 52380 {
lab=Y6}
N 560 52330 600 52330 {
lab=word872}
N 600 52330 640 52330 {
lab=word872}
N 570 52320 570 52370 {
lab=GND}
N 570 52370 570 52380 {
lab=GND}
N 630 52320 630 52370 {
lab=Y7}
N 630 52370 630 52380 {
lab=Y7}
N 10 52440 40 52440 {
lab=GND}
N 40 52430 40 52440 {
lab=GND}
N 0 52390 40 52390 {
lab=word873}
N 40 52390 80 52390 {
lab=word873}
N 10 52380 10 52430 {
lab=GND}
N 10 52430 10 52440 {
lab=GND}
N 70 52380 70 52430 {
lab=Y0}
N 70 52430 70 52440 {
lab=Y0}
N 90 52440 120 52440 {
lab=GND}
N 120 52430 120 52440 {
lab=GND}
N 80 52390 120 52390 {
lab=word873}
N 120 52390 160 52390 {
lab=word873}
N 90 52380 90 52430 {
lab=GND}
N 90 52430 90 52440 {
lab=GND}
N 150 52380 150 52430 {
lab=Y1}
N 150 52430 150 52440 {
lab=Y1}
N 170 52440 200 52440 {
lab=GND}
N 200 52430 200 52440 {
lab=GND}
N 160 52390 200 52390 {
lab=word873}
N 200 52390 240 52390 {
lab=word873}
N 170 52380 170 52430 {
lab=GND}
N 170 52430 170 52440 {
lab=GND}
N 230 52380 230 52430 {
lab=Y2}
N 230 52430 230 52440 {
lab=Y2}
N 240 52390 280 52390 {
lab=word873}
N 280 52390 320 52390 {
lab=word873}
N 250 52380 250 52430 {
lab=GND}
N 250 52430 250 52440 {
lab=GND}
N 310 52380 310 52430 {
lab=Y3}
N 310 52430 310 52440 {
lab=Y3}
N 330 52440 360 52440 {
lab=GND}
N 360 52430 360 52440 {
lab=GND}
N 320 52390 360 52390 {
lab=word873}
N 360 52390 400 52390 {
lab=word873}
N 330 52380 330 52430 {
lab=GND}
N 330 52430 330 52440 {
lab=GND}
N 390 52380 390 52430 {
lab=Y4}
N 390 52430 390 52440 {
lab=Y4}
N 400 52390 440 52390 {
lab=word873}
N 440 52390 480 52390 {
lab=word873}
N 410 52380 410 52430 {
lab=GND}
N 410 52430 410 52440 {
lab=GND}
N 470 52380 470 52430 {
lab=Y5}
N 470 52430 470 52440 {
lab=Y5}
N 490 52440 520 52440 {
lab=GND}
N 520 52430 520 52440 {
lab=GND}
N 480 52390 520 52390 {
lab=word873}
N 520 52390 560 52390 {
lab=word873}
N 490 52380 490 52430 {
lab=GND}
N 490 52430 490 52440 {
lab=GND}
N 550 52380 550 52430 {
lab=Y6}
N 550 52430 550 52440 {
lab=Y6}
N 570 52440 600 52440 {
lab=GND}
N 600 52430 600 52440 {
lab=GND}
N 560 52390 600 52390 {
lab=word873}
N 600 52390 640 52390 {
lab=word873}
N 570 52380 570 52430 {
lab=GND}
N 570 52430 570 52440 {
lab=GND}
N 630 52380 630 52430 {
lab=Y7}
N 630 52430 630 52440 {
lab=Y7}
N 10 52500 40 52500 {
lab=GND}
N 40 52490 40 52500 {
lab=GND}
N 0 52450 40 52450 {
lab=word874}
N 40 52450 80 52450 {
lab=word874}
N 10 52440 10 52490 {
lab=GND}
N 10 52490 10 52500 {
lab=GND}
N 70 52440 70 52490 {
lab=Y0}
N 70 52490 70 52500 {
lab=Y0}
N 90 52500 120 52500 {
lab=GND}
N 120 52490 120 52500 {
lab=GND}
N 80 52450 120 52450 {
lab=word874}
N 120 52450 160 52450 {
lab=word874}
N 90 52440 90 52490 {
lab=GND}
N 90 52490 90 52500 {
lab=GND}
N 150 52440 150 52490 {
lab=Y1}
N 150 52490 150 52500 {
lab=Y1}
N 170 52500 200 52500 {
lab=GND}
N 200 52490 200 52500 {
lab=GND}
N 160 52450 200 52450 {
lab=word874}
N 200 52450 240 52450 {
lab=word874}
N 170 52440 170 52490 {
lab=GND}
N 170 52490 170 52500 {
lab=GND}
N 230 52440 230 52490 {
lab=Y2}
N 230 52490 230 52500 {
lab=Y2}
N 240 52450 280 52450 {
lab=word874}
N 280 52450 320 52450 {
lab=word874}
N 250 52440 250 52490 {
lab=GND}
N 250 52490 250 52500 {
lab=GND}
N 310 52440 310 52490 {
lab=Y3}
N 310 52490 310 52500 {
lab=Y3}
N 330 52500 360 52500 {
lab=GND}
N 360 52490 360 52500 {
lab=GND}
N 320 52450 360 52450 {
lab=word874}
N 360 52450 400 52450 {
lab=word874}
N 330 52440 330 52490 {
lab=GND}
N 330 52490 330 52500 {
lab=GND}
N 390 52440 390 52490 {
lab=Y4}
N 390 52490 390 52500 {
lab=Y4}
N 410 52500 440 52500 {
lab=GND}
N 440 52490 440 52500 {
lab=GND}
N 400 52450 440 52450 {
lab=word874}
N 440 52450 480 52450 {
lab=word874}
N 410 52440 410 52490 {
lab=GND}
N 410 52490 410 52500 {
lab=GND}
N 470 52440 470 52490 {
lab=Y5}
N 470 52490 470 52500 {
lab=Y5}
N 480 52450 520 52450 {
lab=word874}
N 520 52450 560 52450 {
lab=word874}
N 490 52440 490 52490 {
lab=GND}
N 490 52490 490 52500 {
lab=GND}
N 550 52440 550 52490 {
lab=Y6}
N 550 52490 550 52500 {
lab=Y6}
N 570 52500 600 52500 {
lab=GND}
N 600 52490 600 52500 {
lab=GND}
N 560 52450 600 52450 {
lab=word874}
N 600 52450 640 52450 {
lab=word874}
N 570 52440 570 52490 {
lab=GND}
N 570 52490 570 52500 {
lab=GND}
N 630 52440 630 52490 {
lab=Y7}
N 630 52490 630 52500 {
lab=Y7}
N 10 52560 40 52560 {
lab=GND}
N 40 52550 40 52560 {
lab=GND}
N 0 52510 40 52510 {
lab=word875}
N 40 52510 80 52510 {
lab=word875}
N 10 52500 10 52550 {
lab=GND}
N 10 52550 10 52560 {
lab=GND}
N 70 52500 70 52550 {
lab=Y0}
N 70 52550 70 52560 {
lab=Y0}
N 90 52560 120 52560 {
lab=GND}
N 120 52550 120 52560 {
lab=GND}
N 80 52510 120 52510 {
lab=word875}
N 120 52510 160 52510 {
lab=word875}
N 90 52500 90 52550 {
lab=GND}
N 90 52550 90 52560 {
lab=GND}
N 150 52500 150 52550 {
lab=Y1}
N 150 52550 150 52560 {
lab=Y1}
N 170 52560 200 52560 {
lab=GND}
N 200 52550 200 52560 {
lab=GND}
N 160 52510 200 52510 {
lab=word875}
N 200 52510 240 52510 {
lab=word875}
N 170 52500 170 52550 {
lab=GND}
N 170 52550 170 52560 {
lab=GND}
N 230 52500 230 52550 {
lab=Y2}
N 230 52550 230 52560 {
lab=Y2}
N 240 52510 280 52510 {
lab=word875}
N 280 52510 320 52510 {
lab=word875}
N 250 52500 250 52550 {
lab=GND}
N 250 52550 250 52560 {
lab=GND}
N 310 52500 310 52550 {
lab=Y3}
N 310 52550 310 52560 {
lab=Y3}
N 330 52560 360 52560 {
lab=GND}
N 360 52550 360 52560 {
lab=GND}
N 320 52510 360 52510 {
lab=word875}
N 360 52510 400 52510 {
lab=word875}
N 330 52500 330 52550 {
lab=GND}
N 330 52550 330 52560 {
lab=GND}
N 390 52500 390 52550 {
lab=Y4}
N 390 52550 390 52560 {
lab=Y4}
N 410 52560 440 52560 {
lab=GND}
N 440 52550 440 52560 {
lab=GND}
N 400 52510 440 52510 {
lab=word875}
N 440 52510 480 52510 {
lab=word875}
N 410 52500 410 52550 {
lab=GND}
N 410 52550 410 52560 {
lab=GND}
N 470 52500 470 52550 {
lab=Y5}
N 470 52550 470 52560 {
lab=Y5}
N 490 52560 520 52560 {
lab=GND}
N 520 52550 520 52560 {
lab=GND}
N 480 52510 520 52510 {
lab=word875}
N 520 52510 560 52510 {
lab=word875}
N 490 52500 490 52550 {
lab=GND}
N 490 52550 490 52560 {
lab=GND}
N 550 52500 550 52550 {
lab=Y6}
N 550 52550 550 52560 {
lab=Y6}
N 560 52510 600 52510 {
lab=word875}
N 600 52510 640 52510 {
lab=word875}
N 570 52500 570 52550 {
lab=GND}
N 570 52550 570 52560 {
lab=GND}
N 630 52500 630 52550 {
lab=Y7}
N 630 52550 630 52560 {
lab=Y7}
N 10 52620 40 52620 {
lab=GND}
N 40 52610 40 52620 {
lab=GND}
N 0 52570 40 52570 {
lab=word876}
N 40 52570 80 52570 {
lab=word876}
N 10 52560 10 52610 {
lab=GND}
N 10 52610 10 52620 {
lab=GND}
N 70 52560 70 52610 {
lab=Y0}
N 70 52610 70 52620 {
lab=Y0}
N 90 52620 120 52620 {
lab=GND}
N 120 52610 120 52620 {
lab=GND}
N 80 52570 120 52570 {
lab=word876}
N 120 52570 160 52570 {
lab=word876}
N 90 52560 90 52610 {
lab=GND}
N 90 52610 90 52620 {
lab=GND}
N 150 52560 150 52610 {
lab=Y1}
N 150 52610 150 52620 {
lab=Y1}
N 170 52620 200 52620 {
lab=GND}
N 200 52610 200 52620 {
lab=GND}
N 160 52570 200 52570 {
lab=word876}
N 200 52570 240 52570 {
lab=word876}
N 170 52560 170 52610 {
lab=GND}
N 170 52610 170 52620 {
lab=GND}
N 230 52560 230 52610 {
lab=Y2}
N 230 52610 230 52620 {
lab=Y2}
N 250 52620 280 52620 {
lab=GND}
N 280 52610 280 52620 {
lab=GND}
N 240 52570 280 52570 {
lab=word876}
N 280 52570 320 52570 {
lab=word876}
N 250 52560 250 52610 {
lab=GND}
N 250 52610 250 52620 {
lab=GND}
N 310 52560 310 52610 {
lab=Y3}
N 310 52610 310 52620 {
lab=Y3}
N 320 52570 360 52570 {
lab=word876}
N 360 52570 400 52570 {
lab=word876}
N 330 52560 330 52610 {
lab=GND}
N 330 52610 330 52620 {
lab=GND}
N 390 52560 390 52610 {
lab=Y4}
N 390 52610 390 52620 {
lab=Y4}
N 400 52570 440 52570 {
lab=word876}
N 440 52570 480 52570 {
lab=word876}
N 410 52560 410 52610 {
lab=GND}
N 410 52610 410 52620 {
lab=GND}
N 470 52560 470 52610 {
lab=Y5}
N 470 52610 470 52620 {
lab=Y5}
N 480 52570 520 52570 {
lab=word876}
N 520 52570 560 52570 {
lab=word876}
N 490 52560 490 52610 {
lab=GND}
N 490 52610 490 52620 {
lab=GND}
N 550 52560 550 52610 {
lab=Y6}
N 550 52610 550 52620 {
lab=Y6}
N 560 52570 600 52570 {
lab=word876}
N 600 52570 640 52570 {
lab=word876}
N 570 52560 570 52610 {
lab=GND}
N 570 52610 570 52620 {
lab=GND}
N 630 52560 630 52610 {
lab=Y7}
N 630 52610 630 52620 {
lab=Y7}
N 10 52680 40 52680 {
lab=GND}
N 40 52670 40 52680 {
lab=GND}
N 0 52630 40 52630 {
lab=word877}
N 40 52630 80 52630 {
lab=word877}
N 10 52620 10 52670 {
lab=GND}
N 10 52670 10 52680 {
lab=GND}
N 70 52620 70 52670 {
lab=Y0}
N 70 52670 70 52680 {
lab=Y0}
N 90 52680 120 52680 {
lab=GND}
N 120 52670 120 52680 {
lab=GND}
N 80 52630 120 52630 {
lab=word877}
N 120 52630 160 52630 {
lab=word877}
N 90 52620 90 52670 {
lab=GND}
N 90 52670 90 52680 {
lab=GND}
N 150 52620 150 52670 {
lab=Y1}
N 150 52670 150 52680 {
lab=Y1}
N 170 52680 200 52680 {
lab=GND}
N 200 52670 200 52680 {
lab=GND}
N 160 52630 200 52630 {
lab=word877}
N 200 52630 240 52630 {
lab=word877}
N 170 52620 170 52670 {
lab=GND}
N 170 52670 170 52680 {
lab=GND}
N 230 52620 230 52670 {
lab=Y2}
N 230 52670 230 52680 {
lab=Y2}
N 250 52680 280 52680 {
lab=GND}
N 280 52670 280 52680 {
lab=GND}
N 240 52630 280 52630 {
lab=word877}
N 280 52630 320 52630 {
lab=word877}
N 250 52620 250 52670 {
lab=GND}
N 250 52670 250 52680 {
lab=GND}
N 310 52620 310 52670 {
lab=Y3}
N 310 52670 310 52680 {
lab=Y3}
N 320 52630 360 52630 {
lab=word877}
N 360 52630 400 52630 {
lab=word877}
N 330 52620 330 52670 {
lab=GND}
N 330 52670 330 52680 {
lab=GND}
N 390 52620 390 52670 {
lab=Y4}
N 390 52670 390 52680 {
lab=Y4}
N 400 52630 440 52630 {
lab=word877}
N 440 52630 480 52630 {
lab=word877}
N 410 52620 410 52670 {
lab=GND}
N 410 52670 410 52680 {
lab=GND}
N 470 52620 470 52670 {
lab=Y5}
N 470 52670 470 52680 {
lab=Y5}
N 480 52630 520 52630 {
lab=word877}
N 520 52630 560 52630 {
lab=word877}
N 490 52620 490 52670 {
lab=GND}
N 490 52670 490 52680 {
lab=GND}
N 550 52620 550 52670 {
lab=Y6}
N 550 52670 550 52680 {
lab=Y6}
N 570 52680 600 52680 {
lab=GND}
N 600 52670 600 52680 {
lab=GND}
N 560 52630 600 52630 {
lab=word877}
N 600 52630 640 52630 {
lab=word877}
N 570 52620 570 52670 {
lab=GND}
N 570 52670 570 52680 {
lab=GND}
N 630 52620 630 52670 {
lab=Y7}
N 630 52670 630 52680 {
lab=Y7}
N 10 52740 40 52740 {
lab=GND}
N 40 52730 40 52740 {
lab=GND}
N 0 52690 40 52690 {
lab=word878}
N 40 52690 80 52690 {
lab=word878}
N 10 52680 10 52730 {
lab=GND}
N 10 52730 10 52740 {
lab=GND}
N 70 52680 70 52730 {
lab=Y0}
N 70 52730 70 52740 {
lab=Y0}
N 90 52740 120 52740 {
lab=GND}
N 120 52730 120 52740 {
lab=GND}
N 80 52690 120 52690 {
lab=word878}
N 120 52690 160 52690 {
lab=word878}
N 90 52680 90 52730 {
lab=GND}
N 90 52730 90 52740 {
lab=GND}
N 150 52680 150 52730 {
lab=Y1}
N 150 52730 150 52740 {
lab=Y1}
N 170 52740 200 52740 {
lab=GND}
N 200 52730 200 52740 {
lab=GND}
N 160 52690 200 52690 {
lab=word878}
N 200 52690 240 52690 {
lab=word878}
N 170 52680 170 52730 {
lab=GND}
N 170 52730 170 52740 {
lab=GND}
N 230 52680 230 52730 {
lab=Y2}
N 230 52730 230 52740 {
lab=Y2}
N 250 52740 280 52740 {
lab=GND}
N 280 52730 280 52740 {
lab=GND}
N 240 52690 280 52690 {
lab=word878}
N 280 52690 320 52690 {
lab=word878}
N 250 52680 250 52730 {
lab=GND}
N 250 52730 250 52740 {
lab=GND}
N 310 52680 310 52730 {
lab=Y3}
N 310 52730 310 52740 {
lab=Y3}
N 320 52690 360 52690 {
lab=word878}
N 360 52690 400 52690 {
lab=word878}
N 330 52680 330 52730 {
lab=GND}
N 330 52730 330 52740 {
lab=GND}
N 390 52680 390 52730 {
lab=Y4}
N 390 52730 390 52740 {
lab=Y4}
N 400 52690 440 52690 {
lab=word878}
N 440 52690 480 52690 {
lab=word878}
N 410 52680 410 52730 {
lab=GND}
N 410 52730 410 52740 {
lab=GND}
N 470 52680 470 52730 {
lab=Y5}
N 470 52730 470 52740 {
lab=Y5}
N 490 52740 520 52740 {
lab=GND}
N 520 52730 520 52740 {
lab=GND}
N 480 52690 520 52690 {
lab=word878}
N 520 52690 560 52690 {
lab=word878}
N 490 52680 490 52730 {
lab=GND}
N 490 52730 490 52740 {
lab=GND}
N 550 52680 550 52730 {
lab=Y6}
N 550 52730 550 52740 {
lab=Y6}
N 570 52740 600 52740 {
lab=GND}
N 600 52730 600 52740 {
lab=GND}
N 560 52690 600 52690 {
lab=word878}
N 600 52690 640 52690 {
lab=word878}
N 570 52680 570 52730 {
lab=GND}
N 570 52730 570 52740 {
lab=GND}
N 630 52680 630 52730 {
lab=Y7}
N 630 52730 630 52740 {
lab=Y7}
N 10 52800 40 52800 {
lab=GND}
N 40 52790 40 52800 {
lab=GND}
N 0 52750 40 52750 {
lab=word879}
N 40 52750 80 52750 {
lab=word879}
N 10 52740 10 52790 {
lab=GND}
N 10 52790 10 52800 {
lab=GND}
N 70 52740 70 52790 {
lab=Y0}
N 70 52790 70 52800 {
lab=Y0}
N 90 52800 120 52800 {
lab=GND}
N 120 52790 120 52800 {
lab=GND}
N 80 52750 120 52750 {
lab=word879}
N 120 52750 160 52750 {
lab=word879}
N 90 52740 90 52790 {
lab=GND}
N 90 52790 90 52800 {
lab=GND}
N 150 52740 150 52790 {
lab=Y1}
N 150 52790 150 52800 {
lab=Y1}
N 170 52800 200 52800 {
lab=GND}
N 200 52790 200 52800 {
lab=GND}
N 160 52750 200 52750 {
lab=word879}
N 200 52750 240 52750 {
lab=word879}
N 170 52740 170 52790 {
lab=GND}
N 170 52790 170 52800 {
lab=GND}
N 230 52740 230 52790 {
lab=Y2}
N 230 52790 230 52800 {
lab=Y2}
N 250 52800 280 52800 {
lab=GND}
N 280 52790 280 52800 {
lab=GND}
N 240 52750 280 52750 {
lab=word879}
N 280 52750 320 52750 {
lab=word879}
N 250 52740 250 52790 {
lab=GND}
N 250 52790 250 52800 {
lab=GND}
N 310 52740 310 52790 {
lab=Y3}
N 310 52790 310 52800 {
lab=Y3}
N 320 52750 360 52750 {
lab=word879}
N 360 52750 400 52750 {
lab=word879}
N 330 52740 330 52790 {
lab=GND}
N 330 52790 330 52800 {
lab=GND}
N 390 52740 390 52790 {
lab=Y4}
N 390 52790 390 52800 {
lab=Y4}
N 410 52800 440 52800 {
lab=GND}
N 440 52790 440 52800 {
lab=GND}
N 400 52750 440 52750 {
lab=word879}
N 440 52750 480 52750 {
lab=word879}
N 410 52740 410 52790 {
lab=GND}
N 410 52790 410 52800 {
lab=GND}
N 470 52740 470 52790 {
lab=Y5}
N 470 52790 470 52800 {
lab=Y5}
N 480 52750 520 52750 {
lab=word879}
N 520 52750 560 52750 {
lab=word879}
N 490 52740 490 52790 {
lab=GND}
N 490 52790 490 52800 {
lab=GND}
N 550 52740 550 52790 {
lab=Y6}
N 550 52790 550 52800 {
lab=Y6}
N 560 52750 600 52750 {
lab=word879}
N 600 52750 640 52750 {
lab=word879}
N 570 52740 570 52790 {
lab=GND}
N 570 52790 570 52800 {
lab=GND}
N 630 52740 630 52790 {
lab=Y7}
N 630 52790 630 52800 {
lab=Y7}
N 10 52860 40 52860 {
lab=GND}
N 40 52850 40 52860 {
lab=GND}
N 0 52810 40 52810 {
lab=word880}
N 40 52810 80 52810 {
lab=word880}
N 10 52800 10 52850 {
lab=GND}
N 10 52850 10 52860 {
lab=GND}
N 70 52800 70 52850 {
lab=Y0}
N 70 52850 70 52860 {
lab=Y0}
N 90 52860 120 52860 {
lab=GND}
N 120 52850 120 52860 {
lab=GND}
N 80 52810 120 52810 {
lab=word880}
N 120 52810 160 52810 {
lab=word880}
N 90 52800 90 52850 {
lab=GND}
N 90 52850 90 52860 {
lab=GND}
N 150 52800 150 52850 {
lab=Y1}
N 150 52850 150 52860 {
lab=Y1}
N 170 52860 200 52860 {
lab=GND}
N 200 52850 200 52860 {
lab=GND}
N 160 52810 200 52810 {
lab=word880}
N 200 52810 240 52810 {
lab=word880}
N 170 52800 170 52850 {
lab=GND}
N 170 52850 170 52860 {
lab=GND}
N 230 52800 230 52850 {
lab=Y2}
N 230 52850 230 52860 {
lab=Y2}
N 250 52860 280 52860 {
lab=GND}
N 280 52850 280 52860 {
lab=GND}
N 240 52810 280 52810 {
lab=word880}
N 280 52810 320 52810 {
lab=word880}
N 250 52800 250 52850 {
lab=GND}
N 250 52850 250 52860 {
lab=GND}
N 310 52800 310 52850 {
lab=Y3}
N 310 52850 310 52860 {
lab=Y3}
N 320 52810 360 52810 {
lab=word880}
N 360 52810 400 52810 {
lab=word880}
N 330 52800 330 52850 {
lab=GND}
N 330 52850 330 52860 {
lab=GND}
N 390 52800 390 52850 {
lab=Y4}
N 390 52850 390 52860 {
lab=Y4}
N 410 52860 440 52860 {
lab=GND}
N 440 52850 440 52860 {
lab=GND}
N 400 52810 440 52810 {
lab=word880}
N 440 52810 480 52810 {
lab=word880}
N 410 52800 410 52850 {
lab=GND}
N 410 52850 410 52860 {
lab=GND}
N 470 52800 470 52850 {
lab=Y5}
N 470 52850 470 52860 {
lab=Y5}
N 480 52810 520 52810 {
lab=word880}
N 520 52810 560 52810 {
lab=word880}
N 490 52800 490 52850 {
lab=GND}
N 490 52850 490 52860 {
lab=GND}
N 550 52800 550 52850 {
lab=Y6}
N 550 52850 550 52860 {
lab=Y6}
N 570 52860 600 52860 {
lab=GND}
N 600 52850 600 52860 {
lab=GND}
N 560 52810 600 52810 {
lab=word880}
N 600 52810 640 52810 {
lab=word880}
N 570 52800 570 52850 {
lab=GND}
N 570 52850 570 52860 {
lab=GND}
N 630 52800 630 52850 {
lab=Y7}
N 630 52850 630 52860 {
lab=Y7}
N 10 52920 40 52920 {
lab=GND}
N 40 52910 40 52920 {
lab=GND}
N 0 52870 40 52870 {
lab=word881}
N 40 52870 80 52870 {
lab=word881}
N 10 52860 10 52910 {
lab=GND}
N 10 52910 10 52920 {
lab=GND}
N 70 52860 70 52910 {
lab=Y0}
N 70 52910 70 52920 {
lab=Y0}
N 90 52920 120 52920 {
lab=GND}
N 120 52910 120 52920 {
lab=GND}
N 80 52870 120 52870 {
lab=word881}
N 120 52870 160 52870 {
lab=word881}
N 90 52860 90 52910 {
lab=GND}
N 90 52910 90 52920 {
lab=GND}
N 150 52860 150 52910 {
lab=Y1}
N 150 52910 150 52920 {
lab=Y1}
N 170 52920 200 52920 {
lab=GND}
N 200 52910 200 52920 {
lab=GND}
N 160 52870 200 52870 {
lab=word881}
N 200 52870 240 52870 {
lab=word881}
N 170 52860 170 52910 {
lab=GND}
N 170 52910 170 52920 {
lab=GND}
N 230 52860 230 52910 {
lab=Y2}
N 230 52910 230 52920 {
lab=Y2}
N 250 52920 280 52920 {
lab=GND}
N 280 52910 280 52920 {
lab=GND}
N 240 52870 280 52870 {
lab=word881}
N 280 52870 320 52870 {
lab=word881}
N 250 52860 250 52910 {
lab=GND}
N 250 52910 250 52920 {
lab=GND}
N 310 52860 310 52910 {
lab=Y3}
N 310 52910 310 52920 {
lab=Y3}
N 320 52870 360 52870 {
lab=word881}
N 360 52870 400 52870 {
lab=word881}
N 330 52860 330 52910 {
lab=GND}
N 330 52910 330 52920 {
lab=GND}
N 390 52860 390 52910 {
lab=Y4}
N 390 52910 390 52920 {
lab=Y4}
N 410 52920 440 52920 {
lab=GND}
N 440 52910 440 52920 {
lab=GND}
N 400 52870 440 52870 {
lab=word881}
N 440 52870 480 52870 {
lab=word881}
N 410 52860 410 52910 {
lab=GND}
N 410 52910 410 52920 {
lab=GND}
N 470 52860 470 52910 {
lab=Y5}
N 470 52910 470 52920 {
lab=Y5}
N 490 52920 520 52920 {
lab=GND}
N 520 52910 520 52920 {
lab=GND}
N 480 52870 520 52870 {
lab=word881}
N 520 52870 560 52870 {
lab=word881}
N 490 52860 490 52910 {
lab=GND}
N 490 52910 490 52920 {
lab=GND}
N 550 52860 550 52910 {
lab=Y6}
N 550 52910 550 52920 {
lab=Y6}
N 560 52870 600 52870 {
lab=word881}
N 600 52870 640 52870 {
lab=word881}
N 570 52860 570 52910 {
lab=GND}
N 570 52910 570 52920 {
lab=GND}
N 630 52860 630 52910 {
lab=Y7}
N 630 52910 630 52920 {
lab=Y7}
N 10 52980 40 52980 {
lab=GND}
N 40 52970 40 52980 {
lab=GND}
N 0 52930 40 52930 {
lab=word882}
N 40 52930 80 52930 {
lab=word882}
N 10 52920 10 52970 {
lab=GND}
N 10 52970 10 52980 {
lab=GND}
N 70 52920 70 52970 {
lab=Y0}
N 70 52970 70 52980 {
lab=Y0}
N 90 52980 120 52980 {
lab=GND}
N 120 52970 120 52980 {
lab=GND}
N 80 52930 120 52930 {
lab=word882}
N 120 52930 160 52930 {
lab=word882}
N 90 52920 90 52970 {
lab=GND}
N 90 52970 90 52980 {
lab=GND}
N 150 52920 150 52970 {
lab=Y1}
N 150 52970 150 52980 {
lab=Y1}
N 170 52980 200 52980 {
lab=GND}
N 200 52970 200 52980 {
lab=GND}
N 160 52930 200 52930 {
lab=word882}
N 200 52930 240 52930 {
lab=word882}
N 170 52920 170 52970 {
lab=GND}
N 170 52970 170 52980 {
lab=GND}
N 230 52920 230 52970 {
lab=Y2}
N 230 52970 230 52980 {
lab=Y2}
N 250 52980 280 52980 {
lab=GND}
N 280 52970 280 52980 {
lab=GND}
N 240 52930 280 52930 {
lab=word882}
N 280 52930 320 52930 {
lab=word882}
N 250 52920 250 52970 {
lab=GND}
N 250 52970 250 52980 {
lab=GND}
N 310 52920 310 52970 {
lab=Y3}
N 310 52970 310 52980 {
lab=Y3}
N 330 52980 360 52980 {
lab=GND}
N 360 52970 360 52980 {
lab=GND}
N 320 52930 360 52930 {
lab=word882}
N 360 52930 400 52930 {
lab=word882}
N 330 52920 330 52970 {
lab=GND}
N 330 52970 330 52980 {
lab=GND}
N 390 52920 390 52970 {
lab=Y4}
N 390 52970 390 52980 {
lab=Y4}
N 400 52930 440 52930 {
lab=word882}
N 440 52930 480 52930 {
lab=word882}
N 410 52920 410 52970 {
lab=GND}
N 410 52970 410 52980 {
lab=GND}
N 470 52920 470 52970 {
lab=Y5}
N 470 52970 470 52980 {
lab=Y5}
N 480 52930 520 52930 {
lab=word882}
N 520 52930 560 52930 {
lab=word882}
N 490 52920 490 52970 {
lab=GND}
N 490 52970 490 52980 {
lab=GND}
N 550 52920 550 52970 {
lab=Y6}
N 550 52970 550 52980 {
lab=Y6}
N 560 52930 600 52930 {
lab=word882}
N 600 52930 640 52930 {
lab=word882}
N 570 52920 570 52970 {
lab=GND}
N 570 52970 570 52980 {
lab=GND}
N 630 52920 630 52970 {
lab=Y7}
N 630 52970 630 52980 {
lab=Y7}
N 10 53040 40 53040 {
lab=GND}
N 40 53030 40 53040 {
lab=GND}
N 0 52990 40 52990 {
lab=word883}
N 40 52990 80 52990 {
lab=word883}
N 10 52980 10 53030 {
lab=GND}
N 10 53030 10 53040 {
lab=GND}
N 70 52980 70 53030 {
lab=Y0}
N 70 53030 70 53040 {
lab=Y0}
N 90 53040 120 53040 {
lab=GND}
N 120 53030 120 53040 {
lab=GND}
N 80 52990 120 52990 {
lab=word883}
N 120 52990 160 52990 {
lab=word883}
N 90 52980 90 53030 {
lab=GND}
N 90 53030 90 53040 {
lab=GND}
N 150 52980 150 53030 {
lab=Y1}
N 150 53030 150 53040 {
lab=Y1}
N 170 53040 200 53040 {
lab=GND}
N 200 53030 200 53040 {
lab=GND}
N 160 52990 200 52990 {
lab=word883}
N 200 52990 240 52990 {
lab=word883}
N 170 52980 170 53030 {
lab=GND}
N 170 53030 170 53040 {
lab=GND}
N 230 52980 230 53030 {
lab=Y2}
N 230 53030 230 53040 {
lab=Y2}
N 250 53040 280 53040 {
lab=GND}
N 280 53030 280 53040 {
lab=GND}
N 240 52990 280 52990 {
lab=word883}
N 280 52990 320 52990 {
lab=word883}
N 250 52980 250 53030 {
lab=GND}
N 250 53030 250 53040 {
lab=GND}
N 310 52980 310 53030 {
lab=Y3}
N 310 53030 310 53040 {
lab=Y3}
N 330 53040 360 53040 {
lab=GND}
N 360 53030 360 53040 {
lab=GND}
N 320 52990 360 52990 {
lab=word883}
N 360 52990 400 52990 {
lab=word883}
N 330 52980 330 53030 {
lab=GND}
N 330 53030 330 53040 {
lab=GND}
N 390 52980 390 53030 {
lab=Y4}
N 390 53030 390 53040 {
lab=Y4}
N 400 52990 440 52990 {
lab=word883}
N 440 52990 480 52990 {
lab=word883}
N 410 52980 410 53030 {
lab=GND}
N 410 53030 410 53040 {
lab=GND}
N 470 52980 470 53030 {
lab=Y5}
N 470 53030 470 53040 {
lab=Y5}
N 480 52990 520 52990 {
lab=word883}
N 520 52990 560 52990 {
lab=word883}
N 490 52980 490 53030 {
lab=GND}
N 490 53030 490 53040 {
lab=GND}
N 550 52980 550 53030 {
lab=Y6}
N 550 53030 550 53040 {
lab=Y6}
N 570 53040 600 53040 {
lab=GND}
N 600 53030 600 53040 {
lab=GND}
N 560 52990 600 52990 {
lab=word883}
N 600 52990 640 52990 {
lab=word883}
N 570 52980 570 53030 {
lab=GND}
N 570 53030 570 53040 {
lab=GND}
N 630 52980 630 53030 {
lab=Y7}
N 630 53030 630 53040 {
lab=Y7}
N 10 53100 40 53100 {
lab=GND}
N 40 53090 40 53100 {
lab=GND}
N 0 53050 40 53050 {
lab=word884}
N 40 53050 80 53050 {
lab=word884}
N 10 53040 10 53090 {
lab=GND}
N 10 53090 10 53100 {
lab=GND}
N 70 53040 70 53090 {
lab=Y0}
N 70 53090 70 53100 {
lab=Y0}
N 90 53100 120 53100 {
lab=GND}
N 120 53090 120 53100 {
lab=GND}
N 80 53050 120 53050 {
lab=word884}
N 120 53050 160 53050 {
lab=word884}
N 90 53040 90 53090 {
lab=GND}
N 90 53090 90 53100 {
lab=GND}
N 150 53040 150 53090 {
lab=Y1}
N 150 53090 150 53100 {
lab=Y1}
N 170 53100 200 53100 {
lab=GND}
N 200 53090 200 53100 {
lab=GND}
N 160 53050 200 53050 {
lab=word884}
N 200 53050 240 53050 {
lab=word884}
N 170 53040 170 53090 {
lab=GND}
N 170 53090 170 53100 {
lab=GND}
N 230 53040 230 53090 {
lab=Y2}
N 230 53090 230 53100 {
lab=Y2}
N 250 53100 280 53100 {
lab=GND}
N 280 53090 280 53100 {
lab=GND}
N 240 53050 280 53050 {
lab=word884}
N 280 53050 320 53050 {
lab=word884}
N 250 53040 250 53090 {
lab=GND}
N 250 53090 250 53100 {
lab=GND}
N 310 53040 310 53090 {
lab=Y3}
N 310 53090 310 53100 {
lab=Y3}
N 330 53100 360 53100 {
lab=GND}
N 360 53090 360 53100 {
lab=GND}
N 320 53050 360 53050 {
lab=word884}
N 360 53050 400 53050 {
lab=word884}
N 330 53040 330 53090 {
lab=GND}
N 330 53090 330 53100 {
lab=GND}
N 390 53040 390 53090 {
lab=Y4}
N 390 53090 390 53100 {
lab=Y4}
N 400 53050 440 53050 {
lab=word884}
N 440 53050 480 53050 {
lab=word884}
N 410 53040 410 53090 {
lab=GND}
N 410 53090 410 53100 {
lab=GND}
N 470 53040 470 53090 {
lab=Y5}
N 470 53090 470 53100 {
lab=Y5}
N 490 53100 520 53100 {
lab=GND}
N 520 53090 520 53100 {
lab=GND}
N 480 53050 520 53050 {
lab=word884}
N 520 53050 560 53050 {
lab=word884}
N 490 53040 490 53090 {
lab=GND}
N 490 53090 490 53100 {
lab=GND}
N 550 53040 550 53090 {
lab=Y6}
N 550 53090 550 53100 {
lab=Y6}
N 560 53050 600 53050 {
lab=word884}
N 600 53050 640 53050 {
lab=word884}
N 570 53040 570 53090 {
lab=GND}
N 570 53090 570 53100 {
lab=GND}
N 630 53040 630 53090 {
lab=Y7}
N 630 53090 630 53100 {
lab=Y7}
N 10 53160 40 53160 {
lab=GND}
N 40 53150 40 53160 {
lab=GND}
N 0 53110 40 53110 {
lab=word885}
N 40 53110 80 53110 {
lab=word885}
N 10 53100 10 53150 {
lab=GND}
N 10 53150 10 53160 {
lab=GND}
N 70 53100 70 53150 {
lab=Y0}
N 70 53150 70 53160 {
lab=Y0}
N 90 53160 120 53160 {
lab=GND}
N 120 53150 120 53160 {
lab=GND}
N 80 53110 120 53110 {
lab=word885}
N 120 53110 160 53110 {
lab=word885}
N 90 53100 90 53150 {
lab=GND}
N 90 53150 90 53160 {
lab=GND}
N 150 53100 150 53150 {
lab=Y1}
N 150 53150 150 53160 {
lab=Y1}
N 170 53160 200 53160 {
lab=GND}
N 200 53150 200 53160 {
lab=GND}
N 160 53110 200 53110 {
lab=word885}
N 200 53110 240 53110 {
lab=word885}
N 170 53100 170 53150 {
lab=GND}
N 170 53150 170 53160 {
lab=GND}
N 230 53100 230 53150 {
lab=Y2}
N 230 53150 230 53160 {
lab=Y2}
N 250 53160 280 53160 {
lab=GND}
N 280 53150 280 53160 {
lab=GND}
N 240 53110 280 53110 {
lab=word885}
N 280 53110 320 53110 {
lab=word885}
N 250 53100 250 53150 {
lab=GND}
N 250 53150 250 53160 {
lab=GND}
N 310 53100 310 53150 {
lab=Y3}
N 310 53150 310 53160 {
lab=Y3}
N 330 53160 360 53160 {
lab=GND}
N 360 53150 360 53160 {
lab=GND}
N 320 53110 360 53110 {
lab=word885}
N 360 53110 400 53110 {
lab=word885}
N 330 53100 330 53150 {
lab=GND}
N 330 53150 330 53160 {
lab=GND}
N 390 53100 390 53150 {
lab=Y4}
N 390 53150 390 53160 {
lab=Y4}
N 400 53110 440 53110 {
lab=word885}
N 440 53110 480 53110 {
lab=word885}
N 410 53100 410 53150 {
lab=GND}
N 410 53150 410 53160 {
lab=GND}
N 470 53100 470 53150 {
lab=Y5}
N 470 53150 470 53160 {
lab=Y5}
N 490 53160 520 53160 {
lab=GND}
N 520 53150 520 53160 {
lab=GND}
N 480 53110 520 53110 {
lab=word885}
N 520 53110 560 53110 {
lab=word885}
N 490 53100 490 53150 {
lab=GND}
N 490 53150 490 53160 {
lab=GND}
N 550 53100 550 53150 {
lab=Y6}
N 550 53150 550 53160 {
lab=Y6}
N 560 53110 600 53110 {
lab=word885}
N 600 53110 640 53110 {
lab=word885}
N 570 53100 570 53150 {
lab=GND}
N 570 53150 570 53160 {
lab=GND}
N 630 53100 630 53150 {
lab=Y7}
N 630 53150 630 53160 {
lab=Y7}
N 10 53220 40 53220 {
lab=GND}
N 40 53210 40 53220 {
lab=GND}
N 0 53170 40 53170 {
lab=word886}
N 40 53170 80 53170 {
lab=word886}
N 10 53160 10 53210 {
lab=GND}
N 10 53210 10 53220 {
lab=GND}
N 70 53160 70 53210 {
lab=Y0}
N 70 53210 70 53220 {
lab=Y0}
N 90 53220 120 53220 {
lab=GND}
N 120 53210 120 53220 {
lab=GND}
N 80 53170 120 53170 {
lab=word886}
N 120 53170 160 53170 {
lab=word886}
N 90 53160 90 53210 {
lab=GND}
N 90 53210 90 53220 {
lab=GND}
N 150 53160 150 53210 {
lab=Y1}
N 150 53210 150 53220 {
lab=Y1}
N 170 53220 200 53220 {
lab=GND}
N 200 53210 200 53220 {
lab=GND}
N 160 53170 200 53170 {
lab=word886}
N 200 53170 240 53170 {
lab=word886}
N 170 53160 170 53210 {
lab=GND}
N 170 53210 170 53220 {
lab=GND}
N 230 53160 230 53210 {
lab=Y2}
N 230 53210 230 53220 {
lab=Y2}
N 250 53220 280 53220 {
lab=GND}
N 280 53210 280 53220 {
lab=GND}
N 240 53170 280 53170 {
lab=word886}
N 280 53170 320 53170 {
lab=word886}
N 250 53160 250 53210 {
lab=GND}
N 250 53210 250 53220 {
lab=GND}
N 310 53160 310 53210 {
lab=Y3}
N 310 53210 310 53220 {
lab=Y3}
N 330 53220 360 53220 {
lab=GND}
N 360 53210 360 53220 {
lab=GND}
N 320 53170 360 53170 {
lab=word886}
N 360 53170 400 53170 {
lab=word886}
N 330 53160 330 53210 {
lab=GND}
N 330 53210 330 53220 {
lab=GND}
N 390 53160 390 53210 {
lab=Y4}
N 390 53210 390 53220 {
lab=Y4}
N 400 53170 440 53170 {
lab=word886}
N 440 53170 480 53170 {
lab=word886}
N 410 53160 410 53210 {
lab=GND}
N 410 53210 410 53220 {
lab=GND}
N 470 53160 470 53210 {
lab=Y5}
N 470 53210 470 53220 {
lab=Y5}
N 490 53220 520 53220 {
lab=GND}
N 520 53210 520 53220 {
lab=GND}
N 480 53170 520 53170 {
lab=word886}
N 520 53170 560 53170 {
lab=word886}
N 490 53160 490 53210 {
lab=GND}
N 490 53210 490 53220 {
lab=GND}
N 550 53160 550 53210 {
lab=Y6}
N 550 53210 550 53220 {
lab=Y6}
N 570 53220 600 53220 {
lab=GND}
N 600 53210 600 53220 {
lab=GND}
N 560 53170 600 53170 {
lab=word886}
N 600 53170 640 53170 {
lab=word886}
N 570 53160 570 53210 {
lab=GND}
N 570 53210 570 53220 {
lab=GND}
N 630 53160 630 53210 {
lab=Y7}
N 630 53210 630 53220 {
lab=Y7}
N 10 53280 40 53280 {
lab=GND}
N 40 53270 40 53280 {
lab=GND}
N 0 53230 40 53230 {
lab=word887}
N 40 53230 80 53230 {
lab=word887}
N 10 53220 10 53270 {
lab=GND}
N 10 53270 10 53280 {
lab=GND}
N 70 53220 70 53270 {
lab=Y0}
N 70 53270 70 53280 {
lab=Y0}
N 90 53280 120 53280 {
lab=GND}
N 120 53270 120 53280 {
lab=GND}
N 80 53230 120 53230 {
lab=word887}
N 120 53230 160 53230 {
lab=word887}
N 90 53220 90 53270 {
lab=GND}
N 90 53270 90 53280 {
lab=GND}
N 150 53220 150 53270 {
lab=Y1}
N 150 53270 150 53280 {
lab=Y1}
N 170 53280 200 53280 {
lab=GND}
N 200 53270 200 53280 {
lab=GND}
N 160 53230 200 53230 {
lab=word887}
N 200 53230 240 53230 {
lab=word887}
N 170 53220 170 53270 {
lab=GND}
N 170 53270 170 53280 {
lab=GND}
N 230 53220 230 53270 {
lab=Y2}
N 230 53270 230 53280 {
lab=Y2}
N 250 53280 280 53280 {
lab=GND}
N 280 53270 280 53280 {
lab=GND}
N 240 53230 280 53230 {
lab=word887}
N 280 53230 320 53230 {
lab=word887}
N 250 53220 250 53270 {
lab=GND}
N 250 53270 250 53280 {
lab=GND}
N 310 53220 310 53270 {
lab=Y3}
N 310 53270 310 53280 {
lab=Y3}
N 330 53280 360 53280 {
lab=GND}
N 360 53270 360 53280 {
lab=GND}
N 320 53230 360 53230 {
lab=word887}
N 360 53230 400 53230 {
lab=word887}
N 330 53220 330 53270 {
lab=GND}
N 330 53270 330 53280 {
lab=GND}
N 390 53220 390 53270 {
lab=Y4}
N 390 53270 390 53280 {
lab=Y4}
N 410 53280 440 53280 {
lab=GND}
N 440 53270 440 53280 {
lab=GND}
N 400 53230 440 53230 {
lab=word887}
N 440 53230 480 53230 {
lab=word887}
N 410 53220 410 53270 {
lab=GND}
N 410 53270 410 53280 {
lab=GND}
N 470 53220 470 53270 {
lab=Y5}
N 470 53270 470 53280 {
lab=Y5}
N 480 53230 520 53230 {
lab=word887}
N 520 53230 560 53230 {
lab=word887}
N 490 53220 490 53270 {
lab=GND}
N 490 53270 490 53280 {
lab=GND}
N 550 53220 550 53270 {
lab=Y6}
N 550 53270 550 53280 {
lab=Y6}
N 560 53230 600 53230 {
lab=word887}
N 600 53230 640 53230 {
lab=word887}
N 570 53220 570 53270 {
lab=GND}
N 570 53270 570 53280 {
lab=GND}
N 630 53220 630 53270 {
lab=Y7}
N 630 53270 630 53280 {
lab=Y7}
N 10 53340 40 53340 {
lab=GND}
N 40 53330 40 53340 {
lab=GND}
N 0 53290 40 53290 {
lab=word888}
N 40 53290 80 53290 {
lab=word888}
N 10 53280 10 53330 {
lab=GND}
N 10 53330 10 53340 {
lab=GND}
N 70 53280 70 53330 {
lab=Y0}
N 70 53330 70 53340 {
lab=Y0}
N 90 53340 120 53340 {
lab=GND}
N 120 53330 120 53340 {
lab=GND}
N 80 53290 120 53290 {
lab=word888}
N 120 53290 160 53290 {
lab=word888}
N 90 53280 90 53330 {
lab=GND}
N 90 53330 90 53340 {
lab=GND}
N 150 53280 150 53330 {
lab=Y1}
N 150 53330 150 53340 {
lab=Y1}
N 170 53340 200 53340 {
lab=GND}
N 200 53330 200 53340 {
lab=GND}
N 160 53290 200 53290 {
lab=word888}
N 200 53290 240 53290 {
lab=word888}
N 170 53280 170 53330 {
lab=GND}
N 170 53330 170 53340 {
lab=GND}
N 230 53280 230 53330 {
lab=Y2}
N 230 53330 230 53340 {
lab=Y2}
N 250 53340 280 53340 {
lab=GND}
N 280 53330 280 53340 {
lab=GND}
N 240 53290 280 53290 {
lab=word888}
N 280 53290 320 53290 {
lab=word888}
N 250 53280 250 53330 {
lab=GND}
N 250 53330 250 53340 {
lab=GND}
N 310 53280 310 53330 {
lab=Y3}
N 310 53330 310 53340 {
lab=Y3}
N 330 53340 360 53340 {
lab=GND}
N 360 53330 360 53340 {
lab=GND}
N 320 53290 360 53290 {
lab=word888}
N 360 53290 400 53290 {
lab=word888}
N 330 53280 330 53330 {
lab=GND}
N 330 53330 330 53340 {
lab=GND}
N 390 53280 390 53330 {
lab=Y4}
N 390 53330 390 53340 {
lab=Y4}
N 410 53340 440 53340 {
lab=GND}
N 440 53330 440 53340 {
lab=GND}
N 400 53290 440 53290 {
lab=word888}
N 440 53290 480 53290 {
lab=word888}
N 410 53280 410 53330 {
lab=GND}
N 410 53330 410 53340 {
lab=GND}
N 470 53280 470 53330 {
lab=Y5}
N 470 53330 470 53340 {
lab=Y5}
N 480 53290 520 53290 {
lab=word888}
N 520 53290 560 53290 {
lab=word888}
N 490 53280 490 53330 {
lab=GND}
N 490 53330 490 53340 {
lab=GND}
N 550 53280 550 53330 {
lab=Y6}
N 550 53330 550 53340 {
lab=Y6}
N 570 53340 600 53340 {
lab=GND}
N 600 53330 600 53340 {
lab=GND}
N 560 53290 600 53290 {
lab=word888}
N 600 53290 640 53290 {
lab=word888}
N 570 53280 570 53330 {
lab=GND}
N 570 53330 570 53340 {
lab=GND}
N 630 53280 630 53330 {
lab=Y7}
N 630 53330 630 53340 {
lab=Y7}
N 10 53400 40 53400 {
lab=GND}
N 40 53390 40 53400 {
lab=GND}
N 0 53350 40 53350 {
lab=word889}
N 40 53350 80 53350 {
lab=word889}
N 10 53340 10 53390 {
lab=GND}
N 10 53390 10 53400 {
lab=GND}
N 70 53340 70 53390 {
lab=Y0}
N 70 53390 70 53400 {
lab=Y0}
N 90 53400 120 53400 {
lab=GND}
N 120 53390 120 53400 {
lab=GND}
N 80 53350 120 53350 {
lab=word889}
N 120 53350 160 53350 {
lab=word889}
N 90 53340 90 53390 {
lab=GND}
N 90 53390 90 53400 {
lab=GND}
N 150 53340 150 53390 {
lab=Y1}
N 150 53390 150 53400 {
lab=Y1}
N 170 53400 200 53400 {
lab=GND}
N 200 53390 200 53400 {
lab=GND}
N 160 53350 200 53350 {
lab=word889}
N 200 53350 240 53350 {
lab=word889}
N 170 53340 170 53390 {
lab=GND}
N 170 53390 170 53400 {
lab=GND}
N 230 53340 230 53390 {
lab=Y2}
N 230 53390 230 53400 {
lab=Y2}
N 250 53400 280 53400 {
lab=GND}
N 280 53390 280 53400 {
lab=GND}
N 240 53350 280 53350 {
lab=word889}
N 280 53350 320 53350 {
lab=word889}
N 250 53340 250 53390 {
lab=GND}
N 250 53390 250 53400 {
lab=GND}
N 310 53340 310 53390 {
lab=Y3}
N 310 53390 310 53400 {
lab=Y3}
N 330 53400 360 53400 {
lab=GND}
N 360 53390 360 53400 {
lab=GND}
N 320 53350 360 53350 {
lab=word889}
N 360 53350 400 53350 {
lab=word889}
N 330 53340 330 53390 {
lab=GND}
N 330 53390 330 53400 {
lab=GND}
N 390 53340 390 53390 {
lab=Y4}
N 390 53390 390 53400 {
lab=Y4}
N 410 53400 440 53400 {
lab=GND}
N 440 53390 440 53400 {
lab=GND}
N 400 53350 440 53350 {
lab=word889}
N 440 53350 480 53350 {
lab=word889}
N 410 53340 410 53390 {
lab=GND}
N 410 53390 410 53400 {
lab=GND}
N 470 53340 470 53390 {
lab=Y5}
N 470 53390 470 53400 {
lab=Y5}
N 480 53350 520 53350 {
lab=word889}
N 520 53350 560 53350 {
lab=word889}
N 490 53340 490 53390 {
lab=GND}
N 490 53390 490 53400 {
lab=GND}
N 550 53340 550 53390 {
lab=Y6}
N 550 53390 550 53400 {
lab=Y6}
N 570 53400 600 53400 {
lab=GND}
N 600 53390 600 53400 {
lab=GND}
N 560 53350 600 53350 {
lab=word889}
N 600 53350 640 53350 {
lab=word889}
N 570 53340 570 53390 {
lab=GND}
N 570 53390 570 53400 {
lab=GND}
N 630 53340 630 53390 {
lab=Y7}
N 630 53390 630 53400 {
lab=Y7}
N 10 53460 40 53460 {
lab=GND}
N 40 53450 40 53460 {
lab=GND}
N 0 53410 40 53410 {
lab=word890}
N 40 53410 80 53410 {
lab=word890}
N 10 53400 10 53450 {
lab=GND}
N 10 53450 10 53460 {
lab=GND}
N 70 53400 70 53450 {
lab=Y0}
N 70 53450 70 53460 {
lab=Y0}
N 90 53460 120 53460 {
lab=GND}
N 120 53450 120 53460 {
lab=GND}
N 80 53410 120 53410 {
lab=word890}
N 120 53410 160 53410 {
lab=word890}
N 90 53400 90 53450 {
lab=GND}
N 90 53450 90 53460 {
lab=GND}
N 150 53400 150 53450 {
lab=Y1}
N 150 53450 150 53460 {
lab=Y1}
N 170 53460 200 53460 {
lab=GND}
N 200 53450 200 53460 {
lab=GND}
N 160 53410 200 53410 {
lab=word890}
N 200 53410 240 53410 {
lab=word890}
N 170 53400 170 53450 {
lab=GND}
N 170 53450 170 53460 {
lab=GND}
N 230 53400 230 53450 {
lab=Y2}
N 230 53450 230 53460 {
lab=Y2}
N 250 53460 280 53460 {
lab=GND}
N 280 53450 280 53460 {
lab=GND}
N 240 53410 280 53410 {
lab=word890}
N 280 53410 320 53410 {
lab=word890}
N 250 53400 250 53450 {
lab=GND}
N 250 53450 250 53460 {
lab=GND}
N 310 53400 310 53450 {
lab=Y3}
N 310 53450 310 53460 {
lab=Y3}
N 330 53460 360 53460 {
lab=GND}
N 360 53450 360 53460 {
lab=GND}
N 320 53410 360 53410 {
lab=word890}
N 360 53410 400 53410 {
lab=word890}
N 330 53400 330 53450 {
lab=GND}
N 330 53450 330 53460 {
lab=GND}
N 390 53400 390 53450 {
lab=Y4}
N 390 53450 390 53460 {
lab=Y4}
N 410 53460 440 53460 {
lab=GND}
N 440 53450 440 53460 {
lab=GND}
N 400 53410 440 53410 {
lab=word890}
N 440 53410 480 53410 {
lab=word890}
N 410 53400 410 53450 {
lab=GND}
N 410 53450 410 53460 {
lab=GND}
N 470 53400 470 53450 {
lab=Y5}
N 470 53450 470 53460 {
lab=Y5}
N 490 53460 520 53460 {
lab=GND}
N 520 53450 520 53460 {
lab=GND}
N 480 53410 520 53410 {
lab=word890}
N 520 53410 560 53410 {
lab=word890}
N 490 53400 490 53450 {
lab=GND}
N 490 53450 490 53460 {
lab=GND}
N 550 53400 550 53450 {
lab=Y6}
N 550 53450 550 53460 {
lab=Y6}
N 560 53410 600 53410 {
lab=word890}
N 600 53410 640 53410 {
lab=word890}
N 570 53400 570 53450 {
lab=GND}
N 570 53450 570 53460 {
lab=GND}
N 630 53400 630 53450 {
lab=Y7}
N 630 53450 630 53460 {
lab=Y7}
N 10 53520 40 53520 {
lab=GND}
N 40 53510 40 53520 {
lab=GND}
N 0 53470 40 53470 {
lab=word891}
N 40 53470 80 53470 {
lab=word891}
N 10 53460 10 53510 {
lab=GND}
N 10 53510 10 53520 {
lab=GND}
N 70 53460 70 53510 {
lab=Y0}
N 70 53510 70 53520 {
lab=Y0}
N 90 53520 120 53520 {
lab=GND}
N 120 53510 120 53520 {
lab=GND}
N 80 53470 120 53470 {
lab=word891}
N 120 53470 160 53470 {
lab=word891}
N 90 53460 90 53510 {
lab=GND}
N 90 53510 90 53520 {
lab=GND}
N 150 53460 150 53510 {
lab=Y1}
N 150 53510 150 53520 {
lab=Y1}
N 170 53520 200 53520 {
lab=GND}
N 200 53510 200 53520 {
lab=GND}
N 160 53470 200 53470 {
lab=word891}
N 200 53470 240 53470 {
lab=word891}
N 170 53460 170 53510 {
lab=GND}
N 170 53510 170 53520 {
lab=GND}
N 230 53460 230 53510 {
lab=Y2}
N 230 53510 230 53520 {
lab=Y2}
N 250 53520 280 53520 {
lab=GND}
N 280 53510 280 53520 {
lab=GND}
N 240 53470 280 53470 {
lab=word891}
N 280 53470 320 53470 {
lab=word891}
N 250 53460 250 53510 {
lab=GND}
N 250 53510 250 53520 {
lab=GND}
N 310 53460 310 53510 {
lab=Y3}
N 310 53510 310 53520 {
lab=Y3}
N 330 53520 360 53520 {
lab=GND}
N 360 53510 360 53520 {
lab=GND}
N 320 53470 360 53470 {
lab=word891}
N 360 53470 400 53470 {
lab=word891}
N 330 53460 330 53510 {
lab=GND}
N 330 53510 330 53520 {
lab=GND}
N 390 53460 390 53510 {
lab=Y4}
N 390 53510 390 53520 {
lab=Y4}
N 410 53520 440 53520 {
lab=GND}
N 440 53510 440 53520 {
lab=GND}
N 400 53470 440 53470 {
lab=word891}
N 440 53470 480 53470 {
lab=word891}
N 410 53460 410 53510 {
lab=GND}
N 410 53510 410 53520 {
lab=GND}
N 470 53460 470 53510 {
lab=Y5}
N 470 53510 470 53520 {
lab=Y5}
N 490 53520 520 53520 {
lab=GND}
N 520 53510 520 53520 {
lab=GND}
N 480 53470 520 53470 {
lab=word891}
N 520 53470 560 53470 {
lab=word891}
N 490 53460 490 53510 {
lab=GND}
N 490 53510 490 53520 {
lab=GND}
N 550 53460 550 53510 {
lab=Y6}
N 550 53510 550 53520 {
lab=Y6}
N 560 53470 600 53470 {
lab=word891}
N 600 53470 640 53470 {
lab=word891}
N 570 53460 570 53510 {
lab=GND}
N 570 53510 570 53520 {
lab=GND}
N 630 53460 630 53510 {
lab=Y7}
N 630 53510 630 53520 {
lab=Y7}
N 10 53580 40 53580 {
lab=GND}
N 40 53570 40 53580 {
lab=GND}
N 0 53530 40 53530 {
lab=word892}
N 40 53530 80 53530 {
lab=word892}
N 10 53520 10 53570 {
lab=GND}
N 10 53570 10 53580 {
lab=GND}
N 70 53520 70 53570 {
lab=Y0}
N 70 53570 70 53580 {
lab=Y0}
N 90 53580 120 53580 {
lab=GND}
N 120 53570 120 53580 {
lab=GND}
N 80 53530 120 53530 {
lab=word892}
N 120 53530 160 53530 {
lab=word892}
N 90 53520 90 53570 {
lab=GND}
N 90 53570 90 53580 {
lab=GND}
N 150 53520 150 53570 {
lab=Y1}
N 150 53570 150 53580 {
lab=Y1}
N 170 53580 200 53580 {
lab=GND}
N 200 53570 200 53580 {
lab=GND}
N 160 53530 200 53530 {
lab=word892}
N 200 53530 240 53530 {
lab=word892}
N 170 53520 170 53570 {
lab=GND}
N 170 53570 170 53580 {
lab=GND}
N 230 53520 230 53570 {
lab=Y2}
N 230 53570 230 53580 {
lab=Y2}
N 250 53580 280 53580 {
lab=GND}
N 280 53570 280 53580 {
lab=GND}
N 240 53530 280 53530 {
lab=word892}
N 280 53530 320 53530 {
lab=word892}
N 250 53520 250 53570 {
lab=GND}
N 250 53570 250 53580 {
lab=GND}
N 310 53520 310 53570 {
lab=Y3}
N 310 53570 310 53580 {
lab=Y3}
N 330 53580 360 53580 {
lab=GND}
N 360 53570 360 53580 {
lab=GND}
N 320 53530 360 53530 {
lab=word892}
N 360 53530 400 53530 {
lab=word892}
N 330 53520 330 53570 {
lab=GND}
N 330 53570 330 53580 {
lab=GND}
N 390 53520 390 53570 {
lab=Y4}
N 390 53570 390 53580 {
lab=Y4}
N 410 53580 440 53580 {
lab=GND}
N 440 53570 440 53580 {
lab=GND}
N 400 53530 440 53530 {
lab=word892}
N 440 53530 480 53530 {
lab=word892}
N 410 53520 410 53570 {
lab=GND}
N 410 53570 410 53580 {
lab=GND}
N 470 53520 470 53570 {
lab=Y5}
N 470 53570 470 53580 {
lab=Y5}
N 490 53580 520 53580 {
lab=GND}
N 520 53570 520 53580 {
lab=GND}
N 480 53530 520 53530 {
lab=word892}
N 520 53530 560 53530 {
lab=word892}
N 490 53520 490 53570 {
lab=GND}
N 490 53570 490 53580 {
lab=GND}
N 550 53520 550 53570 {
lab=Y6}
N 550 53570 550 53580 {
lab=Y6}
N 560 53530 600 53530 {
lab=word892}
N 600 53530 640 53530 {
lab=word892}
N 570 53520 570 53570 {
lab=GND}
N 570 53570 570 53580 {
lab=GND}
N 630 53520 630 53570 {
lab=Y7}
N 630 53570 630 53580 {
lab=Y7}
N 10 53640 40 53640 {
lab=GND}
N 40 53630 40 53640 {
lab=GND}
N 0 53590 40 53590 {
lab=word893}
N 40 53590 80 53590 {
lab=word893}
N 10 53580 10 53630 {
lab=GND}
N 10 53630 10 53640 {
lab=GND}
N 70 53580 70 53630 {
lab=Y0}
N 70 53630 70 53640 {
lab=Y0}
N 90 53640 120 53640 {
lab=GND}
N 120 53630 120 53640 {
lab=GND}
N 80 53590 120 53590 {
lab=word893}
N 120 53590 160 53590 {
lab=word893}
N 90 53580 90 53630 {
lab=GND}
N 90 53630 90 53640 {
lab=GND}
N 150 53580 150 53630 {
lab=Y1}
N 150 53630 150 53640 {
lab=Y1}
N 170 53640 200 53640 {
lab=GND}
N 200 53630 200 53640 {
lab=GND}
N 160 53590 200 53590 {
lab=word893}
N 200 53590 240 53590 {
lab=word893}
N 170 53580 170 53630 {
lab=GND}
N 170 53630 170 53640 {
lab=GND}
N 230 53580 230 53630 {
lab=Y2}
N 230 53630 230 53640 {
lab=Y2}
N 250 53640 280 53640 {
lab=GND}
N 280 53630 280 53640 {
lab=GND}
N 240 53590 280 53590 {
lab=word893}
N 280 53590 320 53590 {
lab=word893}
N 250 53580 250 53630 {
lab=GND}
N 250 53630 250 53640 {
lab=GND}
N 310 53580 310 53630 {
lab=Y3}
N 310 53630 310 53640 {
lab=Y3}
N 330 53640 360 53640 {
lab=GND}
N 360 53630 360 53640 {
lab=GND}
N 320 53590 360 53590 {
lab=word893}
N 360 53590 400 53590 {
lab=word893}
N 330 53580 330 53630 {
lab=GND}
N 330 53630 330 53640 {
lab=GND}
N 390 53580 390 53630 {
lab=Y4}
N 390 53630 390 53640 {
lab=Y4}
N 410 53640 440 53640 {
lab=GND}
N 440 53630 440 53640 {
lab=GND}
N 400 53590 440 53590 {
lab=word893}
N 440 53590 480 53590 {
lab=word893}
N 410 53580 410 53630 {
lab=GND}
N 410 53630 410 53640 {
lab=GND}
N 470 53580 470 53630 {
lab=Y5}
N 470 53630 470 53640 {
lab=Y5}
N 490 53640 520 53640 {
lab=GND}
N 520 53630 520 53640 {
lab=GND}
N 480 53590 520 53590 {
lab=word893}
N 520 53590 560 53590 {
lab=word893}
N 490 53580 490 53630 {
lab=GND}
N 490 53630 490 53640 {
lab=GND}
N 550 53580 550 53630 {
lab=Y6}
N 550 53630 550 53640 {
lab=Y6}
N 570 53640 600 53640 {
lab=GND}
N 600 53630 600 53640 {
lab=GND}
N 560 53590 600 53590 {
lab=word893}
N 600 53590 640 53590 {
lab=word893}
N 570 53580 570 53630 {
lab=GND}
N 570 53630 570 53640 {
lab=GND}
N 630 53580 630 53630 {
lab=Y7}
N 630 53630 630 53640 {
lab=Y7}
N 10 53700 40 53700 {
lab=GND}
N 40 53690 40 53700 {
lab=GND}
N 0 53650 40 53650 {
lab=word894}
N 40 53650 80 53650 {
lab=word894}
N 10 53640 10 53690 {
lab=GND}
N 10 53690 10 53700 {
lab=GND}
N 70 53640 70 53690 {
lab=Y0}
N 70 53690 70 53700 {
lab=Y0}
N 90 53700 120 53700 {
lab=GND}
N 120 53690 120 53700 {
lab=GND}
N 80 53650 120 53650 {
lab=word894}
N 120 53650 160 53650 {
lab=word894}
N 90 53640 90 53690 {
lab=GND}
N 90 53690 90 53700 {
lab=GND}
N 150 53640 150 53690 {
lab=Y1}
N 150 53690 150 53700 {
lab=Y1}
N 170 53700 200 53700 {
lab=GND}
N 200 53690 200 53700 {
lab=GND}
N 160 53650 200 53650 {
lab=word894}
N 200 53650 240 53650 {
lab=word894}
N 170 53640 170 53690 {
lab=GND}
N 170 53690 170 53700 {
lab=GND}
N 230 53640 230 53690 {
lab=Y2}
N 230 53690 230 53700 {
lab=Y2}
N 250 53700 280 53700 {
lab=GND}
N 280 53690 280 53700 {
lab=GND}
N 240 53650 280 53650 {
lab=word894}
N 280 53650 320 53650 {
lab=word894}
N 250 53640 250 53690 {
lab=GND}
N 250 53690 250 53700 {
lab=GND}
N 310 53640 310 53690 {
lab=Y3}
N 310 53690 310 53700 {
lab=Y3}
N 330 53700 360 53700 {
lab=GND}
N 360 53690 360 53700 {
lab=GND}
N 320 53650 360 53650 {
lab=word894}
N 360 53650 400 53650 {
lab=word894}
N 330 53640 330 53690 {
lab=GND}
N 330 53690 330 53700 {
lab=GND}
N 390 53640 390 53690 {
lab=Y4}
N 390 53690 390 53700 {
lab=Y4}
N 410 53700 440 53700 {
lab=GND}
N 440 53690 440 53700 {
lab=GND}
N 400 53650 440 53650 {
lab=word894}
N 440 53650 480 53650 {
lab=word894}
N 410 53640 410 53690 {
lab=GND}
N 410 53690 410 53700 {
lab=GND}
N 470 53640 470 53690 {
lab=Y5}
N 470 53690 470 53700 {
lab=Y5}
N 490 53700 520 53700 {
lab=GND}
N 520 53690 520 53700 {
lab=GND}
N 480 53650 520 53650 {
lab=word894}
N 520 53650 560 53650 {
lab=word894}
N 490 53640 490 53690 {
lab=GND}
N 490 53690 490 53700 {
lab=GND}
N 550 53640 550 53690 {
lab=Y6}
N 550 53690 550 53700 {
lab=Y6}
N 570 53700 600 53700 {
lab=GND}
N 600 53690 600 53700 {
lab=GND}
N 560 53650 600 53650 {
lab=word894}
N 600 53650 640 53650 {
lab=word894}
N 570 53640 570 53690 {
lab=GND}
N 570 53690 570 53700 {
lab=GND}
N 630 53640 630 53690 {
lab=Y7}
N 630 53690 630 53700 {
lab=Y7}
N 10 53760 40 53760 {
lab=GND}
N 40 53750 40 53760 {
lab=GND}
N 0 53710 40 53710 {
lab=word895}
N 40 53710 80 53710 {
lab=word895}
N 10 53700 10 53750 {
lab=GND}
N 10 53750 10 53760 {
lab=GND}
N 70 53700 70 53750 {
lab=Y0}
N 70 53750 70 53760 {
lab=Y0}
N 90 53760 120 53760 {
lab=GND}
N 120 53750 120 53760 {
lab=GND}
N 80 53710 120 53710 {
lab=word895}
N 120 53710 160 53710 {
lab=word895}
N 90 53700 90 53750 {
lab=GND}
N 90 53750 90 53760 {
lab=GND}
N 150 53700 150 53750 {
lab=Y1}
N 150 53750 150 53760 {
lab=Y1}
N 170 53760 200 53760 {
lab=GND}
N 200 53750 200 53760 {
lab=GND}
N 160 53710 200 53710 {
lab=word895}
N 200 53710 240 53710 {
lab=word895}
N 170 53700 170 53750 {
lab=GND}
N 170 53750 170 53760 {
lab=GND}
N 230 53700 230 53750 {
lab=Y2}
N 230 53750 230 53760 {
lab=Y2}
N 250 53760 280 53760 {
lab=GND}
N 280 53750 280 53760 {
lab=GND}
N 240 53710 280 53710 {
lab=word895}
N 280 53710 320 53710 {
lab=word895}
N 250 53700 250 53750 {
lab=GND}
N 250 53750 250 53760 {
lab=GND}
N 310 53700 310 53750 {
lab=Y3}
N 310 53750 310 53760 {
lab=Y3}
N 330 53760 360 53760 {
lab=GND}
N 360 53750 360 53760 {
lab=GND}
N 320 53710 360 53710 {
lab=word895}
N 360 53710 400 53710 {
lab=word895}
N 330 53700 330 53750 {
lab=GND}
N 330 53750 330 53760 {
lab=GND}
N 390 53700 390 53750 {
lab=Y4}
N 390 53750 390 53760 {
lab=Y4}
N 410 53760 440 53760 {
lab=GND}
N 440 53750 440 53760 {
lab=GND}
N 400 53710 440 53710 {
lab=word895}
N 440 53710 480 53710 {
lab=word895}
N 410 53700 410 53750 {
lab=GND}
N 410 53750 410 53760 {
lab=GND}
N 470 53700 470 53750 {
lab=Y5}
N 470 53750 470 53760 {
lab=Y5}
N 490 53760 520 53760 {
lab=GND}
N 520 53750 520 53760 {
lab=GND}
N 480 53710 520 53710 {
lab=word895}
N 520 53710 560 53710 {
lab=word895}
N 490 53700 490 53750 {
lab=GND}
N 490 53750 490 53760 {
lab=GND}
N 550 53700 550 53750 {
lab=Y6}
N 550 53750 550 53760 {
lab=Y6}
N 570 53760 600 53760 {
lab=GND}
N 600 53750 600 53760 {
lab=GND}
N 560 53710 600 53710 {
lab=word895}
N 600 53710 640 53710 {
lab=word895}
N 570 53700 570 53750 {
lab=GND}
N 570 53750 570 53760 {
lab=GND}
N 630 53700 630 53750 {
lab=Y7}
N 630 53750 630 53760 {
lab=Y7}
N 10 53820 40 53820 {
lab=GND}
N 40 53810 40 53820 {
lab=GND}
N 0 53770 40 53770 {
lab=word896}
N 40 53770 80 53770 {
lab=word896}
N 10 53760 10 53810 {
lab=GND}
N 10 53810 10 53820 {
lab=GND}
N 70 53760 70 53810 {
lab=Y0}
N 70 53810 70 53820 {
lab=Y0}
N 90 53820 120 53820 {
lab=GND}
N 120 53810 120 53820 {
lab=GND}
N 80 53770 120 53770 {
lab=word896}
N 120 53770 160 53770 {
lab=word896}
N 90 53760 90 53810 {
lab=GND}
N 90 53810 90 53820 {
lab=GND}
N 150 53760 150 53810 {
lab=Y1}
N 150 53810 150 53820 {
lab=Y1}
N 170 53820 200 53820 {
lab=GND}
N 200 53810 200 53820 {
lab=GND}
N 160 53770 200 53770 {
lab=word896}
N 200 53770 240 53770 {
lab=word896}
N 170 53760 170 53810 {
lab=GND}
N 170 53810 170 53820 {
lab=GND}
N 230 53760 230 53810 {
lab=Y2}
N 230 53810 230 53820 {
lab=Y2}
N 250 53820 280 53820 {
lab=GND}
N 280 53810 280 53820 {
lab=GND}
N 240 53770 280 53770 {
lab=word896}
N 280 53770 320 53770 {
lab=word896}
N 250 53760 250 53810 {
lab=GND}
N 250 53810 250 53820 {
lab=GND}
N 310 53760 310 53810 {
lab=Y3}
N 310 53810 310 53820 {
lab=Y3}
N 330 53820 360 53820 {
lab=GND}
N 360 53810 360 53820 {
lab=GND}
N 320 53770 360 53770 {
lab=word896}
N 360 53770 400 53770 {
lab=word896}
N 330 53760 330 53810 {
lab=GND}
N 330 53810 330 53820 {
lab=GND}
N 390 53760 390 53810 {
lab=Y4}
N 390 53810 390 53820 {
lab=Y4}
N 410 53820 440 53820 {
lab=GND}
N 440 53810 440 53820 {
lab=GND}
N 400 53770 440 53770 {
lab=word896}
N 440 53770 480 53770 {
lab=word896}
N 410 53760 410 53810 {
lab=GND}
N 410 53810 410 53820 {
lab=GND}
N 470 53760 470 53810 {
lab=Y5}
N 470 53810 470 53820 {
lab=Y5}
N 490 53820 520 53820 {
lab=GND}
N 520 53810 520 53820 {
lab=GND}
N 480 53770 520 53770 {
lab=word896}
N 520 53770 560 53770 {
lab=word896}
N 490 53760 490 53810 {
lab=GND}
N 490 53810 490 53820 {
lab=GND}
N 550 53760 550 53810 {
lab=Y6}
N 550 53810 550 53820 {
lab=Y6}
N 570 53820 600 53820 {
lab=GND}
N 600 53810 600 53820 {
lab=GND}
N 560 53770 600 53770 {
lab=word896}
N 600 53770 640 53770 {
lab=word896}
N 570 53760 570 53810 {
lab=GND}
N 570 53810 570 53820 {
lab=GND}
N 630 53760 630 53810 {
lab=Y7}
N 630 53810 630 53820 {
lab=Y7}
N 10 53880 40 53880 {
lab=GND}
N 40 53870 40 53880 {
lab=GND}
N 0 53830 40 53830 {
lab=word897}
N 40 53830 80 53830 {
lab=word897}
N 10 53820 10 53870 {
lab=GND}
N 10 53870 10 53880 {
lab=GND}
N 70 53820 70 53870 {
lab=Y0}
N 70 53870 70 53880 {
lab=Y0}
N 90 53880 120 53880 {
lab=GND}
N 120 53870 120 53880 {
lab=GND}
N 80 53830 120 53830 {
lab=word897}
N 120 53830 160 53830 {
lab=word897}
N 90 53820 90 53870 {
lab=GND}
N 90 53870 90 53880 {
lab=GND}
N 150 53820 150 53870 {
lab=Y1}
N 150 53870 150 53880 {
lab=Y1}
N 170 53880 200 53880 {
lab=GND}
N 200 53870 200 53880 {
lab=GND}
N 160 53830 200 53830 {
lab=word897}
N 200 53830 240 53830 {
lab=word897}
N 170 53820 170 53870 {
lab=GND}
N 170 53870 170 53880 {
lab=GND}
N 230 53820 230 53870 {
lab=Y2}
N 230 53870 230 53880 {
lab=Y2}
N 250 53880 280 53880 {
lab=GND}
N 280 53870 280 53880 {
lab=GND}
N 240 53830 280 53830 {
lab=word897}
N 280 53830 320 53830 {
lab=word897}
N 250 53820 250 53870 {
lab=GND}
N 250 53870 250 53880 {
lab=GND}
N 310 53820 310 53870 {
lab=Y3}
N 310 53870 310 53880 {
lab=Y3}
N 330 53880 360 53880 {
lab=GND}
N 360 53870 360 53880 {
lab=GND}
N 320 53830 360 53830 {
lab=word897}
N 360 53830 400 53830 {
lab=word897}
N 330 53820 330 53870 {
lab=GND}
N 330 53870 330 53880 {
lab=GND}
N 390 53820 390 53870 {
lab=Y4}
N 390 53870 390 53880 {
lab=Y4}
N 410 53880 440 53880 {
lab=GND}
N 440 53870 440 53880 {
lab=GND}
N 400 53830 440 53830 {
lab=word897}
N 440 53830 480 53830 {
lab=word897}
N 410 53820 410 53870 {
lab=GND}
N 410 53870 410 53880 {
lab=GND}
N 470 53820 470 53870 {
lab=Y5}
N 470 53870 470 53880 {
lab=Y5}
N 490 53880 520 53880 {
lab=GND}
N 520 53870 520 53880 {
lab=GND}
N 480 53830 520 53830 {
lab=word897}
N 520 53830 560 53830 {
lab=word897}
N 490 53820 490 53870 {
lab=GND}
N 490 53870 490 53880 {
lab=GND}
N 550 53820 550 53870 {
lab=Y6}
N 550 53870 550 53880 {
lab=Y6}
N 570 53880 600 53880 {
lab=GND}
N 600 53870 600 53880 {
lab=GND}
N 560 53830 600 53830 {
lab=word897}
N 600 53830 640 53830 {
lab=word897}
N 570 53820 570 53870 {
lab=GND}
N 570 53870 570 53880 {
lab=GND}
N 630 53820 630 53870 {
lab=Y7}
N 630 53870 630 53880 {
lab=Y7}
N 10 53940 40 53940 {
lab=GND}
N 40 53930 40 53940 {
lab=GND}
N 0 53890 40 53890 {
lab=word898}
N 40 53890 80 53890 {
lab=word898}
N 10 53880 10 53930 {
lab=GND}
N 10 53930 10 53940 {
lab=GND}
N 70 53880 70 53930 {
lab=Y0}
N 70 53930 70 53940 {
lab=Y0}
N 90 53940 120 53940 {
lab=GND}
N 120 53930 120 53940 {
lab=GND}
N 80 53890 120 53890 {
lab=word898}
N 120 53890 160 53890 {
lab=word898}
N 90 53880 90 53930 {
lab=GND}
N 90 53930 90 53940 {
lab=GND}
N 150 53880 150 53930 {
lab=Y1}
N 150 53930 150 53940 {
lab=Y1}
N 170 53940 200 53940 {
lab=GND}
N 200 53930 200 53940 {
lab=GND}
N 160 53890 200 53890 {
lab=word898}
N 200 53890 240 53890 {
lab=word898}
N 170 53880 170 53930 {
lab=GND}
N 170 53930 170 53940 {
lab=GND}
N 230 53880 230 53930 {
lab=Y2}
N 230 53930 230 53940 {
lab=Y2}
N 250 53940 280 53940 {
lab=GND}
N 280 53930 280 53940 {
lab=GND}
N 240 53890 280 53890 {
lab=word898}
N 280 53890 320 53890 {
lab=word898}
N 250 53880 250 53930 {
lab=GND}
N 250 53930 250 53940 {
lab=GND}
N 310 53880 310 53930 {
lab=Y3}
N 310 53930 310 53940 {
lab=Y3}
N 330 53940 360 53940 {
lab=GND}
N 360 53930 360 53940 {
lab=GND}
N 320 53890 360 53890 {
lab=word898}
N 360 53890 400 53890 {
lab=word898}
N 330 53880 330 53930 {
lab=GND}
N 330 53930 330 53940 {
lab=GND}
N 390 53880 390 53930 {
lab=Y4}
N 390 53930 390 53940 {
lab=Y4}
N 410 53940 440 53940 {
lab=GND}
N 440 53930 440 53940 {
lab=GND}
N 400 53890 440 53890 {
lab=word898}
N 440 53890 480 53890 {
lab=word898}
N 410 53880 410 53930 {
lab=GND}
N 410 53930 410 53940 {
lab=GND}
N 470 53880 470 53930 {
lab=Y5}
N 470 53930 470 53940 {
lab=Y5}
N 490 53940 520 53940 {
lab=GND}
N 520 53930 520 53940 {
lab=GND}
N 480 53890 520 53890 {
lab=word898}
N 520 53890 560 53890 {
lab=word898}
N 490 53880 490 53930 {
lab=GND}
N 490 53930 490 53940 {
lab=GND}
N 550 53880 550 53930 {
lab=Y6}
N 550 53930 550 53940 {
lab=Y6}
N 570 53940 600 53940 {
lab=GND}
N 600 53930 600 53940 {
lab=GND}
N 560 53890 600 53890 {
lab=word898}
N 600 53890 640 53890 {
lab=word898}
N 570 53880 570 53930 {
lab=GND}
N 570 53930 570 53940 {
lab=GND}
N 630 53880 630 53930 {
lab=Y7}
N 630 53930 630 53940 {
lab=Y7}
N 10 54000 40 54000 {
lab=GND}
N 40 53990 40 54000 {
lab=GND}
N 0 53950 40 53950 {
lab=word899}
N 40 53950 80 53950 {
lab=word899}
N 10 53940 10 53990 {
lab=GND}
N 10 53990 10 54000 {
lab=GND}
N 70 53940 70 53990 {
lab=Y0}
N 70 53990 70 54000 {
lab=Y0}
N 90 54000 120 54000 {
lab=GND}
N 120 53990 120 54000 {
lab=GND}
N 80 53950 120 53950 {
lab=word899}
N 120 53950 160 53950 {
lab=word899}
N 90 53940 90 53990 {
lab=GND}
N 90 53990 90 54000 {
lab=GND}
N 150 53940 150 53990 {
lab=Y1}
N 150 53990 150 54000 {
lab=Y1}
N 170 54000 200 54000 {
lab=GND}
N 200 53990 200 54000 {
lab=GND}
N 160 53950 200 53950 {
lab=word899}
N 200 53950 240 53950 {
lab=word899}
N 170 53940 170 53990 {
lab=GND}
N 170 53990 170 54000 {
lab=GND}
N 230 53940 230 53990 {
lab=Y2}
N 230 53990 230 54000 {
lab=Y2}
N 250 54000 280 54000 {
lab=GND}
N 280 53990 280 54000 {
lab=GND}
N 240 53950 280 53950 {
lab=word899}
N 280 53950 320 53950 {
lab=word899}
N 250 53940 250 53990 {
lab=GND}
N 250 53990 250 54000 {
lab=GND}
N 310 53940 310 53990 {
lab=Y3}
N 310 53990 310 54000 {
lab=Y3}
N 330 54000 360 54000 {
lab=GND}
N 360 53990 360 54000 {
lab=GND}
N 320 53950 360 53950 {
lab=word899}
N 360 53950 400 53950 {
lab=word899}
N 330 53940 330 53990 {
lab=GND}
N 330 53990 330 54000 {
lab=GND}
N 390 53940 390 53990 {
lab=Y4}
N 390 53990 390 54000 {
lab=Y4}
N 410 54000 440 54000 {
lab=GND}
N 440 53990 440 54000 {
lab=GND}
N 400 53950 440 53950 {
lab=word899}
N 440 53950 480 53950 {
lab=word899}
N 410 53940 410 53990 {
lab=GND}
N 410 53990 410 54000 {
lab=GND}
N 470 53940 470 53990 {
lab=Y5}
N 470 53990 470 54000 {
lab=Y5}
N 490 54000 520 54000 {
lab=GND}
N 520 53990 520 54000 {
lab=GND}
N 480 53950 520 53950 {
lab=word899}
N 520 53950 560 53950 {
lab=word899}
N 490 53940 490 53990 {
lab=GND}
N 490 53990 490 54000 {
lab=GND}
N 550 53940 550 53990 {
lab=Y6}
N 550 53990 550 54000 {
lab=Y6}
N 570 54000 600 54000 {
lab=GND}
N 600 53990 600 54000 {
lab=GND}
N 560 53950 600 53950 {
lab=word899}
N 600 53950 640 53950 {
lab=word899}
N 570 53940 570 53990 {
lab=GND}
N 570 53990 570 54000 {
lab=GND}
N 630 53940 630 53990 {
lab=Y7}
N 630 53990 630 54000 {
lab=Y7}
N 10 54060 40 54060 {
lab=GND}
N 40 54050 40 54060 {
lab=GND}
N 0 54010 40 54010 {
lab=word900}
N 40 54010 80 54010 {
lab=word900}
N 10 54000 10 54050 {
lab=GND}
N 10 54050 10 54060 {
lab=GND}
N 70 54000 70 54050 {
lab=Y0}
N 70 54050 70 54060 {
lab=Y0}
N 90 54060 120 54060 {
lab=GND}
N 120 54050 120 54060 {
lab=GND}
N 80 54010 120 54010 {
lab=word900}
N 120 54010 160 54010 {
lab=word900}
N 90 54000 90 54050 {
lab=GND}
N 90 54050 90 54060 {
lab=GND}
N 150 54000 150 54050 {
lab=Y1}
N 150 54050 150 54060 {
lab=Y1}
N 170 54060 200 54060 {
lab=GND}
N 200 54050 200 54060 {
lab=GND}
N 160 54010 200 54010 {
lab=word900}
N 200 54010 240 54010 {
lab=word900}
N 170 54000 170 54050 {
lab=GND}
N 170 54050 170 54060 {
lab=GND}
N 230 54000 230 54050 {
lab=Y2}
N 230 54050 230 54060 {
lab=Y2}
N 250 54060 280 54060 {
lab=GND}
N 280 54050 280 54060 {
lab=GND}
N 240 54010 280 54010 {
lab=word900}
N 280 54010 320 54010 {
lab=word900}
N 250 54000 250 54050 {
lab=GND}
N 250 54050 250 54060 {
lab=GND}
N 310 54000 310 54050 {
lab=Y3}
N 310 54050 310 54060 {
lab=Y3}
N 330 54060 360 54060 {
lab=GND}
N 360 54050 360 54060 {
lab=GND}
N 320 54010 360 54010 {
lab=word900}
N 360 54010 400 54010 {
lab=word900}
N 330 54000 330 54050 {
lab=GND}
N 330 54050 330 54060 {
lab=GND}
N 390 54000 390 54050 {
lab=Y4}
N 390 54050 390 54060 {
lab=Y4}
N 410 54060 440 54060 {
lab=GND}
N 440 54050 440 54060 {
lab=GND}
N 400 54010 440 54010 {
lab=word900}
N 440 54010 480 54010 {
lab=word900}
N 410 54000 410 54050 {
lab=GND}
N 410 54050 410 54060 {
lab=GND}
N 470 54000 470 54050 {
lab=Y5}
N 470 54050 470 54060 {
lab=Y5}
N 490 54060 520 54060 {
lab=GND}
N 520 54050 520 54060 {
lab=GND}
N 480 54010 520 54010 {
lab=word900}
N 520 54010 560 54010 {
lab=word900}
N 490 54000 490 54050 {
lab=GND}
N 490 54050 490 54060 {
lab=GND}
N 550 54000 550 54050 {
lab=Y6}
N 550 54050 550 54060 {
lab=Y6}
N 560 54010 600 54010 {
lab=word900}
N 600 54010 640 54010 {
lab=word900}
N 570 54000 570 54050 {
lab=GND}
N 570 54050 570 54060 {
lab=GND}
N 630 54000 630 54050 {
lab=Y7}
N 630 54050 630 54060 {
lab=Y7}
N 10 54120 40 54120 {
lab=GND}
N 40 54110 40 54120 {
lab=GND}
N 0 54070 40 54070 {
lab=word901}
N 40 54070 80 54070 {
lab=word901}
N 10 54060 10 54110 {
lab=GND}
N 10 54110 10 54120 {
lab=GND}
N 70 54060 70 54110 {
lab=Y0}
N 70 54110 70 54120 {
lab=Y0}
N 90 54120 120 54120 {
lab=GND}
N 120 54110 120 54120 {
lab=GND}
N 80 54070 120 54070 {
lab=word901}
N 120 54070 160 54070 {
lab=word901}
N 90 54060 90 54110 {
lab=GND}
N 90 54110 90 54120 {
lab=GND}
N 150 54060 150 54110 {
lab=Y1}
N 150 54110 150 54120 {
lab=Y1}
N 170 54120 200 54120 {
lab=GND}
N 200 54110 200 54120 {
lab=GND}
N 160 54070 200 54070 {
lab=word901}
N 200 54070 240 54070 {
lab=word901}
N 170 54060 170 54110 {
lab=GND}
N 170 54110 170 54120 {
lab=GND}
N 230 54060 230 54110 {
lab=Y2}
N 230 54110 230 54120 {
lab=Y2}
N 250 54120 280 54120 {
lab=GND}
N 280 54110 280 54120 {
lab=GND}
N 240 54070 280 54070 {
lab=word901}
N 280 54070 320 54070 {
lab=word901}
N 250 54060 250 54110 {
lab=GND}
N 250 54110 250 54120 {
lab=GND}
N 310 54060 310 54110 {
lab=Y3}
N 310 54110 310 54120 {
lab=Y3}
N 330 54120 360 54120 {
lab=GND}
N 360 54110 360 54120 {
lab=GND}
N 320 54070 360 54070 {
lab=word901}
N 360 54070 400 54070 {
lab=word901}
N 330 54060 330 54110 {
lab=GND}
N 330 54110 330 54120 {
lab=GND}
N 390 54060 390 54110 {
lab=Y4}
N 390 54110 390 54120 {
lab=Y4}
N 410 54120 440 54120 {
lab=GND}
N 440 54110 440 54120 {
lab=GND}
N 400 54070 440 54070 {
lab=word901}
N 440 54070 480 54070 {
lab=word901}
N 410 54060 410 54110 {
lab=GND}
N 410 54110 410 54120 {
lab=GND}
N 470 54060 470 54110 {
lab=Y5}
N 470 54110 470 54120 {
lab=Y5}
N 490 54120 520 54120 {
lab=GND}
N 520 54110 520 54120 {
lab=GND}
N 480 54070 520 54070 {
lab=word901}
N 520 54070 560 54070 {
lab=word901}
N 490 54060 490 54110 {
lab=GND}
N 490 54110 490 54120 {
lab=GND}
N 550 54060 550 54110 {
lab=Y6}
N 550 54110 550 54120 {
lab=Y6}
N 560 54070 600 54070 {
lab=word901}
N 600 54070 640 54070 {
lab=word901}
N 570 54060 570 54110 {
lab=GND}
N 570 54110 570 54120 {
lab=GND}
N 630 54060 630 54110 {
lab=Y7}
N 630 54110 630 54120 {
lab=Y7}
N 10 54180 40 54180 {
lab=GND}
N 40 54170 40 54180 {
lab=GND}
N 0 54130 40 54130 {
lab=word902}
N 40 54130 80 54130 {
lab=word902}
N 10 54120 10 54170 {
lab=GND}
N 10 54170 10 54180 {
lab=GND}
N 70 54120 70 54170 {
lab=Y0}
N 70 54170 70 54180 {
lab=Y0}
N 90 54180 120 54180 {
lab=GND}
N 120 54170 120 54180 {
lab=GND}
N 80 54130 120 54130 {
lab=word902}
N 120 54130 160 54130 {
lab=word902}
N 90 54120 90 54170 {
lab=GND}
N 90 54170 90 54180 {
lab=GND}
N 150 54120 150 54170 {
lab=Y1}
N 150 54170 150 54180 {
lab=Y1}
N 170 54180 200 54180 {
lab=GND}
N 200 54170 200 54180 {
lab=GND}
N 160 54130 200 54130 {
lab=word902}
N 200 54130 240 54130 {
lab=word902}
N 170 54120 170 54170 {
lab=GND}
N 170 54170 170 54180 {
lab=GND}
N 230 54120 230 54170 {
lab=Y2}
N 230 54170 230 54180 {
lab=Y2}
N 250 54180 280 54180 {
lab=GND}
N 280 54170 280 54180 {
lab=GND}
N 240 54130 280 54130 {
lab=word902}
N 280 54130 320 54130 {
lab=word902}
N 250 54120 250 54170 {
lab=GND}
N 250 54170 250 54180 {
lab=GND}
N 310 54120 310 54170 {
lab=Y3}
N 310 54170 310 54180 {
lab=Y3}
N 330 54180 360 54180 {
lab=GND}
N 360 54170 360 54180 {
lab=GND}
N 320 54130 360 54130 {
lab=word902}
N 360 54130 400 54130 {
lab=word902}
N 330 54120 330 54170 {
lab=GND}
N 330 54170 330 54180 {
lab=GND}
N 390 54120 390 54170 {
lab=Y4}
N 390 54170 390 54180 {
lab=Y4}
N 410 54180 440 54180 {
lab=GND}
N 440 54170 440 54180 {
lab=GND}
N 400 54130 440 54130 {
lab=word902}
N 440 54130 480 54130 {
lab=word902}
N 410 54120 410 54170 {
lab=GND}
N 410 54170 410 54180 {
lab=GND}
N 470 54120 470 54170 {
lab=Y5}
N 470 54170 470 54180 {
lab=Y5}
N 490 54180 520 54180 {
lab=GND}
N 520 54170 520 54180 {
lab=GND}
N 480 54130 520 54130 {
lab=word902}
N 520 54130 560 54130 {
lab=word902}
N 490 54120 490 54170 {
lab=GND}
N 490 54170 490 54180 {
lab=GND}
N 550 54120 550 54170 {
lab=Y6}
N 550 54170 550 54180 {
lab=Y6}
N 560 54130 600 54130 {
lab=word902}
N 600 54130 640 54130 {
lab=word902}
N 570 54120 570 54170 {
lab=GND}
N 570 54170 570 54180 {
lab=GND}
N 630 54120 630 54170 {
lab=Y7}
N 630 54170 630 54180 {
lab=Y7}
N 10 54240 40 54240 {
lab=GND}
N 40 54230 40 54240 {
lab=GND}
N 0 54190 40 54190 {
lab=word903}
N 40 54190 80 54190 {
lab=word903}
N 10 54180 10 54230 {
lab=GND}
N 10 54230 10 54240 {
lab=GND}
N 70 54180 70 54230 {
lab=Y0}
N 70 54230 70 54240 {
lab=Y0}
N 90 54240 120 54240 {
lab=GND}
N 120 54230 120 54240 {
lab=GND}
N 80 54190 120 54190 {
lab=word903}
N 120 54190 160 54190 {
lab=word903}
N 90 54180 90 54230 {
lab=GND}
N 90 54230 90 54240 {
lab=GND}
N 150 54180 150 54230 {
lab=Y1}
N 150 54230 150 54240 {
lab=Y1}
N 170 54240 200 54240 {
lab=GND}
N 200 54230 200 54240 {
lab=GND}
N 160 54190 200 54190 {
lab=word903}
N 200 54190 240 54190 {
lab=word903}
N 170 54180 170 54230 {
lab=GND}
N 170 54230 170 54240 {
lab=GND}
N 230 54180 230 54230 {
lab=Y2}
N 230 54230 230 54240 {
lab=Y2}
N 250 54240 280 54240 {
lab=GND}
N 280 54230 280 54240 {
lab=GND}
N 240 54190 280 54190 {
lab=word903}
N 280 54190 320 54190 {
lab=word903}
N 250 54180 250 54230 {
lab=GND}
N 250 54230 250 54240 {
lab=GND}
N 310 54180 310 54230 {
lab=Y3}
N 310 54230 310 54240 {
lab=Y3}
N 330 54240 360 54240 {
lab=GND}
N 360 54230 360 54240 {
lab=GND}
N 320 54190 360 54190 {
lab=word903}
N 360 54190 400 54190 {
lab=word903}
N 330 54180 330 54230 {
lab=GND}
N 330 54230 330 54240 {
lab=GND}
N 390 54180 390 54230 {
lab=Y4}
N 390 54230 390 54240 {
lab=Y4}
N 410 54240 440 54240 {
lab=GND}
N 440 54230 440 54240 {
lab=GND}
N 400 54190 440 54190 {
lab=word903}
N 440 54190 480 54190 {
lab=word903}
N 410 54180 410 54230 {
lab=GND}
N 410 54230 410 54240 {
lab=GND}
N 470 54180 470 54230 {
lab=Y5}
N 470 54230 470 54240 {
lab=Y5}
N 480 54190 520 54190 {
lab=word903}
N 520 54190 560 54190 {
lab=word903}
N 490 54180 490 54230 {
lab=GND}
N 490 54230 490 54240 {
lab=GND}
N 550 54180 550 54230 {
lab=Y6}
N 550 54230 550 54240 {
lab=Y6}
N 570 54240 600 54240 {
lab=GND}
N 600 54230 600 54240 {
lab=GND}
N 560 54190 600 54190 {
lab=word903}
N 600 54190 640 54190 {
lab=word903}
N 570 54180 570 54230 {
lab=GND}
N 570 54230 570 54240 {
lab=GND}
N 630 54180 630 54230 {
lab=Y7}
N 630 54230 630 54240 {
lab=Y7}
N 10 54300 40 54300 {
lab=GND}
N 40 54290 40 54300 {
lab=GND}
N 0 54250 40 54250 {
lab=word904}
N 40 54250 80 54250 {
lab=word904}
N 10 54240 10 54290 {
lab=GND}
N 10 54290 10 54300 {
lab=GND}
N 70 54240 70 54290 {
lab=Y0}
N 70 54290 70 54300 {
lab=Y0}
N 90 54300 120 54300 {
lab=GND}
N 120 54290 120 54300 {
lab=GND}
N 80 54250 120 54250 {
lab=word904}
N 120 54250 160 54250 {
lab=word904}
N 90 54240 90 54290 {
lab=GND}
N 90 54290 90 54300 {
lab=GND}
N 150 54240 150 54290 {
lab=Y1}
N 150 54290 150 54300 {
lab=Y1}
N 170 54300 200 54300 {
lab=GND}
N 200 54290 200 54300 {
lab=GND}
N 160 54250 200 54250 {
lab=word904}
N 200 54250 240 54250 {
lab=word904}
N 170 54240 170 54290 {
lab=GND}
N 170 54290 170 54300 {
lab=GND}
N 230 54240 230 54290 {
lab=Y2}
N 230 54290 230 54300 {
lab=Y2}
N 250 54300 280 54300 {
lab=GND}
N 280 54290 280 54300 {
lab=GND}
N 240 54250 280 54250 {
lab=word904}
N 280 54250 320 54250 {
lab=word904}
N 250 54240 250 54290 {
lab=GND}
N 250 54290 250 54300 {
lab=GND}
N 310 54240 310 54290 {
lab=Y3}
N 310 54290 310 54300 {
lab=Y3}
N 330 54300 360 54300 {
lab=GND}
N 360 54290 360 54300 {
lab=GND}
N 320 54250 360 54250 {
lab=word904}
N 360 54250 400 54250 {
lab=word904}
N 330 54240 330 54290 {
lab=GND}
N 330 54290 330 54300 {
lab=GND}
N 390 54240 390 54290 {
lab=Y4}
N 390 54290 390 54300 {
lab=Y4}
N 410 54300 440 54300 {
lab=GND}
N 440 54290 440 54300 {
lab=GND}
N 400 54250 440 54250 {
lab=word904}
N 440 54250 480 54250 {
lab=word904}
N 410 54240 410 54290 {
lab=GND}
N 410 54290 410 54300 {
lab=GND}
N 470 54240 470 54290 {
lab=Y5}
N 470 54290 470 54300 {
lab=Y5}
N 480 54250 520 54250 {
lab=word904}
N 520 54250 560 54250 {
lab=word904}
N 490 54240 490 54290 {
lab=GND}
N 490 54290 490 54300 {
lab=GND}
N 550 54240 550 54290 {
lab=Y6}
N 550 54290 550 54300 {
lab=Y6}
N 570 54300 600 54300 {
lab=GND}
N 600 54290 600 54300 {
lab=GND}
N 560 54250 600 54250 {
lab=word904}
N 600 54250 640 54250 {
lab=word904}
N 570 54240 570 54290 {
lab=GND}
N 570 54290 570 54300 {
lab=GND}
N 630 54240 630 54290 {
lab=Y7}
N 630 54290 630 54300 {
lab=Y7}
N 10 54360 40 54360 {
lab=GND}
N 40 54350 40 54360 {
lab=GND}
N 0 54310 40 54310 {
lab=word905}
N 40 54310 80 54310 {
lab=word905}
N 10 54300 10 54350 {
lab=GND}
N 10 54350 10 54360 {
lab=GND}
N 70 54300 70 54350 {
lab=Y0}
N 70 54350 70 54360 {
lab=Y0}
N 90 54360 120 54360 {
lab=GND}
N 120 54350 120 54360 {
lab=GND}
N 80 54310 120 54310 {
lab=word905}
N 120 54310 160 54310 {
lab=word905}
N 90 54300 90 54350 {
lab=GND}
N 90 54350 90 54360 {
lab=GND}
N 150 54300 150 54350 {
lab=Y1}
N 150 54350 150 54360 {
lab=Y1}
N 170 54360 200 54360 {
lab=GND}
N 200 54350 200 54360 {
lab=GND}
N 160 54310 200 54310 {
lab=word905}
N 200 54310 240 54310 {
lab=word905}
N 170 54300 170 54350 {
lab=GND}
N 170 54350 170 54360 {
lab=GND}
N 230 54300 230 54350 {
lab=Y2}
N 230 54350 230 54360 {
lab=Y2}
N 250 54360 280 54360 {
lab=GND}
N 280 54350 280 54360 {
lab=GND}
N 240 54310 280 54310 {
lab=word905}
N 280 54310 320 54310 {
lab=word905}
N 250 54300 250 54350 {
lab=GND}
N 250 54350 250 54360 {
lab=GND}
N 310 54300 310 54350 {
lab=Y3}
N 310 54350 310 54360 {
lab=Y3}
N 330 54360 360 54360 {
lab=GND}
N 360 54350 360 54360 {
lab=GND}
N 320 54310 360 54310 {
lab=word905}
N 360 54310 400 54310 {
lab=word905}
N 330 54300 330 54350 {
lab=GND}
N 330 54350 330 54360 {
lab=GND}
N 390 54300 390 54350 {
lab=Y4}
N 390 54350 390 54360 {
lab=Y4}
N 410 54360 440 54360 {
lab=GND}
N 440 54350 440 54360 {
lab=GND}
N 400 54310 440 54310 {
lab=word905}
N 440 54310 480 54310 {
lab=word905}
N 410 54300 410 54350 {
lab=GND}
N 410 54350 410 54360 {
lab=GND}
N 470 54300 470 54350 {
lab=Y5}
N 470 54350 470 54360 {
lab=Y5}
N 480 54310 520 54310 {
lab=word905}
N 520 54310 560 54310 {
lab=word905}
N 490 54300 490 54350 {
lab=GND}
N 490 54350 490 54360 {
lab=GND}
N 550 54300 550 54350 {
lab=Y6}
N 550 54350 550 54360 {
lab=Y6}
N 560 54310 600 54310 {
lab=word905}
N 600 54310 640 54310 {
lab=word905}
N 570 54300 570 54350 {
lab=GND}
N 570 54350 570 54360 {
lab=GND}
N 630 54300 630 54350 {
lab=Y7}
N 630 54350 630 54360 {
lab=Y7}
N 10 54420 40 54420 {
lab=GND}
N 40 54410 40 54420 {
lab=GND}
N 0 54370 40 54370 {
lab=word906}
N 40 54370 80 54370 {
lab=word906}
N 10 54360 10 54410 {
lab=GND}
N 10 54410 10 54420 {
lab=GND}
N 70 54360 70 54410 {
lab=Y0}
N 70 54410 70 54420 {
lab=Y0}
N 90 54420 120 54420 {
lab=GND}
N 120 54410 120 54420 {
lab=GND}
N 80 54370 120 54370 {
lab=word906}
N 120 54370 160 54370 {
lab=word906}
N 90 54360 90 54410 {
lab=GND}
N 90 54410 90 54420 {
lab=GND}
N 150 54360 150 54410 {
lab=Y1}
N 150 54410 150 54420 {
lab=Y1}
N 170 54420 200 54420 {
lab=GND}
N 200 54410 200 54420 {
lab=GND}
N 160 54370 200 54370 {
lab=word906}
N 200 54370 240 54370 {
lab=word906}
N 170 54360 170 54410 {
lab=GND}
N 170 54410 170 54420 {
lab=GND}
N 230 54360 230 54410 {
lab=Y2}
N 230 54410 230 54420 {
lab=Y2}
N 250 54420 280 54420 {
lab=GND}
N 280 54410 280 54420 {
lab=GND}
N 240 54370 280 54370 {
lab=word906}
N 280 54370 320 54370 {
lab=word906}
N 250 54360 250 54410 {
lab=GND}
N 250 54410 250 54420 {
lab=GND}
N 310 54360 310 54410 {
lab=Y3}
N 310 54410 310 54420 {
lab=Y3}
N 330 54420 360 54420 {
lab=GND}
N 360 54410 360 54420 {
lab=GND}
N 320 54370 360 54370 {
lab=word906}
N 360 54370 400 54370 {
lab=word906}
N 330 54360 330 54410 {
lab=GND}
N 330 54410 330 54420 {
lab=GND}
N 390 54360 390 54410 {
lab=Y4}
N 390 54410 390 54420 {
lab=Y4}
N 400 54370 440 54370 {
lab=word906}
N 440 54370 480 54370 {
lab=word906}
N 410 54360 410 54410 {
lab=GND}
N 410 54410 410 54420 {
lab=GND}
N 470 54360 470 54410 {
lab=Y5}
N 470 54410 470 54420 {
lab=Y5}
N 490 54420 520 54420 {
lab=GND}
N 520 54410 520 54420 {
lab=GND}
N 480 54370 520 54370 {
lab=word906}
N 520 54370 560 54370 {
lab=word906}
N 490 54360 490 54410 {
lab=GND}
N 490 54410 490 54420 {
lab=GND}
N 550 54360 550 54410 {
lab=Y6}
N 550 54410 550 54420 {
lab=Y6}
N 570 54420 600 54420 {
lab=GND}
N 600 54410 600 54420 {
lab=GND}
N 560 54370 600 54370 {
lab=word906}
N 600 54370 640 54370 {
lab=word906}
N 570 54360 570 54410 {
lab=GND}
N 570 54410 570 54420 {
lab=GND}
N 630 54360 630 54410 {
lab=Y7}
N 630 54410 630 54420 {
lab=Y7}
N 10 54480 40 54480 {
lab=GND}
N 40 54470 40 54480 {
lab=GND}
N 0 54430 40 54430 {
lab=word907}
N 40 54430 80 54430 {
lab=word907}
N 10 54420 10 54470 {
lab=GND}
N 10 54470 10 54480 {
lab=GND}
N 70 54420 70 54470 {
lab=Y0}
N 70 54470 70 54480 {
lab=Y0}
N 90 54480 120 54480 {
lab=GND}
N 120 54470 120 54480 {
lab=GND}
N 80 54430 120 54430 {
lab=word907}
N 120 54430 160 54430 {
lab=word907}
N 90 54420 90 54470 {
lab=GND}
N 90 54470 90 54480 {
lab=GND}
N 150 54420 150 54470 {
lab=Y1}
N 150 54470 150 54480 {
lab=Y1}
N 170 54480 200 54480 {
lab=GND}
N 200 54470 200 54480 {
lab=GND}
N 160 54430 200 54430 {
lab=word907}
N 200 54430 240 54430 {
lab=word907}
N 170 54420 170 54470 {
lab=GND}
N 170 54470 170 54480 {
lab=GND}
N 230 54420 230 54470 {
lab=Y2}
N 230 54470 230 54480 {
lab=Y2}
N 250 54480 280 54480 {
lab=GND}
N 280 54470 280 54480 {
lab=GND}
N 240 54430 280 54430 {
lab=word907}
N 280 54430 320 54430 {
lab=word907}
N 250 54420 250 54470 {
lab=GND}
N 250 54470 250 54480 {
lab=GND}
N 310 54420 310 54470 {
lab=Y3}
N 310 54470 310 54480 {
lab=Y3}
N 330 54480 360 54480 {
lab=GND}
N 360 54470 360 54480 {
lab=GND}
N 320 54430 360 54430 {
lab=word907}
N 360 54430 400 54430 {
lab=word907}
N 330 54420 330 54470 {
lab=GND}
N 330 54470 330 54480 {
lab=GND}
N 390 54420 390 54470 {
lab=Y4}
N 390 54470 390 54480 {
lab=Y4}
N 400 54430 440 54430 {
lab=word907}
N 440 54430 480 54430 {
lab=word907}
N 410 54420 410 54470 {
lab=GND}
N 410 54470 410 54480 {
lab=GND}
N 470 54420 470 54470 {
lab=Y5}
N 470 54470 470 54480 {
lab=Y5}
N 490 54480 520 54480 {
lab=GND}
N 520 54470 520 54480 {
lab=GND}
N 480 54430 520 54430 {
lab=word907}
N 520 54430 560 54430 {
lab=word907}
N 490 54420 490 54470 {
lab=GND}
N 490 54470 490 54480 {
lab=GND}
N 550 54420 550 54470 {
lab=Y6}
N 550 54470 550 54480 {
lab=Y6}
N 560 54430 600 54430 {
lab=word907}
N 600 54430 640 54430 {
lab=word907}
N 570 54420 570 54470 {
lab=GND}
N 570 54470 570 54480 {
lab=GND}
N 630 54420 630 54470 {
lab=Y7}
N 630 54470 630 54480 {
lab=Y7}
N 10 54540 40 54540 {
lab=GND}
N 40 54530 40 54540 {
lab=GND}
N 0 54490 40 54490 {
lab=word908}
N 40 54490 80 54490 {
lab=word908}
N 10 54480 10 54530 {
lab=GND}
N 10 54530 10 54540 {
lab=GND}
N 70 54480 70 54530 {
lab=Y0}
N 70 54530 70 54540 {
lab=Y0}
N 90 54540 120 54540 {
lab=GND}
N 120 54530 120 54540 {
lab=GND}
N 80 54490 120 54490 {
lab=word908}
N 120 54490 160 54490 {
lab=word908}
N 90 54480 90 54530 {
lab=GND}
N 90 54530 90 54540 {
lab=GND}
N 150 54480 150 54530 {
lab=Y1}
N 150 54530 150 54540 {
lab=Y1}
N 170 54540 200 54540 {
lab=GND}
N 200 54530 200 54540 {
lab=GND}
N 160 54490 200 54490 {
lab=word908}
N 200 54490 240 54490 {
lab=word908}
N 170 54480 170 54530 {
lab=GND}
N 170 54530 170 54540 {
lab=GND}
N 230 54480 230 54530 {
lab=Y2}
N 230 54530 230 54540 {
lab=Y2}
N 250 54540 280 54540 {
lab=GND}
N 280 54530 280 54540 {
lab=GND}
N 240 54490 280 54490 {
lab=word908}
N 280 54490 320 54490 {
lab=word908}
N 250 54480 250 54530 {
lab=GND}
N 250 54530 250 54540 {
lab=GND}
N 310 54480 310 54530 {
lab=Y3}
N 310 54530 310 54540 {
lab=Y3}
N 330 54540 360 54540 {
lab=GND}
N 360 54530 360 54540 {
lab=GND}
N 320 54490 360 54490 {
lab=word908}
N 360 54490 400 54490 {
lab=word908}
N 330 54480 330 54530 {
lab=GND}
N 330 54530 330 54540 {
lab=GND}
N 390 54480 390 54530 {
lab=Y4}
N 390 54530 390 54540 {
lab=Y4}
N 400 54490 440 54490 {
lab=word908}
N 440 54490 480 54490 {
lab=word908}
N 410 54480 410 54530 {
lab=GND}
N 410 54530 410 54540 {
lab=GND}
N 470 54480 470 54530 {
lab=Y5}
N 470 54530 470 54540 {
lab=Y5}
N 490 54540 520 54540 {
lab=GND}
N 520 54530 520 54540 {
lab=GND}
N 480 54490 520 54490 {
lab=word908}
N 520 54490 560 54490 {
lab=word908}
N 490 54480 490 54530 {
lab=GND}
N 490 54530 490 54540 {
lab=GND}
N 550 54480 550 54530 {
lab=Y6}
N 550 54530 550 54540 {
lab=Y6}
N 560 54490 600 54490 {
lab=word908}
N 600 54490 640 54490 {
lab=word908}
N 570 54480 570 54530 {
lab=GND}
N 570 54530 570 54540 {
lab=GND}
N 630 54480 630 54530 {
lab=Y7}
N 630 54530 630 54540 {
lab=Y7}
N 10 54600 40 54600 {
lab=GND}
N 40 54590 40 54600 {
lab=GND}
N 0 54550 40 54550 {
lab=word909}
N 40 54550 80 54550 {
lab=word909}
N 10 54540 10 54590 {
lab=GND}
N 10 54590 10 54600 {
lab=GND}
N 70 54540 70 54590 {
lab=Y0}
N 70 54590 70 54600 {
lab=Y0}
N 90 54600 120 54600 {
lab=GND}
N 120 54590 120 54600 {
lab=GND}
N 80 54550 120 54550 {
lab=word909}
N 120 54550 160 54550 {
lab=word909}
N 90 54540 90 54590 {
lab=GND}
N 90 54590 90 54600 {
lab=GND}
N 150 54540 150 54590 {
lab=Y1}
N 150 54590 150 54600 {
lab=Y1}
N 170 54600 200 54600 {
lab=GND}
N 200 54590 200 54600 {
lab=GND}
N 160 54550 200 54550 {
lab=word909}
N 200 54550 240 54550 {
lab=word909}
N 170 54540 170 54590 {
lab=GND}
N 170 54590 170 54600 {
lab=GND}
N 230 54540 230 54590 {
lab=Y2}
N 230 54590 230 54600 {
lab=Y2}
N 250 54600 280 54600 {
lab=GND}
N 280 54590 280 54600 {
lab=GND}
N 240 54550 280 54550 {
lab=word909}
N 280 54550 320 54550 {
lab=word909}
N 250 54540 250 54590 {
lab=GND}
N 250 54590 250 54600 {
lab=GND}
N 310 54540 310 54590 {
lab=Y3}
N 310 54590 310 54600 {
lab=Y3}
N 330 54600 360 54600 {
lab=GND}
N 360 54590 360 54600 {
lab=GND}
N 320 54550 360 54550 {
lab=word909}
N 360 54550 400 54550 {
lab=word909}
N 330 54540 330 54590 {
lab=GND}
N 330 54590 330 54600 {
lab=GND}
N 390 54540 390 54590 {
lab=Y4}
N 390 54590 390 54600 {
lab=Y4}
N 400 54550 440 54550 {
lab=word909}
N 440 54550 480 54550 {
lab=word909}
N 410 54540 410 54590 {
lab=GND}
N 410 54590 410 54600 {
lab=GND}
N 470 54540 470 54590 {
lab=Y5}
N 470 54590 470 54600 {
lab=Y5}
N 480 54550 520 54550 {
lab=word909}
N 520 54550 560 54550 {
lab=word909}
N 490 54540 490 54590 {
lab=GND}
N 490 54590 490 54600 {
lab=GND}
N 550 54540 550 54590 {
lab=Y6}
N 550 54590 550 54600 {
lab=Y6}
N 570 54600 600 54600 {
lab=GND}
N 600 54590 600 54600 {
lab=GND}
N 560 54550 600 54550 {
lab=word909}
N 600 54550 640 54550 {
lab=word909}
N 570 54540 570 54590 {
lab=GND}
N 570 54590 570 54600 {
lab=GND}
N 630 54540 630 54590 {
lab=Y7}
N 630 54590 630 54600 {
lab=Y7}
N 10 54660 40 54660 {
lab=GND}
N 40 54650 40 54660 {
lab=GND}
N 0 54610 40 54610 {
lab=word910}
N 40 54610 80 54610 {
lab=word910}
N 10 54600 10 54650 {
lab=GND}
N 10 54650 10 54660 {
lab=GND}
N 70 54600 70 54650 {
lab=Y0}
N 70 54650 70 54660 {
lab=Y0}
N 90 54660 120 54660 {
lab=GND}
N 120 54650 120 54660 {
lab=GND}
N 80 54610 120 54610 {
lab=word910}
N 120 54610 160 54610 {
lab=word910}
N 90 54600 90 54650 {
lab=GND}
N 90 54650 90 54660 {
lab=GND}
N 150 54600 150 54650 {
lab=Y1}
N 150 54650 150 54660 {
lab=Y1}
N 170 54660 200 54660 {
lab=GND}
N 200 54650 200 54660 {
lab=GND}
N 160 54610 200 54610 {
lab=word910}
N 200 54610 240 54610 {
lab=word910}
N 170 54600 170 54650 {
lab=GND}
N 170 54650 170 54660 {
lab=GND}
N 230 54600 230 54650 {
lab=Y2}
N 230 54650 230 54660 {
lab=Y2}
N 250 54660 280 54660 {
lab=GND}
N 280 54650 280 54660 {
lab=GND}
N 240 54610 280 54610 {
lab=word910}
N 280 54610 320 54610 {
lab=word910}
N 250 54600 250 54650 {
lab=GND}
N 250 54650 250 54660 {
lab=GND}
N 310 54600 310 54650 {
lab=Y3}
N 310 54650 310 54660 {
lab=Y3}
N 330 54660 360 54660 {
lab=GND}
N 360 54650 360 54660 {
lab=GND}
N 320 54610 360 54610 {
lab=word910}
N 360 54610 400 54610 {
lab=word910}
N 330 54600 330 54650 {
lab=GND}
N 330 54650 330 54660 {
lab=GND}
N 390 54600 390 54650 {
lab=Y4}
N 390 54650 390 54660 {
lab=Y4}
N 400 54610 440 54610 {
lab=word910}
N 440 54610 480 54610 {
lab=word910}
N 410 54600 410 54650 {
lab=GND}
N 410 54650 410 54660 {
lab=GND}
N 470 54600 470 54650 {
lab=Y5}
N 470 54650 470 54660 {
lab=Y5}
N 480 54610 520 54610 {
lab=word910}
N 520 54610 560 54610 {
lab=word910}
N 490 54600 490 54650 {
lab=GND}
N 490 54650 490 54660 {
lab=GND}
N 550 54600 550 54650 {
lab=Y6}
N 550 54650 550 54660 {
lab=Y6}
N 560 54610 600 54610 {
lab=word910}
N 600 54610 640 54610 {
lab=word910}
N 570 54600 570 54650 {
lab=GND}
N 570 54650 570 54660 {
lab=GND}
N 630 54600 630 54650 {
lab=Y7}
N 630 54650 630 54660 {
lab=Y7}
N 10 54720 40 54720 {
lab=GND}
N 40 54710 40 54720 {
lab=GND}
N 0 54670 40 54670 {
lab=word911}
N 40 54670 80 54670 {
lab=word911}
N 10 54660 10 54710 {
lab=GND}
N 10 54710 10 54720 {
lab=GND}
N 70 54660 70 54710 {
lab=Y0}
N 70 54710 70 54720 {
lab=Y0}
N 90 54720 120 54720 {
lab=GND}
N 120 54710 120 54720 {
lab=GND}
N 80 54670 120 54670 {
lab=word911}
N 120 54670 160 54670 {
lab=word911}
N 90 54660 90 54710 {
lab=GND}
N 90 54710 90 54720 {
lab=GND}
N 150 54660 150 54710 {
lab=Y1}
N 150 54710 150 54720 {
lab=Y1}
N 170 54720 200 54720 {
lab=GND}
N 200 54710 200 54720 {
lab=GND}
N 160 54670 200 54670 {
lab=word911}
N 200 54670 240 54670 {
lab=word911}
N 170 54660 170 54710 {
lab=GND}
N 170 54710 170 54720 {
lab=GND}
N 230 54660 230 54710 {
lab=Y2}
N 230 54710 230 54720 {
lab=Y2}
N 250 54720 280 54720 {
lab=GND}
N 280 54710 280 54720 {
lab=GND}
N 240 54670 280 54670 {
lab=word911}
N 280 54670 320 54670 {
lab=word911}
N 250 54660 250 54710 {
lab=GND}
N 250 54710 250 54720 {
lab=GND}
N 310 54660 310 54710 {
lab=Y3}
N 310 54710 310 54720 {
lab=Y3}
N 320 54670 360 54670 {
lab=word911}
N 360 54670 400 54670 {
lab=word911}
N 330 54660 330 54710 {
lab=GND}
N 330 54710 330 54720 {
lab=GND}
N 390 54660 390 54710 {
lab=Y4}
N 390 54710 390 54720 {
lab=Y4}
N 410 54720 440 54720 {
lab=GND}
N 440 54710 440 54720 {
lab=GND}
N 400 54670 440 54670 {
lab=word911}
N 440 54670 480 54670 {
lab=word911}
N 410 54660 410 54710 {
lab=GND}
N 410 54710 410 54720 {
lab=GND}
N 470 54660 470 54710 {
lab=Y5}
N 470 54710 470 54720 {
lab=Y5}
N 490 54720 520 54720 {
lab=GND}
N 520 54710 520 54720 {
lab=GND}
N 480 54670 520 54670 {
lab=word911}
N 520 54670 560 54670 {
lab=word911}
N 490 54660 490 54710 {
lab=GND}
N 490 54710 490 54720 {
lab=GND}
N 550 54660 550 54710 {
lab=Y6}
N 550 54710 550 54720 {
lab=Y6}
N 560 54670 600 54670 {
lab=word911}
N 600 54670 640 54670 {
lab=word911}
N 570 54660 570 54710 {
lab=GND}
N 570 54710 570 54720 {
lab=GND}
N 630 54660 630 54710 {
lab=Y7}
N 630 54710 630 54720 {
lab=Y7}
N 10 54780 40 54780 {
lab=GND}
N 40 54770 40 54780 {
lab=GND}
N 0 54730 40 54730 {
lab=word912}
N 40 54730 80 54730 {
lab=word912}
N 10 54720 10 54770 {
lab=GND}
N 10 54770 10 54780 {
lab=GND}
N 70 54720 70 54770 {
lab=Y0}
N 70 54770 70 54780 {
lab=Y0}
N 90 54780 120 54780 {
lab=GND}
N 120 54770 120 54780 {
lab=GND}
N 80 54730 120 54730 {
lab=word912}
N 120 54730 160 54730 {
lab=word912}
N 90 54720 90 54770 {
lab=GND}
N 90 54770 90 54780 {
lab=GND}
N 150 54720 150 54770 {
lab=Y1}
N 150 54770 150 54780 {
lab=Y1}
N 170 54780 200 54780 {
lab=GND}
N 200 54770 200 54780 {
lab=GND}
N 160 54730 200 54730 {
lab=word912}
N 200 54730 240 54730 {
lab=word912}
N 170 54720 170 54770 {
lab=GND}
N 170 54770 170 54780 {
lab=GND}
N 230 54720 230 54770 {
lab=Y2}
N 230 54770 230 54780 {
lab=Y2}
N 250 54780 280 54780 {
lab=GND}
N 280 54770 280 54780 {
lab=GND}
N 240 54730 280 54730 {
lab=word912}
N 280 54730 320 54730 {
lab=word912}
N 250 54720 250 54770 {
lab=GND}
N 250 54770 250 54780 {
lab=GND}
N 310 54720 310 54770 {
lab=Y3}
N 310 54770 310 54780 {
lab=Y3}
N 320 54730 360 54730 {
lab=word912}
N 360 54730 400 54730 {
lab=word912}
N 330 54720 330 54770 {
lab=GND}
N 330 54770 330 54780 {
lab=GND}
N 390 54720 390 54770 {
lab=Y4}
N 390 54770 390 54780 {
lab=Y4}
N 410 54780 440 54780 {
lab=GND}
N 440 54770 440 54780 {
lab=GND}
N 400 54730 440 54730 {
lab=word912}
N 440 54730 480 54730 {
lab=word912}
N 410 54720 410 54770 {
lab=GND}
N 410 54770 410 54780 {
lab=GND}
N 470 54720 470 54770 {
lab=Y5}
N 470 54770 470 54780 {
lab=Y5}
N 480 54730 520 54730 {
lab=word912}
N 520 54730 560 54730 {
lab=word912}
N 490 54720 490 54770 {
lab=GND}
N 490 54770 490 54780 {
lab=GND}
N 550 54720 550 54770 {
lab=Y6}
N 550 54770 550 54780 {
lab=Y6}
N 570 54780 600 54780 {
lab=GND}
N 600 54770 600 54780 {
lab=GND}
N 560 54730 600 54730 {
lab=word912}
N 600 54730 640 54730 {
lab=word912}
N 570 54720 570 54770 {
lab=GND}
N 570 54770 570 54780 {
lab=GND}
N 630 54720 630 54770 {
lab=Y7}
N 630 54770 630 54780 {
lab=Y7}
N 10 54840 40 54840 {
lab=GND}
N 40 54830 40 54840 {
lab=GND}
N 0 54790 40 54790 {
lab=word913}
N 40 54790 80 54790 {
lab=word913}
N 10 54780 10 54830 {
lab=GND}
N 10 54830 10 54840 {
lab=GND}
N 70 54780 70 54830 {
lab=Y0}
N 70 54830 70 54840 {
lab=Y0}
N 90 54840 120 54840 {
lab=GND}
N 120 54830 120 54840 {
lab=GND}
N 80 54790 120 54790 {
lab=word913}
N 120 54790 160 54790 {
lab=word913}
N 90 54780 90 54830 {
lab=GND}
N 90 54830 90 54840 {
lab=GND}
N 150 54780 150 54830 {
lab=Y1}
N 150 54830 150 54840 {
lab=Y1}
N 170 54840 200 54840 {
lab=GND}
N 200 54830 200 54840 {
lab=GND}
N 160 54790 200 54790 {
lab=word913}
N 200 54790 240 54790 {
lab=word913}
N 170 54780 170 54830 {
lab=GND}
N 170 54830 170 54840 {
lab=GND}
N 230 54780 230 54830 {
lab=Y2}
N 230 54830 230 54840 {
lab=Y2}
N 250 54840 280 54840 {
lab=GND}
N 280 54830 280 54840 {
lab=GND}
N 240 54790 280 54790 {
lab=word913}
N 280 54790 320 54790 {
lab=word913}
N 250 54780 250 54830 {
lab=GND}
N 250 54830 250 54840 {
lab=GND}
N 310 54780 310 54830 {
lab=Y3}
N 310 54830 310 54840 {
lab=Y3}
N 320 54790 360 54790 {
lab=word913}
N 360 54790 400 54790 {
lab=word913}
N 330 54780 330 54830 {
lab=GND}
N 330 54830 330 54840 {
lab=GND}
N 390 54780 390 54830 {
lab=Y4}
N 390 54830 390 54840 {
lab=Y4}
N 410 54840 440 54840 {
lab=GND}
N 440 54830 440 54840 {
lab=GND}
N 400 54790 440 54790 {
lab=word913}
N 440 54790 480 54790 {
lab=word913}
N 410 54780 410 54830 {
lab=GND}
N 410 54830 410 54840 {
lab=GND}
N 470 54780 470 54830 {
lab=Y5}
N 470 54830 470 54840 {
lab=Y5}
N 480 54790 520 54790 {
lab=word913}
N 520 54790 560 54790 {
lab=word913}
N 490 54780 490 54830 {
lab=GND}
N 490 54830 490 54840 {
lab=GND}
N 550 54780 550 54830 {
lab=Y6}
N 550 54830 550 54840 {
lab=Y6}
N 560 54790 600 54790 {
lab=word913}
N 600 54790 640 54790 {
lab=word913}
N 570 54780 570 54830 {
lab=GND}
N 570 54830 570 54840 {
lab=GND}
N 630 54780 630 54830 {
lab=Y7}
N 630 54830 630 54840 {
lab=Y7}
N 10 54900 40 54900 {
lab=GND}
N 40 54890 40 54900 {
lab=GND}
N 0 54850 40 54850 {
lab=word914}
N 40 54850 80 54850 {
lab=word914}
N 10 54840 10 54890 {
lab=GND}
N 10 54890 10 54900 {
lab=GND}
N 70 54840 70 54890 {
lab=Y0}
N 70 54890 70 54900 {
lab=Y0}
N 90 54900 120 54900 {
lab=GND}
N 120 54890 120 54900 {
lab=GND}
N 80 54850 120 54850 {
lab=word914}
N 120 54850 160 54850 {
lab=word914}
N 90 54840 90 54890 {
lab=GND}
N 90 54890 90 54900 {
lab=GND}
N 150 54840 150 54890 {
lab=Y1}
N 150 54890 150 54900 {
lab=Y1}
N 170 54900 200 54900 {
lab=GND}
N 200 54890 200 54900 {
lab=GND}
N 160 54850 200 54850 {
lab=word914}
N 200 54850 240 54850 {
lab=word914}
N 170 54840 170 54890 {
lab=GND}
N 170 54890 170 54900 {
lab=GND}
N 230 54840 230 54890 {
lab=Y2}
N 230 54890 230 54900 {
lab=Y2}
N 250 54900 280 54900 {
lab=GND}
N 280 54890 280 54900 {
lab=GND}
N 240 54850 280 54850 {
lab=word914}
N 280 54850 320 54850 {
lab=word914}
N 250 54840 250 54890 {
lab=GND}
N 250 54890 250 54900 {
lab=GND}
N 310 54840 310 54890 {
lab=Y3}
N 310 54890 310 54900 {
lab=Y3}
N 320 54850 360 54850 {
lab=word914}
N 360 54850 400 54850 {
lab=word914}
N 330 54840 330 54890 {
lab=GND}
N 330 54890 330 54900 {
lab=GND}
N 390 54840 390 54890 {
lab=Y4}
N 390 54890 390 54900 {
lab=Y4}
N 400 54850 440 54850 {
lab=word914}
N 440 54850 480 54850 {
lab=word914}
N 410 54840 410 54890 {
lab=GND}
N 410 54890 410 54900 {
lab=GND}
N 470 54840 470 54890 {
lab=Y5}
N 470 54890 470 54900 {
lab=Y5}
N 490 54900 520 54900 {
lab=GND}
N 520 54890 520 54900 {
lab=GND}
N 480 54850 520 54850 {
lab=word914}
N 520 54850 560 54850 {
lab=word914}
N 490 54840 490 54890 {
lab=GND}
N 490 54890 490 54900 {
lab=GND}
N 550 54840 550 54890 {
lab=Y6}
N 550 54890 550 54900 {
lab=Y6}
N 570 54900 600 54900 {
lab=GND}
N 600 54890 600 54900 {
lab=GND}
N 560 54850 600 54850 {
lab=word914}
N 600 54850 640 54850 {
lab=word914}
N 570 54840 570 54890 {
lab=GND}
N 570 54890 570 54900 {
lab=GND}
N 630 54840 630 54890 {
lab=Y7}
N 630 54890 630 54900 {
lab=Y7}
N 10 54960 40 54960 {
lab=GND}
N 40 54950 40 54960 {
lab=GND}
N 0 54910 40 54910 {
lab=word915}
N 40 54910 80 54910 {
lab=word915}
N 10 54900 10 54950 {
lab=GND}
N 10 54950 10 54960 {
lab=GND}
N 70 54900 70 54950 {
lab=Y0}
N 70 54950 70 54960 {
lab=Y0}
N 90 54960 120 54960 {
lab=GND}
N 120 54950 120 54960 {
lab=GND}
N 80 54910 120 54910 {
lab=word915}
N 120 54910 160 54910 {
lab=word915}
N 90 54900 90 54950 {
lab=GND}
N 90 54950 90 54960 {
lab=GND}
N 150 54900 150 54950 {
lab=Y1}
N 150 54950 150 54960 {
lab=Y1}
N 170 54960 200 54960 {
lab=GND}
N 200 54950 200 54960 {
lab=GND}
N 160 54910 200 54910 {
lab=word915}
N 200 54910 240 54910 {
lab=word915}
N 170 54900 170 54950 {
lab=GND}
N 170 54950 170 54960 {
lab=GND}
N 230 54900 230 54950 {
lab=Y2}
N 230 54950 230 54960 {
lab=Y2}
N 250 54960 280 54960 {
lab=GND}
N 280 54950 280 54960 {
lab=GND}
N 240 54910 280 54910 {
lab=word915}
N 280 54910 320 54910 {
lab=word915}
N 250 54900 250 54950 {
lab=GND}
N 250 54950 250 54960 {
lab=GND}
N 310 54900 310 54950 {
lab=Y3}
N 310 54950 310 54960 {
lab=Y3}
N 320 54910 360 54910 {
lab=word915}
N 360 54910 400 54910 {
lab=word915}
N 330 54900 330 54950 {
lab=GND}
N 330 54950 330 54960 {
lab=GND}
N 390 54900 390 54950 {
lab=Y4}
N 390 54950 390 54960 {
lab=Y4}
N 400 54910 440 54910 {
lab=word915}
N 440 54910 480 54910 {
lab=word915}
N 410 54900 410 54950 {
lab=GND}
N 410 54950 410 54960 {
lab=GND}
N 470 54900 470 54950 {
lab=Y5}
N 470 54950 470 54960 {
lab=Y5}
N 480 54910 520 54910 {
lab=word915}
N 520 54910 560 54910 {
lab=word915}
N 490 54900 490 54950 {
lab=GND}
N 490 54950 490 54960 {
lab=GND}
N 550 54900 550 54950 {
lab=Y6}
N 550 54950 550 54960 {
lab=Y6}
N 570 54960 600 54960 {
lab=GND}
N 600 54950 600 54960 {
lab=GND}
N 560 54910 600 54910 {
lab=word915}
N 600 54910 640 54910 {
lab=word915}
N 570 54900 570 54950 {
lab=GND}
N 570 54950 570 54960 {
lab=GND}
N 630 54900 630 54950 {
lab=Y7}
N 630 54950 630 54960 {
lab=Y7}
N 10 55020 40 55020 {
lab=GND}
N 40 55010 40 55020 {
lab=GND}
N 0 54970 40 54970 {
lab=word916}
N 40 54970 80 54970 {
lab=word916}
N 10 54960 10 55010 {
lab=GND}
N 10 55010 10 55020 {
lab=GND}
N 70 54960 70 55010 {
lab=Y0}
N 70 55010 70 55020 {
lab=Y0}
N 90 55020 120 55020 {
lab=GND}
N 120 55010 120 55020 {
lab=GND}
N 80 54970 120 54970 {
lab=word916}
N 120 54970 160 54970 {
lab=word916}
N 90 54960 90 55010 {
lab=GND}
N 90 55010 90 55020 {
lab=GND}
N 150 54960 150 55010 {
lab=Y1}
N 150 55010 150 55020 {
lab=Y1}
N 170 55020 200 55020 {
lab=GND}
N 200 55010 200 55020 {
lab=GND}
N 160 54970 200 54970 {
lab=word916}
N 200 54970 240 54970 {
lab=word916}
N 170 54960 170 55010 {
lab=GND}
N 170 55010 170 55020 {
lab=GND}
N 230 54960 230 55010 {
lab=Y2}
N 230 55010 230 55020 {
lab=Y2}
N 250 55020 280 55020 {
lab=GND}
N 280 55010 280 55020 {
lab=GND}
N 240 54970 280 54970 {
lab=word916}
N 280 54970 320 54970 {
lab=word916}
N 250 54960 250 55010 {
lab=GND}
N 250 55010 250 55020 {
lab=GND}
N 310 54960 310 55010 {
lab=Y3}
N 310 55010 310 55020 {
lab=Y3}
N 320 54970 360 54970 {
lab=word916}
N 360 54970 400 54970 {
lab=word916}
N 330 54960 330 55010 {
lab=GND}
N 330 55010 330 55020 {
lab=GND}
N 390 54960 390 55010 {
lab=Y4}
N 390 55010 390 55020 {
lab=Y4}
N 400 54970 440 54970 {
lab=word916}
N 440 54970 480 54970 {
lab=word916}
N 410 54960 410 55010 {
lab=GND}
N 410 55010 410 55020 {
lab=GND}
N 470 54960 470 55010 {
lab=Y5}
N 470 55010 470 55020 {
lab=Y5}
N 480 54970 520 54970 {
lab=word916}
N 520 54970 560 54970 {
lab=word916}
N 490 54960 490 55010 {
lab=GND}
N 490 55010 490 55020 {
lab=GND}
N 550 54960 550 55010 {
lab=Y6}
N 550 55010 550 55020 {
lab=Y6}
N 560 54970 600 54970 {
lab=word916}
N 600 54970 640 54970 {
lab=word916}
N 570 54960 570 55010 {
lab=GND}
N 570 55010 570 55020 {
lab=GND}
N 630 54960 630 55010 {
lab=Y7}
N 630 55010 630 55020 {
lab=Y7}
N 10 55080 40 55080 {
lab=GND}
N 40 55070 40 55080 {
lab=GND}
N 0 55030 40 55030 {
lab=word917}
N 40 55030 80 55030 {
lab=word917}
N 10 55020 10 55070 {
lab=GND}
N 10 55070 10 55080 {
lab=GND}
N 70 55020 70 55070 {
lab=Y0}
N 70 55070 70 55080 {
lab=Y0}
N 90 55080 120 55080 {
lab=GND}
N 120 55070 120 55080 {
lab=GND}
N 80 55030 120 55030 {
lab=word917}
N 120 55030 160 55030 {
lab=word917}
N 90 55020 90 55070 {
lab=GND}
N 90 55070 90 55080 {
lab=GND}
N 150 55020 150 55070 {
lab=Y1}
N 150 55070 150 55080 {
lab=Y1}
N 170 55080 200 55080 {
lab=GND}
N 200 55070 200 55080 {
lab=GND}
N 160 55030 200 55030 {
lab=word917}
N 200 55030 240 55030 {
lab=word917}
N 170 55020 170 55070 {
lab=GND}
N 170 55070 170 55080 {
lab=GND}
N 230 55020 230 55070 {
lab=Y2}
N 230 55070 230 55080 {
lab=Y2}
N 240 55030 280 55030 {
lab=word917}
N 280 55030 320 55030 {
lab=word917}
N 250 55020 250 55070 {
lab=GND}
N 250 55070 250 55080 {
lab=GND}
N 310 55020 310 55070 {
lab=Y3}
N 310 55070 310 55080 {
lab=Y3}
N 330 55080 360 55080 {
lab=GND}
N 360 55070 360 55080 {
lab=GND}
N 320 55030 360 55030 {
lab=word917}
N 360 55030 400 55030 {
lab=word917}
N 330 55020 330 55070 {
lab=GND}
N 330 55070 330 55080 {
lab=GND}
N 390 55020 390 55070 {
lab=Y4}
N 390 55070 390 55080 {
lab=Y4}
N 410 55080 440 55080 {
lab=GND}
N 440 55070 440 55080 {
lab=GND}
N 400 55030 440 55030 {
lab=word917}
N 440 55030 480 55030 {
lab=word917}
N 410 55020 410 55070 {
lab=GND}
N 410 55070 410 55080 {
lab=GND}
N 470 55020 470 55070 {
lab=Y5}
N 470 55070 470 55080 {
lab=Y5}
N 490 55080 520 55080 {
lab=GND}
N 520 55070 520 55080 {
lab=GND}
N 480 55030 520 55030 {
lab=word917}
N 520 55030 560 55030 {
lab=word917}
N 490 55020 490 55070 {
lab=GND}
N 490 55070 490 55080 {
lab=GND}
N 550 55020 550 55070 {
lab=Y6}
N 550 55070 550 55080 {
lab=Y6}
N 560 55030 600 55030 {
lab=word917}
N 600 55030 640 55030 {
lab=word917}
N 570 55020 570 55070 {
lab=GND}
N 570 55070 570 55080 {
lab=GND}
N 630 55020 630 55070 {
lab=Y7}
N 630 55070 630 55080 {
lab=Y7}
N 10 55140 40 55140 {
lab=GND}
N 40 55130 40 55140 {
lab=GND}
N 0 55090 40 55090 {
lab=word918}
N 40 55090 80 55090 {
lab=word918}
N 10 55080 10 55130 {
lab=GND}
N 10 55130 10 55140 {
lab=GND}
N 70 55080 70 55130 {
lab=Y0}
N 70 55130 70 55140 {
lab=Y0}
N 90 55140 120 55140 {
lab=GND}
N 120 55130 120 55140 {
lab=GND}
N 80 55090 120 55090 {
lab=word918}
N 120 55090 160 55090 {
lab=word918}
N 90 55080 90 55130 {
lab=GND}
N 90 55130 90 55140 {
lab=GND}
N 150 55080 150 55130 {
lab=Y1}
N 150 55130 150 55140 {
lab=Y1}
N 170 55140 200 55140 {
lab=GND}
N 200 55130 200 55140 {
lab=GND}
N 160 55090 200 55090 {
lab=word918}
N 200 55090 240 55090 {
lab=word918}
N 170 55080 170 55130 {
lab=GND}
N 170 55130 170 55140 {
lab=GND}
N 230 55080 230 55130 {
lab=Y2}
N 230 55130 230 55140 {
lab=Y2}
N 240 55090 280 55090 {
lab=word918}
N 280 55090 320 55090 {
lab=word918}
N 250 55080 250 55130 {
lab=GND}
N 250 55130 250 55140 {
lab=GND}
N 310 55080 310 55130 {
lab=Y3}
N 310 55130 310 55140 {
lab=Y3}
N 330 55140 360 55140 {
lab=GND}
N 360 55130 360 55140 {
lab=GND}
N 320 55090 360 55090 {
lab=word918}
N 360 55090 400 55090 {
lab=word918}
N 330 55080 330 55130 {
lab=GND}
N 330 55130 330 55140 {
lab=GND}
N 390 55080 390 55130 {
lab=Y4}
N 390 55130 390 55140 {
lab=Y4}
N 410 55140 440 55140 {
lab=GND}
N 440 55130 440 55140 {
lab=GND}
N 400 55090 440 55090 {
lab=word918}
N 440 55090 480 55090 {
lab=word918}
N 410 55080 410 55130 {
lab=GND}
N 410 55130 410 55140 {
lab=GND}
N 470 55080 470 55130 {
lab=Y5}
N 470 55130 470 55140 {
lab=Y5}
N 480 55090 520 55090 {
lab=word918}
N 520 55090 560 55090 {
lab=word918}
N 490 55080 490 55130 {
lab=GND}
N 490 55130 490 55140 {
lab=GND}
N 550 55080 550 55130 {
lab=Y6}
N 550 55130 550 55140 {
lab=Y6}
N 570 55140 600 55140 {
lab=GND}
N 600 55130 600 55140 {
lab=GND}
N 560 55090 600 55090 {
lab=word918}
N 600 55090 640 55090 {
lab=word918}
N 570 55080 570 55130 {
lab=GND}
N 570 55130 570 55140 {
lab=GND}
N 630 55080 630 55130 {
lab=Y7}
N 630 55130 630 55140 {
lab=Y7}
N 10 55200 40 55200 {
lab=GND}
N 40 55190 40 55200 {
lab=GND}
N 0 55150 40 55150 {
lab=word919}
N 40 55150 80 55150 {
lab=word919}
N 10 55140 10 55190 {
lab=GND}
N 10 55190 10 55200 {
lab=GND}
N 70 55140 70 55190 {
lab=Y0}
N 70 55190 70 55200 {
lab=Y0}
N 90 55200 120 55200 {
lab=GND}
N 120 55190 120 55200 {
lab=GND}
N 80 55150 120 55150 {
lab=word919}
N 120 55150 160 55150 {
lab=word919}
N 90 55140 90 55190 {
lab=GND}
N 90 55190 90 55200 {
lab=GND}
N 150 55140 150 55190 {
lab=Y1}
N 150 55190 150 55200 {
lab=Y1}
N 170 55200 200 55200 {
lab=GND}
N 200 55190 200 55200 {
lab=GND}
N 160 55150 200 55150 {
lab=word919}
N 200 55150 240 55150 {
lab=word919}
N 170 55140 170 55190 {
lab=GND}
N 170 55190 170 55200 {
lab=GND}
N 230 55140 230 55190 {
lab=Y2}
N 230 55190 230 55200 {
lab=Y2}
N 240 55150 280 55150 {
lab=word919}
N 280 55150 320 55150 {
lab=word919}
N 250 55140 250 55190 {
lab=GND}
N 250 55190 250 55200 {
lab=GND}
N 310 55140 310 55190 {
lab=Y3}
N 310 55190 310 55200 {
lab=Y3}
N 330 55200 360 55200 {
lab=GND}
N 360 55190 360 55200 {
lab=GND}
N 320 55150 360 55150 {
lab=word919}
N 360 55150 400 55150 {
lab=word919}
N 330 55140 330 55190 {
lab=GND}
N 330 55190 330 55200 {
lab=GND}
N 390 55140 390 55190 {
lab=Y4}
N 390 55190 390 55200 {
lab=Y4}
N 400 55150 440 55150 {
lab=word919}
N 440 55150 480 55150 {
lab=word919}
N 410 55140 410 55190 {
lab=GND}
N 410 55190 410 55200 {
lab=GND}
N 470 55140 470 55190 {
lab=Y5}
N 470 55190 470 55200 {
lab=Y5}
N 490 55200 520 55200 {
lab=GND}
N 520 55190 520 55200 {
lab=GND}
N 480 55150 520 55150 {
lab=word919}
N 520 55150 560 55150 {
lab=word919}
N 490 55140 490 55190 {
lab=GND}
N 490 55190 490 55200 {
lab=GND}
N 550 55140 550 55190 {
lab=Y6}
N 550 55190 550 55200 {
lab=Y6}
N 570 55200 600 55200 {
lab=GND}
N 600 55190 600 55200 {
lab=GND}
N 560 55150 600 55150 {
lab=word919}
N 600 55150 640 55150 {
lab=word919}
N 570 55140 570 55190 {
lab=GND}
N 570 55190 570 55200 {
lab=GND}
N 630 55140 630 55190 {
lab=Y7}
N 630 55190 630 55200 {
lab=Y7}
N 10 55260 40 55260 {
lab=GND}
N 40 55250 40 55260 {
lab=GND}
N 0 55210 40 55210 {
lab=word920}
N 40 55210 80 55210 {
lab=word920}
N 10 55200 10 55250 {
lab=GND}
N 10 55250 10 55260 {
lab=GND}
N 70 55200 70 55250 {
lab=Y0}
N 70 55250 70 55260 {
lab=Y0}
N 90 55260 120 55260 {
lab=GND}
N 120 55250 120 55260 {
lab=GND}
N 80 55210 120 55210 {
lab=word920}
N 120 55210 160 55210 {
lab=word920}
N 90 55200 90 55250 {
lab=GND}
N 90 55250 90 55260 {
lab=GND}
N 150 55200 150 55250 {
lab=Y1}
N 150 55250 150 55260 {
lab=Y1}
N 170 55260 200 55260 {
lab=GND}
N 200 55250 200 55260 {
lab=GND}
N 160 55210 200 55210 {
lab=word920}
N 200 55210 240 55210 {
lab=word920}
N 170 55200 170 55250 {
lab=GND}
N 170 55250 170 55260 {
lab=GND}
N 230 55200 230 55250 {
lab=Y2}
N 230 55250 230 55260 {
lab=Y2}
N 240 55210 280 55210 {
lab=word920}
N 280 55210 320 55210 {
lab=word920}
N 250 55200 250 55250 {
lab=GND}
N 250 55250 250 55260 {
lab=GND}
N 310 55200 310 55250 {
lab=Y3}
N 310 55250 310 55260 {
lab=Y3}
N 330 55260 360 55260 {
lab=GND}
N 360 55250 360 55260 {
lab=GND}
N 320 55210 360 55210 {
lab=word920}
N 360 55210 400 55210 {
lab=word920}
N 330 55200 330 55250 {
lab=GND}
N 330 55250 330 55260 {
lab=GND}
N 390 55200 390 55250 {
lab=Y4}
N 390 55250 390 55260 {
lab=Y4}
N 400 55210 440 55210 {
lab=word920}
N 440 55210 480 55210 {
lab=word920}
N 410 55200 410 55250 {
lab=GND}
N 410 55250 410 55260 {
lab=GND}
N 470 55200 470 55250 {
lab=Y5}
N 470 55250 470 55260 {
lab=Y5}
N 490 55260 520 55260 {
lab=GND}
N 520 55250 520 55260 {
lab=GND}
N 480 55210 520 55210 {
lab=word920}
N 520 55210 560 55210 {
lab=word920}
N 490 55200 490 55250 {
lab=GND}
N 490 55250 490 55260 {
lab=GND}
N 550 55200 550 55250 {
lab=Y6}
N 550 55250 550 55260 {
lab=Y6}
N 560 55210 600 55210 {
lab=word920}
N 600 55210 640 55210 {
lab=word920}
N 570 55200 570 55250 {
lab=GND}
N 570 55250 570 55260 {
lab=GND}
N 630 55200 630 55250 {
lab=Y7}
N 630 55250 630 55260 {
lab=Y7}
N 10 55320 40 55320 {
lab=GND}
N 40 55310 40 55320 {
lab=GND}
N 0 55270 40 55270 {
lab=word921}
N 40 55270 80 55270 {
lab=word921}
N 10 55260 10 55310 {
lab=GND}
N 10 55310 10 55320 {
lab=GND}
N 70 55260 70 55310 {
lab=Y0}
N 70 55310 70 55320 {
lab=Y0}
N 90 55320 120 55320 {
lab=GND}
N 120 55310 120 55320 {
lab=GND}
N 80 55270 120 55270 {
lab=word921}
N 120 55270 160 55270 {
lab=word921}
N 90 55260 90 55310 {
lab=GND}
N 90 55310 90 55320 {
lab=GND}
N 150 55260 150 55310 {
lab=Y1}
N 150 55310 150 55320 {
lab=Y1}
N 170 55320 200 55320 {
lab=GND}
N 200 55310 200 55320 {
lab=GND}
N 160 55270 200 55270 {
lab=word921}
N 200 55270 240 55270 {
lab=word921}
N 170 55260 170 55310 {
lab=GND}
N 170 55310 170 55320 {
lab=GND}
N 230 55260 230 55310 {
lab=Y2}
N 230 55310 230 55320 {
lab=Y2}
N 240 55270 280 55270 {
lab=word921}
N 280 55270 320 55270 {
lab=word921}
N 250 55260 250 55310 {
lab=GND}
N 250 55310 250 55320 {
lab=GND}
N 310 55260 310 55310 {
lab=Y3}
N 310 55310 310 55320 {
lab=Y3}
N 330 55320 360 55320 {
lab=GND}
N 360 55310 360 55320 {
lab=GND}
N 320 55270 360 55270 {
lab=word921}
N 360 55270 400 55270 {
lab=word921}
N 330 55260 330 55310 {
lab=GND}
N 330 55310 330 55320 {
lab=GND}
N 390 55260 390 55310 {
lab=Y4}
N 390 55310 390 55320 {
lab=Y4}
N 400 55270 440 55270 {
lab=word921}
N 440 55270 480 55270 {
lab=word921}
N 410 55260 410 55310 {
lab=GND}
N 410 55310 410 55320 {
lab=GND}
N 470 55260 470 55310 {
lab=Y5}
N 470 55310 470 55320 {
lab=Y5}
N 480 55270 520 55270 {
lab=word921}
N 520 55270 560 55270 {
lab=word921}
N 490 55260 490 55310 {
lab=GND}
N 490 55310 490 55320 {
lab=GND}
N 550 55260 550 55310 {
lab=Y6}
N 550 55310 550 55320 {
lab=Y6}
N 560 55270 600 55270 {
lab=word921}
N 600 55270 640 55270 {
lab=word921}
N 570 55260 570 55310 {
lab=GND}
N 570 55310 570 55320 {
lab=GND}
N 630 55260 630 55310 {
lab=Y7}
N 630 55310 630 55320 {
lab=Y7}
N 10 55380 40 55380 {
lab=GND}
N 40 55370 40 55380 {
lab=GND}
N 0 55330 40 55330 {
lab=word922}
N 40 55330 80 55330 {
lab=word922}
N 10 55320 10 55370 {
lab=GND}
N 10 55370 10 55380 {
lab=GND}
N 70 55320 70 55370 {
lab=Y0}
N 70 55370 70 55380 {
lab=Y0}
N 90 55380 120 55380 {
lab=GND}
N 120 55370 120 55380 {
lab=GND}
N 80 55330 120 55330 {
lab=word922}
N 120 55330 160 55330 {
lab=word922}
N 90 55320 90 55370 {
lab=GND}
N 90 55370 90 55380 {
lab=GND}
N 150 55320 150 55370 {
lab=Y1}
N 150 55370 150 55380 {
lab=Y1}
N 170 55380 200 55380 {
lab=GND}
N 200 55370 200 55380 {
lab=GND}
N 160 55330 200 55330 {
lab=word922}
N 200 55330 240 55330 {
lab=word922}
N 170 55320 170 55370 {
lab=GND}
N 170 55370 170 55380 {
lab=GND}
N 230 55320 230 55370 {
lab=Y2}
N 230 55370 230 55380 {
lab=Y2}
N 240 55330 280 55330 {
lab=word922}
N 280 55330 320 55330 {
lab=word922}
N 250 55320 250 55370 {
lab=GND}
N 250 55370 250 55380 {
lab=GND}
N 310 55320 310 55370 {
lab=Y3}
N 310 55370 310 55380 {
lab=Y3}
N 320 55330 360 55330 {
lab=word922}
N 360 55330 400 55330 {
lab=word922}
N 330 55320 330 55370 {
lab=GND}
N 330 55370 330 55380 {
lab=GND}
N 390 55320 390 55370 {
lab=Y4}
N 390 55370 390 55380 {
lab=Y4}
N 410 55380 440 55380 {
lab=GND}
N 440 55370 440 55380 {
lab=GND}
N 400 55330 440 55330 {
lab=word922}
N 440 55330 480 55330 {
lab=word922}
N 410 55320 410 55370 {
lab=GND}
N 410 55370 410 55380 {
lab=GND}
N 470 55320 470 55370 {
lab=Y5}
N 470 55370 470 55380 {
lab=Y5}
N 490 55380 520 55380 {
lab=GND}
N 520 55370 520 55380 {
lab=GND}
N 480 55330 520 55330 {
lab=word922}
N 520 55330 560 55330 {
lab=word922}
N 490 55320 490 55370 {
lab=GND}
N 490 55370 490 55380 {
lab=GND}
N 550 55320 550 55370 {
lab=Y6}
N 550 55370 550 55380 {
lab=Y6}
N 560 55330 600 55330 {
lab=word922}
N 600 55330 640 55330 {
lab=word922}
N 570 55320 570 55370 {
lab=GND}
N 570 55370 570 55380 {
lab=GND}
N 630 55320 630 55370 {
lab=Y7}
N 630 55370 630 55380 {
lab=Y7}
N 10 55440 40 55440 {
lab=GND}
N 40 55430 40 55440 {
lab=GND}
N 0 55390 40 55390 {
lab=word923}
N 40 55390 80 55390 {
lab=word923}
N 10 55380 10 55430 {
lab=GND}
N 10 55430 10 55440 {
lab=GND}
N 70 55380 70 55430 {
lab=Y0}
N 70 55430 70 55440 {
lab=Y0}
N 90 55440 120 55440 {
lab=GND}
N 120 55430 120 55440 {
lab=GND}
N 80 55390 120 55390 {
lab=word923}
N 120 55390 160 55390 {
lab=word923}
N 90 55380 90 55430 {
lab=GND}
N 90 55430 90 55440 {
lab=GND}
N 150 55380 150 55430 {
lab=Y1}
N 150 55430 150 55440 {
lab=Y1}
N 170 55440 200 55440 {
lab=GND}
N 200 55430 200 55440 {
lab=GND}
N 160 55390 200 55390 {
lab=word923}
N 200 55390 240 55390 {
lab=word923}
N 170 55380 170 55430 {
lab=GND}
N 170 55430 170 55440 {
lab=GND}
N 230 55380 230 55430 {
lab=Y2}
N 230 55430 230 55440 {
lab=Y2}
N 240 55390 280 55390 {
lab=word923}
N 280 55390 320 55390 {
lab=word923}
N 250 55380 250 55430 {
lab=GND}
N 250 55430 250 55440 {
lab=GND}
N 310 55380 310 55430 {
lab=Y3}
N 310 55430 310 55440 {
lab=Y3}
N 320 55390 360 55390 {
lab=word923}
N 360 55390 400 55390 {
lab=word923}
N 330 55380 330 55430 {
lab=GND}
N 330 55430 330 55440 {
lab=GND}
N 390 55380 390 55430 {
lab=Y4}
N 390 55430 390 55440 {
lab=Y4}
N 410 55440 440 55440 {
lab=GND}
N 440 55430 440 55440 {
lab=GND}
N 400 55390 440 55390 {
lab=word923}
N 440 55390 480 55390 {
lab=word923}
N 410 55380 410 55430 {
lab=GND}
N 410 55430 410 55440 {
lab=GND}
N 470 55380 470 55430 {
lab=Y5}
N 470 55430 470 55440 {
lab=Y5}
N 480 55390 520 55390 {
lab=word923}
N 520 55390 560 55390 {
lab=word923}
N 490 55380 490 55430 {
lab=GND}
N 490 55430 490 55440 {
lab=GND}
N 550 55380 550 55430 {
lab=Y6}
N 550 55430 550 55440 {
lab=Y6}
N 560 55390 600 55390 {
lab=word923}
N 600 55390 640 55390 {
lab=word923}
N 570 55380 570 55430 {
lab=GND}
N 570 55430 570 55440 {
lab=GND}
N 630 55380 630 55430 {
lab=Y7}
N 630 55430 630 55440 {
lab=Y7}
N 10 55500 40 55500 {
lab=GND}
N 40 55490 40 55500 {
lab=GND}
N 0 55450 40 55450 {
lab=word924}
N 40 55450 80 55450 {
lab=word924}
N 10 55440 10 55490 {
lab=GND}
N 10 55490 10 55500 {
lab=GND}
N 70 55440 70 55490 {
lab=Y0}
N 70 55490 70 55500 {
lab=Y0}
N 90 55500 120 55500 {
lab=GND}
N 120 55490 120 55500 {
lab=GND}
N 80 55450 120 55450 {
lab=word924}
N 120 55450 160 55450 {
lab=word924}
N 90 55440 90 55490 {
lab=GND}
N 90 55490 90 55500 {
lab=GND}
N 150 55440 150 55490 {
lab=Y1}
N 150 55490 150 55500 {
lab=Y1}
N 170 55500 200 55500 {
lab=GND}
N 200 55490 200 55500 {
lab=GND}
N 160 55450 200 55450 {
lab=word924}
N 200 55450 240 55450 {
lab=word924}
N 170 55440 170 55490 {
lab=GND}
N 170 55490 170 55500 {
lab=GND}
N 230 55440 230 55490 {
lab=Y2}
N 230 55490 230 55500 {
lab=Y2}
N 240 55450 280 55450 {
lab=word924}
N 280 55450 320 55450 {
lab=word924}
N 250 55440 250 55490 {
lab=GND}
N 250 55490 250 55500 {
lab=GND}
N 310 55440 310 55490 {
lab=Y3}
N 310 55490 310 55500 {
lab=Y3}
N 320 55450 360 55450 {
lab=word924}
N 360 55450 400 55450 {
lab=word924}
N 330 55440 330 55490 {
lab=GND}
N 330 55490 330 55500 {
lab=GND}
N 390 55440 390 55490 {
lab=Y4}
N 390 55490 390 55500 {
lab=Y4}
N 400 55450 440 55450 {
lab=word924}
N 440 55450 480 55450 {
lab=word924}
N 410 55440 410 55490 {
lab=GND}
N 410 55490 410 55500 {
lab=GND}
N 470 55440 470 55490 {
lab=Y5}
N 470 55490 470 55500 {
lab=Y5}
N 490 55500 520 55500 {
lab=GND}
N 520 55490 520 55500 {
lab=GND}
N 480 55450 520 55450 {
lab=word924}
N 520 55450 560 55450 {
lab=word924}
N 490 55440 490 55490 {
lab=GND}
N 490 55490 490 55500 {
lab=GND}
N 550 55440 550 55490 {
lab=Y6}
N 550 55490 550 55500 {
lab=Y6}
N 560 55450 600 55450 {
lab=word924}
N 600 55450 640 55450 {
lab=word924}
N 570 55440 570 55490 {
lab=GND}
N 570 55490 570 55500 {
lab=GND}
N 630 55440 630 55490 {
lab=Y7}
N 630 55490 630 55500 {
lab=Y7}
N 10 55560 40 55560 {
lab=GND}
N 40 55550 40 55560 {
lab=GND}
N 0 55510 40 55510 {
lab=word925}
N 40 55510 80 55510 {
lab=word925}
N 10 55500 10 55550 {
lab=GND}
N 10 55550 10 55560 {
lab=GND}
N 70 55500 70 55550 {
lab=Y0}
N 70 55550 70 55560 {
lab=Y0}
N 90 55560 120 55560 {
lab=GND}
N 120 55550 120 55560 {
lab=GND}
N 80 55510 120 55510 {
lab=word925}
N 120 55510 160 55510 {
lab=word925}
N 90 55500 90 55550 {
lab=GND}
N 90 55550 90 55560 {
lab=GND}
N 150 55500 150 55550 {
lab=Y1}
N 150 55550 150 55560 {
lab=Y1}
N 170 55560 200 55560 {
lab=GND}
N 200 55550 200 55560 {
lab=GND}
N 160 55510 200 55510 {
lab=word925}
N 200 55510 240 55510 {
lab=word925}
N 170 55500 170 55550 {
lab=GND}
N 170 55550 170 55560 {
lab=GND}
N 230 55500 230 55550 {
lab=Y2}
N 230 55550 230 55560 {
lab=Y2}
N 240 55510 280 55510 {
lab=word925}
N 280 55510 320 55510 {
lab=word925}
N 250 55500 250 55550 {
lab=GND}
N 250 55550 250 55560 {
lab=GND}
N 310 55500 310 55550 {
lab=Y3}
N 310 55550 310 55560 {
lab=Y3}
N 320 55510 360 55510 {
lab=word925}
N 360 55510 400 55510 {
lab=word925}
N 330 55500 330 55550 {
lab=GND}
N 330 55550 330 55560 {
lab=GND}
N 390 55500 390 55550 {
lab=Y4}
N 390 55550 390 55560 {
lab=Y4}
N 400 55510 440 55510 {
lab=word925}
N 440 55510 480 55510 {
lab=word925}
N 410 55500 410 55550 {
lab=GND}
N 410 55550 410 55560 {
lab=GND}
N 470 55500 470 55550 {
lab=Y5}
N 470 55550 470 55560 {
lab=Y5}
N 480 55510 520 55510 {
lab=word925}
N 520 55510 560 55510 {
lab=word925}
N 490 55500 490 55550 {
lab=GND}
N 490 55550 490 55560 {
lab=GND}
N 550 55500 550 55550 {
lab=Y6}
N 550 55550 550 55560 {
lab=Y6}
N 560 55510 600 55510 {
lab=word925}
N 600 55510 640 55510 {
lab=word925}
N 570 55500 570 55550 {
lab=GND}
N 570 55550 570 55560 {
lab=GND}
N 630 55500 630 55550 {
lab=Y7}
N 630 55550 630 55560 {
lab=Y7}
N 10 55620 40 55620 {
lab=GND}
N 40 55610 40 55620 {
lab=GND}
N 0 55570 40 55570 {
lab=word926}
N 40 55570 80 55570 {
lab=word926}
N 10 55560 10 55610 {
lab=GND}
N 10 55610 10 55620 {
lab=GND}
N 70 55560 70 55610 {
lab=Y0}
N 70 55610 70 55620 {
lab=Y0}
N 90 55620 120 55620 {
lab=GND}
N 120 55610 120 55620 {
lab=GND}
N 80 55570 120 55570 {
lab=word926}
N 120 55570 160 55570 {
lab=word926}
N 90 55560 90 55610 {
lab=GND}
N 90 55610 90 55620 {
lab=GND}
N 150 55560 150 55610 {
lab=Y1}
N 150 55610 150 55620 {
lab=Y1}
N 160 55570 200 55570 {
lab=word926}
N 200 55570 240 55570 {
lab=word926}
N 170 55560 170 55610 {
lab=GND}
N 170 55610 170 55620 {
lab=GND}
N 230 55560 230 55610 {
lab=Y2}
N 230 55610 230 55620 {
lab=Y2}
N 250 55620 280 55620 {
lab=GND}
N 280 55610 280 55620 {
lab=GND}
N 240 55570 280 55570 {
lab=word926}
N 280 55570 320 55570 {
lab=word926}
N 250 55560 250 55610 {
lab=GND}
N 250 55610 250 55620 {
lab=GND}
N 310 55560 310 55610 {
lab=Y3}
N 310 55610 310 55620 {
lab=Y3}
N 330 55620 360 55620 {
lab=GND}
N 360 55610 360 55620 {
lab=GND}
N 320 55570 360 55570 {
lab=word926}
N 360 55570 400 55570 {
lab=word926}
N 330 55560 330 55610 {
lab=GND}
N 330 55610 330 55620 {
lab=GND}
N 390 55560 390 55610 {
lab=Y4}
N 390 55610 390 55620 {
lab=Y4}
N 410 55620 440 55620 {
lab=GND}
N 440 55610 440 55620 {
lab=GND}
N 400 55570 440 55570 {
lab=word926}
N 440 55570 480 55570 {
lab=word926}
N 410 55560 410 55610 {
lab=GND}
N 410 55610 410 55620 {
lab=GND}
N 470 55560 470 55610 {
lab=Y5}
N 470 55610 470 55620 {
lab=Y5}
N 490 55620 520 55620 {
lab=GND}
N 520 55610 520 55620 {
lab=GND}
N 480 55570 520 55570 {
lab=word926}
N 520 55570 560 55570 {
lab=word926}
N 490 55560 490 55610 {
lab=GND}
N 490 55610 490 55620 {
lab=GND}
N 550 55560 550 55610 {
lab=Y6}
N 550 55610 550 55620 {
lab=Y6}
N 560 55570 600 55570 {
lab=word926}
N 600 55570 640 55570 {
lab=word926}
N 570 55560 570 55610 {
lab=GND}
N 570 55610 570 55620 {
lab=GND}
N 630 55560 630 55610 {
lab=Y7}
N 630 55610 630 55620 {
lab=Y7}
N 10 55680 40 55680 {
lab=GND}
N 40 55670 40 55680 {
lab=GND}
N 0 55630 40 55630 {
lab=word927}
N 40 55630 80 55630 {
lab=word927}
N 10 55620 10 55670 {
lab=GND}
N 10 55670 10 55680 {
lab=GND}
N 70 55620 70 55670 {
lab=Y0}
N 70 55670 70 55680 {
lab=Y0}
N 90 55680 120 55680 {
lab=GND}
N 120 55670 120 55680 {
lab=GND}
N 80 55630 120 55630 {
lab=word927}
N 120 55630 160 55630 {
lab=word927}
N 90 55620 90 55670 {
lab=GND}
N 90 55670 90 55680 {
lab=GND}
N 150 55620 150 55670 {
lab=Y1}
N 150 55670 150 55680 {
lab=Y1}
N 160 55630 200 55630 {
lab=word927}
N 200 55630 240 55630 {
lab=word927}
N 170 55620 170 55670 {
lab=GND}
N 170 55670 170 55680 {
lab=GND}
N 230 55620 230 55670 {
lab=Y2}
N 230 55670 230 55680 {
lab=Y2}
N 250 55680 280 55680 {
lab=GND}
N 280 55670 280 55680 {
lab=GND}
N 240 55630 280 55630 {
lab=word927}
N 280 55630 320 55630 {
lab=word927}
N 250 55620 250 55670 {
lab=GND}
N 250 55670 250 55680 {
lab=GND}
N 310 55620 310 55670 {
lab=Y3}
N 310 55670 310 55680 {
lab=Y3}
N 330 55680 360 55680 {
lab=GND}
N 360 55670 360 55680 {
lab=GND}
N 320 55630 360 55630 {
lab=word927}
N 360 55630 400 55630 {
lab=word927}
N 330 55620 330 55670 {
lab=GND}
N 330 55670 330 55680 {
lab=GND}
N 390 55620 390 55670 {
lab=Y4}
N 390 55670 390 55680 {
lab=Y4}
N 410 55680 440 55680 {
lab=GND}
N 440 55670 440 55680 {
lab=GND}
N 400 55630 440 55630 {
lab=word927}
N 440 55630 480 55630 {
lab=word927}
N 410 55620 410 55670 {
lab=GND}
N 410 55670 410 55680 {
lab=GND}
N 470 55620 470 55670 {
lab=Y5}
N 470 55670 470 55680 {
lab=Y5}
N 480 55630 520 55630 {
lab=word927}
N 520 55630 560 55630 {
lab=word927}
N 490 55620 490 55670 {
lab=GND}
N 490 55670 490 55680 {
lab=GND}
N 550 55620 550 55670 {
lab=Y6}
N 550 55670 550 55680 {
lab=Y6}
N 560 55630 600 55630 {
lab=word927}
N 600 55630 640 55630 {
lab=word927}
N 570 55620 570 55670 {
lab=GND}
N 570 55670 570 55680 {
lab=GND}
N 630 55620 630 55670 {
lab=Y7}
N 630 55670 630 55680 {
lab=Y7}
N 10 55740 40 55740 {
lab=GND}
N 40 55730 40 55740 {
lab=GND}
N 0 55690 40 55690 {
lab=word928}
N 40 55690 80 55690 {
lab=word928}
N 10 55680 10 55730 {
lab=GND}
N 10 55730 10 55740 {
lab=GND}
N 70 55680 70 55730 {
lab=Y0}
N 70 55730 70 55740 {
lab=Y0}
N 90 55740 120 55740 {
lab=GND}
N 120 55730 120 55740 {
lab=GND}
N 80 55690 120 55690 {
lab=word928}
N 120 55690 160 55690 {
lab=word928}
N 90 55680 90 55730 {
lab=GND}
N 90 55730 90 55740 {
lab=GND}
N 150 55680 150 55730 {
lab=Y1}
N 150 55730 150 55740 {
lab=Y1}
N 160 55690 200 55690 {
lab=word928}
N 200 55690 240 55690 {
lab=word928}
N 170 55680 170 55730 {
lab=GND}
N 170 55730 170 55740 {
lab=GND}
N 230 55680 230 55730 {
lab=Y2}
N 230 55730 230 55740 {
lab=Y2}
N 250 55740 280 55740 {
lab=GND}
N 280 55730 280 55740 {
lab=GND}
N 240 55690 280 55690 {
lab=word928}
N 280 55690 320 55690 {
lab=word928}
N 250 55680 250 55730 {
lab=GND}
N 250 55730 250 55740 {
lab=GND}
N 310 55680 310 55730 {
lab=Y3}
N 310 55730 310 55740 {
lab=Y3}
N 330 55740 360 55740 {
lab=GND}
N 360 55730 360 55740 {
lab=GND}
N 320 55690 360 55690 {
lab=word928}
N 360 55690 400 55690 {
lab=word928}
N 330 55680 330 55730 {
lab=GND}
N 330 55730 330 55740 {
lab=GND}
N 390 55680 390 55730 {
lab=Y4}
N 390 55730 390 55740 {
lab=Y4}
N 400 55690 440 55690 {
lab=word928}
N 440 55690 480 55690 {
lab=word928}
N 410 55680 410 55730 {
lab=GND}
N 410 55730 410 55740 {
lab=GND}
N 470 55680 470 55730 {
lab=Y5}
N 470 55730 470 55740 {
lab=Y5}
N 490 55740 520 55740 {
lab=GND}
N 520 55730 520 55740 {
lab=GND}
N 480 55690 520 55690 {
lab=word928}
N 520 55690 560 55690 {
lab=word928}
N 490 55680 490 55730 {
lab=GND}
N 490 55730 490 55740 {
lab=GND}
N 550 55680 550 55730 {
lab=Y6}
N 550 55730 550 55740 {
lab=Y6}
N 560 55690 600 55690 {
lab=word928}
N 600 55690 640 55690 {
lab=word928}
N 570 55680 570 55730 {
lab=GND}
N 570 55730 570 55740 {
lab=GND}
N 630 55680 630 55730 {
lab=Y7}
N 630 55730 630 55740 {
lab=Y7}
N 10 55800 40 55800 {
lab=GND}
N 40 55790 40 55800 {
lab=GND}
N 0 55750 40 55750 {
lab=word929}
N 40 55750 80 55750 {
lab=word929}
N 10 55740 10 55790 {
lab=GND}
N 10 55790 10 55800 {
lab=GND}
N 70 55740 70 55790 {
lab=Y0}
N 70 55790 70 55800 {
lab=Y0}
N 90 55800 120 55800 {
lab=GND}
N 120 55790 120 55800 {
lab=GND}
N 80 55750 120 55750 {
lab=word929}
N 120 55750 160 55750 {
lab=word929}
N 90 55740 90 55790 {
lab=GND}
N 90 55790 90 55800 {
lab=GND}
N 150 55740 150 55790 {
lab=Y1}
N 150 55790 150 55800 {
lab=Y1}
N 160 55750 200 55750 {
lab=word929}
N 200 55750 240 55750 {
lab=word929}
N 170 55740 170 55790 {
lab=GND}
N 170 55790 170 55800 {
lab=GND}
N 230 55740 230 55790 {
lab=Y2}
N 230 55790 230 55800 {
lab=Y2}
N 250 55800 280 55800 {
lab=GND}
N 280 55790 280 55800 {
lab=GND}
N 240 55750 280 55750 {
lab=word929}
N 280 55750 320 55750 {
lab=word929}
N 250 55740 250 55790 {
lab=GND}
N 250 55790 250 55800 {
lab=GND}
N 310 55740 310 55790 {
lab=Y3}
N 310 55790 310 55800 {
lab=Y3}
N 320 55750 360 55750 {
lab=word929}
N 360 55750 400 55750 {
lab=word929}
N 330 55740 330 55790 {
lab=GND}
N 330 55790 330 55800 {
lab=GND}
N 390 55740 390 55790 {
lab=Y4}
N 390 55790 390 55800 {
lab=Y4}
N 410 55800 440 55800 {
lab=GND}
N 440 55790 440 55800 {
lab=GND}
N 400 55750 440 55750 {
lab=word929}
N 440 55750 480 55750 {
lab=word929}
N 410 55740 410 55790 {
lab=GND}
N 410 55790 410 55800 {
lab=GND}
N 470 55740 470 55790 {
lab=Y5}
N 470 55790 470 55800 {
lab=Y5}
N 490 55800 520 55800 {
lab=GND}
N 520 55790 520 55800 {
lab=GND}
N 480 55750 520 55750 {
lab=word929}
N 520 55750 560 55750 {
lab=word929}
N 490 55740 490 55790 {
lab=GND}
N 490 55790 490 55800 {
lab=GND}
N 550 55740 550 55790 {
lab=Y6}
N 550 55790 550 55800 {
lab=Y6}
N 570 55800 600 55800 {
lab=GND}
N 600 55790 600 55800 {
lab=GND}
N 560 55750 600 55750 {
lab=word929}
N 600 55750 640 55750 {
lab=word929}
N 570 55740 570 55790 {
lab=GND}
N 570 55790 570 55800 {
lab=GND}
N 630 55740 630 55790 {
lab=Y7}
N 630 55790 630 55800 {
lab=Y7}
N 10 55860 40 55860 {
lab=GND}
N 40 55850 40 55860 {
lab=GND}
N 0 55810 40 55810 {
lab=word930}
N 40 55810 80 55810 {
lab=word930}
N 10 55800 10 55850 {
lab=GND}
N 10 55850 10 55860 {
lab=GND}
N 70 55800 70 55850 {
lab=Y0}
N 70 55850 70 55860 {
lab=Y0}
N 90 55860 120 55860 {
lab=GND}
N 120 55850 120 55860 {
lab=GND}
N 80 55810 120 55810 {
lab=word930}
N 120 55810 160 55810 {
lab=word930}
N 90 55800 90 55850 {
lab=GND}
N 90 55850 90 55860 {
lab=GND}
N 150 55800 150 55850 {
lab=Y1}
N 150 55850 150 55860 {
lab=Y1}
N 160 55810 200 55810 {
lab=word930}
N 200 55810 240 55810 {
lab=word930}
N 170 55800 170 55850 {
lab=GND}
N 170 55850 170 55860 {
lab=GND}
N 230 55800 230 55850 {
lab=Y2}
N 230 55850 230 55860 {
lab=Y2}
N 250 55860 280 55860 {
lab=GND}
N 280 55850 280 55860 {
lab=GND}
N 240 55810 280 55810 {
lab=word930}
N 280 55810 320 55810 {
lab=word930}
N 250 55800 250 55850 {
lab=GND}
N 250 55850 250 55860 {
lab=GND}
N 310 55800 310 55850 {
lab=Y3}
N 310 55850 310 55860 {
lab=Y3}
N 320 55810 360 55810 {
lab=word930}
N 360 55810 400 55810 {
lab=word930}
N 330 55800 330 55850 {
lab=GND}
N 330 55850 330 55860 {
lab=GND}
N 390 55800 390 55850 {
lab=Y4}
N 390 55850 390 55860 {
lab=Y4}
N 410 55860 440 55860 {
lab=GND}
N 440 55850 440 55860 {
lab=GND}
N 400 55810 440 55810 {
lab=word930}
N 440 55810 480 55810 {
lab=word930}
N 410 55800 410 55850 {
lab=GND}
N 410 55850 410 55860 {
lab=GND}
N 470 55800 470 55850 {
lab=Y5}
N 470 55850 470 55860 {
lab=Y5}
N 480 55810 520 55810 {
lab=word930}
N 520 55810 560 55810 {
lab=word930}
N 490 55800 490 55850 {
lab=GND}
N 490 55850 490 55860 {
lab=GND}
N 550 55800 550 55850 {
lab=Y6}
N 550 55850 550 55860 {
lab=Y6}
N 570 55860 600 55860 {
lab=GND}
N 600 55850 600 55860 {
lab=GND}
N 560 55810 600 55810 {
lab=word930}
N 600 55810 640 55810 {
lab=word930}
N 570 55800 570 55850 {
lab=GND}
N 570 55850 570 55860 {
lab=GND}
N 630 55800 630 55850 {
lab=Y7}
N 630 55850 630 55860 {
lab=Y7}
N 10 55920 40 55920 {
lab=GND}
N 40 55910 40 55920 {
lab=GND}
N 0 55870 40 55870 {
lab=word931}
N 40 55870 80 55870 {
lab=word931}
N 10 55860 10 55910 {
lab=GND}
N 10 55910 10 55920 {
lab=GND}
N 70 55860 70 55910 {
lab=Y0}
N 70 55910 70 55920 {
lab=Y0}
N 90 55920 120 55920 {
lab=GND}
N 120 55910 120 55920 {
lab=GND}
N 80 55870 120 55870 {
lab=word931}
N 120 55870 160 55870 {
lab=word931}
N 90 55860 90 55910 {
lab=GND}
N 90 55910 90 55920 {
lab=GND}
N 150 55860 150 55910 {
lab=Y1}
N 150 55910 150 55920 {
lab=Y1}
N 160 55870 200 55870 {
lab=word931}
N 200 55870 240 55870 {
lab=word931}
N 170 55860 170 55910 {
lab=GND}
N 170 55910 170 55920 {
lab=GND}
N 230 55860 230 55910 {
lab=Y2}
N 230 55910 230 55920 {
lab=Y2}
N 250 55920 280 55920 {
lab=GND}
N 280 55910 280 55920 {
lab=GND}
N 240 55870 280 55870 {
lab=word931}
N 280 55870 320 55870 {
lab=word931}
N 250 55860 250 55910 {
lab=GND}
N 250 55910 250 55920 {
lab=GND}
N 310 55860 310 55910 {
lab=Y3}
N 310 55910 310 55920 {
lab=Y3}
N 320 55870 360 55870 {
lab=word931}
N 360 55870 400 55870 {
lab=word931}
N 330 55860 330 55910 {
lab=GND}
N 330 55910 330 55920 {
lab=GND}
N 390 55860 390 55910 {
lab=Y4}
N 390 55910 390 55920 {
lab=Y4}
N 400 55870 440 55870 {
lab=word931}
N 440 55870 480 55870 {
lab=word931}
N 410 55860 410 55910 {
lab=GND}
N 410 55910 410 55920 {
lab=GND}
N 470 55860 470 55910 {
lab=Y5}
N 470 55910 470 55920 {
lab=Y5}
N 490 55920 520 55920 {
lab=GND}
N 520 55910 520 55920 {
lab=GND}
N 480 55870 520 55870 {
lab=word931}
N 520 55870 560 55870 {
lab=word931}
N 490 55860 490 55910 {
lab=GND}
N 490 55910 490 55920 {
lab=GND}
N 550 55860 550 55910 {
lab=Y6}
N 550 55910 550 55920 {
lab=Y6}
N 570 55920 600 55920 {
lab=GND}
N 600 55910 600 55920 {
lab=GND}
N 560 55870 600 55870 {
lab=word931}
N 600 55870 640 55870 {
lab=word931}
N 570 55860 570 55910 {
lab=GND}
N 570 55910 570 55920 {
lab=GND}
N 630 55860 630 55910 {
lab=Y7}
N 630 55910 630 55920 {
lab=Y7}
N 10 55980 40 55980 {
lab=GND}
N 40 55970 40 55980 {
lab=GND}
N 0 55930 40 55930 {
lab=word932}
N 40 55930 80 55930 {
lab=word932}
N 10 55920 10 55970 {
lab=GND}
N 10 55970 10 55980 {
lab=GND}
N 70 55920 70 55970 {
lab=Y0}
N 70 55970 70 55980 {
lab=Y0}
N 90 55980 120 55980 {
lab=GND}
N 120 55970 120 55980 {
lab=GND}
N 80 55930 120 55930 {
lab=word932}
N 120 55930 160 55930 {
lab=word932}
N 90 55920 90 55970 {
lab=GND}
N 90 55970 90 55980 {
lab=GND}
N 150 55920 150 55970 {
lab=Y1}
N 150 55970 150 55980 {
lab=Y1}
N 160 55930 200 55930 {
lab=word932}
N 200 55930 240 55930 {
lab=word932}
N 170 55920 170 55970 {
lab=GND}
N 170 55970 170 55980 {
lab=GND}
N 230 55920 230 55970 {
lab=Y2}
N 230 55970 230 55980 {
lab=Y2}
N 250 55980 280 55980 {
lab=GND}
N 280 55970 280 55980 {
lab=GND}
N 240 55930 280 55930 {
lab=word932}
N 280 55930 320 55930 {
lab=word932}
N 250 55920 250 55970 {
lab=GND}
N 250 55970 250 55980 {
lab=GND}
N 310 55920 310 55970 {
lab=Y3}
N 310 55970 310 55980 {
lab=Y3}
N 320 55930 360 55930 {
lab=word932}
N 360 55930 400 55930 {
lab=word932}
N 330 55920 330 55970 {
lab=GND}
N 330 55970 330 55980 {
lab=GND}
N 390 55920 390 55970 {
lab=Y4}
N 390 55970 390 55980 {
lab=Y4}
N 400 55930 440 55930 {
lab=word932}
N 440 55930 480 55930 {
lab=word932}
N 410 55920 410 55970 {
lab=GND}
N 410 55970 410 55980 {
lab=GND}
N 470 55920 470 55970 {
lab=Y5}
N 470 55970 470 55980 {
lab=Y5}
N 480 55930 520 55930 {
lab=word932}
N 520 55930 560 55930 {
lab=word932}
N 490 55920 490 55970 {
lab=GND}
N 490 55970 490 55980 {
lab=GND}
N 550 55920 550 55970 {
lab=Y6}
N 550 55970 550 55980 {
lab=Y6}
N 560 55930 600 55930 {
lab=word932}
N 600 55930 640 55930 {
lab=word932}
N 570 55920 570 55970 {
lab=GND}
N 570 55970 570 55980 {
lab=GND}
N 630 55920 630 55970 {
lab=Y7}
N 630 55970 630 55980 {
lab=Y7}
N 10 56040 40 56040 {
lab=GND}
N 40 56030 40 56040 {
lab=GND}
N 0 55990 40 55990 {
lab=word933}
N 40 55990 80 55990 {
lab=word933}
N 10 55980 10 56030 {
lab=GND}
N 10 56030 10 56040 {
lab=GND}
N 70 55980 70 56030 {
lab=Y0}
N 70 56030 70 56040 {
lab=Y0}
N 90 56040 120 56040 {
lab=GND}
N 120 56030 120 56040 {
lab=GND}
N 80 55990 120 55990 {
lab=word933}
N 120 55990 160 55990 {
lab=word933}
N 90 55980 90 56030 {
lab=GND}
N 90 56030 90 56040 {
lab=GND}
N 150 55980 150 56030 {
lab=Y1}
N 150 56030 150 56040 {
lab=Y1}
N 160 55990 200 55990 {
lab=word933}
N 200 55990 240 55990 {
lab=word933}
N 170 55980 170 56030 {
lab=GND}
N 170 56030 170 56040 {
lab=GND}
N 230 55980 230 56030 {
lab=Y2}
N 230 56030 230 56040 {
lab=Y2}
N 240 55990 280 55990 {
lab=word933}
N 280 55990 320 55990 {
lab=word933}
N 250 55980 250 56030 {
lab=GND}
N 250 56030 250 56040 {
lab=GND}
N 310 55980 310 56030 {
lab=Y3}
N 310 56030 310 56040 {
lab=Y3}
N 330 56040 360 56040 {
lab=GND}
N 360 56030 360 56040 {
lab=GND}
N 320 55990 360 55990 {
lab=word933}
N 360 55990 400 55990 {
lab=word933}
N 330 55980 330 56030 {
lab=GND}
N 330 56030 330 56040 {
lab=GND}
N 390 55980 390 56030 {
lab=Y4}
N 390 56030 390 56040 {
lab=Y4}
N 410 56040 440 56040 {
lab=GND}
N 440 56030 440 56040 {
lab=GND}
N 400 55990 440 55990 {
lab=word933}
N 440 55990 480 55990 {
lab=word933}
N 410 55980 410 56030 {
lab=GND}
N 410 56030 410 56040 {
lab=GND}
N 470 55980 470 56030 {
lab=Y5}
N 470 56030 470 56040 {
lab=Y5}
N 490 56040 520 56040 {
lab=GND}
N 520 56030 520 56040 {
lab=GND}
N 480 55990 520 55990 {
lab=word933}
N 520 55990 560 55990 {
lab=word933}
N 490 55980 490 56030 {
lab=GND}
N 490 56030 490 56040 {
lab=GND}
N 550 55980 550 56030 {
lab=Y6}
N 550 56030 550 56040 {
lab=Y6}
N 560 55990 600 55990 {
lab=word933}
N 600 55990 640 55990 {
lab=word933}
N 570 55980 570 56030 {
lab=GND}
N 570 56030 570 56040 {
lab=GND}
N 630 55980 630 56030 {
lab=Y7}
N 630 56030 630 56040 {
lab=Y7}
N 10 56100 40 56100 {
lab=GND}
N 40 56090 40 56100 {
lab=GND}
N 0 56050 40 56050 {
lab=word934}
N 40 56050 80 56050 {
lab=word934}
N 10 56040 10 56090 {
lab=GND}
N 10 56090 10 56100 {
lab=GND}
N 70 56040 70 56090 {
lab=Y0}
N 70 56090 70 56100 {
lab=Y0}
N 90 56100 120 56100 {
lab=GND}
N 120 56090 120 56100 {
lab=GND}
N 80 56050 120 56050 {
lab=word934}
N 120 56050 160 56050 {
lab=word934}
N 90 56040 90 56090 {
lab=GND}
N 90 56090 90 56100 {
lab=GND}
N 150 56040 150 56090 {
lab=Y1}
N 150 56090 150 56100 {
lab=Y1}
N 160 56050 200 56050 {
lab=word934}
N 200 56050 240 56050 {
lab=word934}
N 170 56040 170 56090 {
lab=GND}
N 170 56090 170 56100 {
lab=GND}
N 230 56040 230 56090 {
lab=Y2}
N 230 56090 230 56100 {
lab=Y2}
N 240 56050 280 56050 {
lab=word934}
N 280 56050 320 56050 {
lab=word934}
N 250 56040 250 56090 {
lab=GND}
N 250 56090 250 56100 {
lab=GND}
N 310 56040 310 56090 {
lab=Y3}
N 310 56090 310 56100 {
lab=Y3}
N 330 56100 360 56100 {
lab=GND}
N 360 56090 360 56100 {
lab=GND}
N 320 56050 360 56050 {
lab=word934}
N 360 56050 400 56050 {
lab=word934}
N 330 56040 330 56090 {
lab=GND}
N 330 56090 330 56100 {
lab=GND}
N 390 56040 390 56090 {
lab=Y4}
N 390 56090 390 56100 {
lab=Y4}
N 400 56050 440 56050 {
lab=word934}
N 440 56050 480 56050 {
lab=word934}
N 410 56040 410 56090 {
lab=GND}
N 410 56090 410 56100 {
lab=GND}
N 470 56040 470 56090 {
lab=Y5}
N 470 56090 470 56100 {
lab=Y5}
N 490 56100 520 56100 {
lab=GND}
N 520 56090 520 56100 {
lab=GND}
N 480 56050 520 56050 {
lab=word934}
N 520 56050 560 56050 {
lab=word934}
N 490 56040 490 56090 {
lab=GND}
N 490 56090 490 56100 {
lab=GND}
N 550 56040 550 56090 {
lab=Y6}
N 550 56090 550 56100 {
lab=Y6}
N 570 56100 600 56100 {
lab=GND}
N 600 56090 600 56100 {
lab=GND}
N 560 56050 600 56050 {
lab=word934}
N 600 56050 640 56050 {
lab=word934}
N 570 56040 570 56090 {
lab=GND}
N 570 56090 570 56100 {
lab=GND}
N 630 56040 630 56090 {
lab=Y7}
N 630 56090 630 56100 {
lab=Y7}
N 10 56160 40 56160 {
lab=GND}
N 40 56150 40 56160 {
lab=GND}
N 0 56110 40 56110 {
lab=word935}
N 40 56110 80 56110 {
lab=word935}
N 10 56100 10 56150 {
lab=GND}
N 10 56150 10 56160 {
lab=GND}
N 70 56100 70 56150 {
lab=Y0}
N 70 56150 70 56160 {
lab=Y0}
N 90 56160 120 56160 {
lab=GND}
N 120 56150 120 56160 {
lab=GND}
N 80 56110 120 56110 {
lab=word935}
N 120 56110 160 56110 {
lab=word935}
N 90 56100 90 56150 {
lab=GND}
N 90 56150 90 56160 {
lab=GND}
N 150 56100 150 56150 {
lab=Y1}
N 150 56150 150 56160 {
lab=Y1}
N 160 56110 200 56110 {
lab=word935}
N 200 56110 240 56110 {
lab=word935}
N 170 56100 170 56150 {
lab=GND}
N 170 56150 170 56160 {
lab=GND}
N 230 56100 230 56150 {
lab=Y2}
N 230 56150 230 56160 {
lab=Y2}
N 240 56110 280 56110 {
lab=word935}
N 280 56110 320 56110 {
lab=word935}
N 250 56100 250 56150 {
lab=GND}
N 250 56150 250 56160 {
lab=GND}
N 310 56100 310 56150 {
lab=Y3}
N 310 56150 310 56160 {
lab=Y3}
N 330 56160 360 56160 {
lab=GND}
N 360 56150 360 56160 {
lab=GND}
N 320 56110 360 56110 {
lab=word935}
N 360 56110 400 56110 {
lab=word935}
N 330 56100 330 56150 {
lab=GND}
N 330 56150 330 56160 {
lab=GND}
N 390 56100 390 56150 {
lab=Y4}
N 390 56150 390 56160 {
lab=Y4}
N 400 56110 440 56110 {
lab=word935}
N 440 56110 480 56110 {
lab=word935}
N 410 56100 410 56150 {
lab=GND}
N 410 56150 410 56160 {
lab=GND}
N 470 56100 470 56150 {
lab=Y5}
N 470 56150 470 56160 {
lab=Y5}
N 480 56110 520 56110 {
lab=word935}
N 520 56110 560 56110 {
lab=word935}
N 490 56100 490 56150 {
lab=GND}
N 490 56150 490 56160 {
lab=GND}
N 550 56100 550 56150 {
lab=Y6}
N 550 56150 550 56160 {
lab=Y6}
N 570 56160 600 56160 {
lab=GND}
N 600 56150 600 56160 {
lab=GND}
N 560 56110 600 56110 {
lab=word935}
N 600 56110 640 56110 {
lab=word935}
N 570 56100 570 56150 {
lab=GND}
N 570 56150 570 56160 {
lab=GND}
N 630 56100 630 56150 {
lab=Y7}
N 630 56150 630 56160 {
lab=Y7}
N 10 56220 40 56220 {
lab=GND}
N 40 56210 40 56220 {
lab=GND}
N 0 56170 40 56170 {
lab=word936}
N 40 56170 80 56170 {
lab=word936}
N 10 56160 10 56210 {
lab=GND}
N 10 56210 10 56220 {
lab=GND}
N 70 56160 70 56210 {
lab=Y0}
N 70 56210 70 56220 {
lab=Y0}
N 90 56220 120 56220 {
lab=GND}
N 120 56210 120 56220 {
lab=GND}
N 80 56170 120 56170 {
lab=word936}
N 120 56170 160 56170 {
lab=word936}
N 90 56160 90 56210 {
lab=GND}
N 90 56210 90 56220 {
lab=GND}
N 150 56160 150 56210 {
lab=Y1}
N 150 56210 150 56220 {
lab=Y1}
N 160 56170 200 56170 {
lab=word936}
N 200 56170 240 56170 {
lab=word936}
N 170 56160 170 56210 {
lab=GND}
N 170 56210 170 56220 {
lab=GND}
N 230 56160 230 56210 {
lab=Y2}
N 230 56210 230 56220 {
lab=Y2}
N 240 56170 280 56170 {
lab=word936}
N 280 56170 320 56170 {
lab=word936}
N 250 56160 250 56210 {
lab=GND}
N 250 56210 250 56220 {
lab=GND}
N 310 56160 310 56210 {
lab=Y3}
N 310 56210 310 56220 {
lab=Y3}
N 320 56170 360 56170 {
lab=word936}
N 360 56170 400 56170 {
lab=word936}
N 330 56160 330 56210 {
lab=GND}
N 330 56210 330 56220 {
lab=GND}
N 390 56160 390 56210 {
lab=Y4}
N 390 56210 390 56220 {
lab=Y4}
N 410 56220 440 56220 {
lab=GND}
N 440 56210 440 56220 {
lab=GND}
N 400 56170 440 56170 {
lab=word936}
N 440 56170 480 56170 {
lab=word936}
N 410 56160 410 56210 {
lab=GND}
N 410 56210 410 56220 {
lab=GND}
N 470 56160 470 56210 {
lab=Y5}
N 470 56210 470 56220 {
lab=Y5}
N 490 56220 520 56220 {
lab=GND}
N 520 56210 520 56220 {
lab=GND}
N 480 56170 520 56170 {
lab=word936}
N 520 56170 560 56170 {
lab=word936}
N 490 56160 490 56210 {
lab=GND}
N 490 56210 490 56220 {
lab=GND}
N 550 56160 550 56210 {
lab=Y6}
N 550 56210 550 56220 {
lab=Y6}
N 560 56170 600 56170 {
lab=word936}
N 600 56170 640 56170 {
lab=word936}
N 570 56160 570 56210 {
lab=GND}
N 570 56210 570 56220 {
lab=GND}
N 630 56160 630 56210 {
lab=Y7}
N 630 56210 630 56220 {
lab=Y7}
N 10 56280 40 56280 {
lab=GND}
N 40 56270 40 56280 {
lab=GND}
N 0 56230 40 56230 {
lab=word937}
N 40 56230 80 56230 {
lab=word937}
N 10 56220 10 56270 {
lab=GND}
N 10 56270 10 56280 {
lab=GND}
N 70 56220 70 56270 {
lab=Y0}
N 70 56270 70 56280 {
lab=Y0}
N 90 56280 120 56280 {
lab=GND}
N 120 56270 120 56280 {
lab=GND}
N 80 56230 120 56230 {
lab=word937}
N 120 56230 160 56230 {
lab=word937}
N 90 56220 90 56270 {
lab=GND}
N 90 56270 90 56280 {
lab=GND}
N 150 56220 150 56270 {
lab=Y1}
N 150 56270 150 56280 {
lab=Y1}
N 160 56230 200 56230 {
lab=word937}
N 200 56230 240 56230 {
lab=word937}
N 170 56220 170 56270 {
lab=GND}
N 170 56270 170 56280 {
lab=GND}
N 230 56220 230 56270 {
lab=Y2}
N 230 56270 230 56280 {
lab=Y2}
N 240 56230 280 56230 {
lab=word937}
N 280 56230 320 56230 {
lab=word937}
N 250 56220 250 56270 {
lab=GND}
N 250 56270 250 56280 {
lab=GND}
N 310 56220 310 56270 {
lab=Y3}
N 310 56270 310 56280 {
lab=Y3}
N 320 56230 360 56230 {
lab=word937}
N 360 56230 400 56230 {
lab=word937}
N 330 56220 330 56270 {
lab=GND}
N 330 56270 330 56280 {
lab=GND}
N 390 56220 390 56270 {
lab=Y4}
N 390 56270 390 56280 {
lab=Y4}
N 410 56280 440 56280 {
lab=GND}
N 440 56270 440 56280 {
lab=GND}
N 400 56230 440 56230 {
lab=word937}
N 440 56230 480 56230 {
lab=word937}
N 410 56220 410 56270 {
lab=GND}
N 410 56270 410 56280 {
lab=GND}
N 470 56220 470 56270 {
lab=Y5}
N 470 56270 470 56280 {
lab=Y5}
N 480 56230 520 56230 {
lab=word937}
N 520 56230 560 56230 {
lab=word937}
N 490 56220 490 56270 {
lab=GND}
N 490 56270 490 56280 {
lab=GND}
N 550 56220 550 56270 {
lab=Y6}
N 550 56270 550 56280 {
lab=Y6}
N 560 56230 600 56230 {
lab=word937}
N 600 56230 640 56230 {
lab=word937}
N 570 56220 570 56270 {
lab=GND}
N 570 56270 570 56280 {
lab=GND}
N 630 56220 630 56270 {
lab=Y7}
N 630 56270 630 56280 {
lab=Y7}
N 10 56340 40 56340 {
lab=GND}
N 40 56330 40 56340 {
lab=GND}
N 0 56290 40 56290 {
lab=word938}
N 40 56290 80 56290 {
lab=word938}
N 10 56280 10 56330 {
lab=GND}
N 10 56330 10 56340 {
lab=GND}
N 70 56280 70 56330 {
lab=Y0}
N 70 56330 70 56340 {
lab=Y0}
N 90 56340 120 56340 {
lab=GND}
N 120 56330 120 56340 {
lab=GND}
N 80 56290 120 56290 {
lab=word938}
N 120 56290 160 56290 {
lab=word938}
N 90 56280 90 56330 {
lab=GND}
N 90 56330 90 56340 {
lab=GND}
N 150 56280 150 56330 {
lab=Y1}
N 150 56330 150 56340 {
lab=Y1}
N 160 56290 200 56290 {
lab=word938}
N 200 56290 240 56290 {
lab=word938}
N 170 56280 170 56330 {
lab=GND}
N 170 56330 170 56340 {
lab=GND}
N 230 56280 230 56330 {
lab=Y2}
N 230 56330 230 56340 {
lab=Y2}
N 240 56290 280 56290 {
lab=word938}
N 280 56290 320 56290 {
lab=word938}
N 250 56280 250 56330 {
lab=GND}
N 250 56330 250 56340 {
lab=GND}
N 310 56280 310 56330 {
lab=Y3}
N 310 56330 310 56340 {
lab=Y3}
N 320 56290 360 56290 {
lab=word938}
N 360 56290 400 56290 {
lab=word938}
N 330 56280 330 56330 {
lab=GND}
N 330 56330 330 56340 {
lab=GND}
N 390 56280 390 56330 {
lab=Y4}
N 390 56330 390 56340 {
lab=Y4}
N 400 56290 440 56290 {
lab=word938}
N 440 56290 480 56290 {
lab=word938}
N 410 56280 410 56330 {
lab=GND}
N 410 56330 410 56340 {
lab=GND}
N 470 56280 470 56330 {
lab=Y5}
N 470 56330 470 56340 {
lab=Y5}
N 480 56290 520 56290 {
lab=word938}
N 520 56290 560 56290 {
lab=word938}
N 490 56280 490 56330 {
lab=GND}
N 490 56330 490 56340 {
lab=GND}
N 550 56280 550 56330 {
lab=Y6}
N 550 56330 550 56340 {
lab=Y6}
N 570 56340 600 56340 {
lab=GND}
N 600 56330 600 56340 {
lab=GND}
N 560 56290 600 56290 {
lab=word938}
N 600 56290 640 56290 {
lab=word938}
N 570 56280 570 56330 {
lab=GND}
N 570 56330 570 56340 {
lab=GND}
N 630 56280 630 56330 {
lab=Y7}
N 630 56330 630 56340 {
lab=Y7}
N 10 56400 40 56400 {
lab=GND}
N 40 56390 40 56400 {
lab=GND}
N 0 56350 40 56350 {
lab=word939}
N 40 56350 80 56350 {
lab=word939}
N 10 56340 10 56390 {
lab=GND}
N 10 56390 10 56400 {
lab=GND}
N 70 56340 70 56390 {
lab=Y0}
N 70 56390 70 56400 {
lab=Y0}
N 80 56350 120 56350 {
lab=word939}
N 120 56350 160 56350 {
lab=word939}
N 90 56340 90 56390 {
lab=GND}
N 90 56390 90 56400 {
lab=GND}
N 150 56340 150 56390 {
lab=Y1}
N 150 56390 150 56400 {
lab=Y1}
N 170 56400 200 56400 {
lab=GND}
N 200 56390 200 56400 {
lab=GND}
N 160 56350 200 56350 {
lab=word939}
N 200 56350 240 56350 {
lab=word939}
N 170 56340 170 56390 {
lab=GND}
N 170 56390 170 56400 {
lab=GND}
N 230 56340 230 56390 {
lab=Y2}
N 230 56390 230 56400 {
lab=Y2}
N 250 56400 280 56400 {
lab=GND}
N 280 56390 280 56400 {
lab=GND}
N 240 56350 280 56350 {
lab=word939}
N 280 56350 320 56350 {
lab=word939}
N 250 56340 250 56390 {
lab=GND}
N 250 56390 250 56400 {
lab=GND}
N 310 56340 310 56390 {
lab=Y3}
N 310 56390 310 56400 {
lab=Y3}
N 330 56400 360 56400 {
lab=GND}
N 360 56390 360 56400 {
lab=GND}
N 320 56350 360 56350 {
lab=word939}
N 360 56350 400 56350 {
lab=word939}
N 330 56340 330 56390 {
lab=GND}
N 330 56390 330 56400 {
lab=GND}
N 390 56340 390 56390 {
lab=Y4}
N 390 56390 390 56400 {
lab=Y4}
N 410 56400 440 56400 {
lab=GND}
N 440 56390 440 56400 {
lab=GND}
N 400 56350 440 56350 {
lab=word939}
N 440 56350 480 56350 {
lab=word939}
N 410 56340 410 56390 {
lab=GND}
N 410 56390 410 56400 {
lab=GND}
N 470 56340 470 56390 {
lab=Y5}
N 470 56390 470 56400 {
lab=Y5}
N 490 56400 520 56400 {
lab=GND}
N 520 56390 520 56400 {
lab=GND}
N 480 56350 520 56350 {
lab=word939}
N 520 56350 560 56350 {
lab=word939}
N 490 56340 490 56390 {
lab=GND}
N 490 56390 490 56400 {
lab=GND}
N 550 56340 550 56390 {
lab=Y6}
N 550 56390 550 56400 {
lab=Y6}
N 560 56350 600 56350 {
lab=word939}
N 600 56350 640 56350 {
lab=word939}
N 570 56340 570 56390 {
lab=GND}
N 570 56390 570 56400 {
lab=GND}
N 630 56340 630 56390 {
lab=Y7}
N 630 56390 630 56400 {
lab=Y7}
N 10 56460 40 56460 {
lab=GND}
N 40 56450 40 56460 {
lab=GND}
N 0 56410 40 56410 {
lab=word940}
N 40 56410 80 56410 {
lab=word940}
N 10 56400 10 56450 {
lab=GND}
N 10 56450 10 56460 {
lab=GND}
N 70 56400 70 56450 {
lab=Y0}
N 70 56450 70 56460 {
lab=Y0}
N 80 56410 120 56410 {
lab=word940}
N 120 56410 160 56410 {
lab=word940}
N 90 56400 90 56450 {
lab=GND}
N 90 56450 90 56460 {
lab=GND}
N 150 56400 150 56450 {
lab=Y1}
N 150 56450 150 56460 {
lab=Y1}
N 170 56460 200 56460 {
lab=GND}
N 200 56450 200 56460 {
lab=GND}
N 160 56410 200 56410 {
lab=word940}
N 200 56410 240 56410 {
lab=word940}
N 170 56400 170 56450 {
lab=GND}
N 170 56450 170 56460 {
lab=GND}
N 230 56400 230 56450 {
lab=Y2}
N 230 56450 230 56460 {
lab=Y2}
N 250 56460 280 56460 {
lab=GND}
N 280 56450 280 56460 {
lab=GND}
N 240 56410 280 56410 {
lab=word940}
N 280 56410 320 56410 {
lab=word940}
N 250 56400 250 56450 {
lab=GND}
N 250 56450 250 56460 {
lab=GND}
N 310 56400 310 56450 {
lab=Y3}
N 310 56450 310 56460 {
lab=Y3}
N 330 56460 360 56460 {
lab=GND}
N 360 56450 360 56460 {
lab=GND}
N 320 56410 360 56410 {
lab=word940}
N 360 56410 400 56410 {
lab=word940}
N 330 56400 330 56450 {
lab=GND}
N 330 56450 330 56460 {
lab=GND}
N 390 56400 390 56450 {
lab=Y4}
N 390 56450 390 56460 {
lab=Y4}
N 410 56460 440 56460 {
lab=GND}
N 440 56450 440 56460 {
lab=GND}
N 400 56410 440 56410 {
lab=word940}
N 440 56410 480 56410 {
lab=word940}
N 410 56400 410 56450 {
lab=GND}
N 410 56450 410 56460 {
lab=GND}
N 470 56400 470 56450 {
lab=Y5}
N 470 56450 470 56460 {
lab=Y5}
N 480 56410 520 56410 {
lab=word940}
N 520 56410 560 56410 {
lab=word940}
N 490 56400 490 56450 {
lab=GND}
N 490 56450 490 56460 {
lab=GND}
N 550 56400 550 56450 {
lab=Y6}
N 550 56450 550 56460 {
lab=Y6}
N 560 56410 600 56410 {
lab=word940}
N 600 56410 640 56410 {
lab=word940}
N 570 56400 570 56450 {
lab=GND}
N 570 56450 570 56460 {
lab=GND}
N 630 56400 630 56450 {
lab=Y7}
N 630 56450 630 56460 {
lab=Y7}
N 10 56520 40 56520 {
lab=GND}
N 40 56510 40 56520 {
lab=GND}
N 0 56470 40 56470 {
lab=word941}
N 40 56470 80 56470 {
lab=word941}
N 10 56460 10 56510 {
lab=GND}
N 10 56510 10 56520 {
lab=GND}
N 70 56460 70 56510 {
lab=Y0}
N 70 56510 70 56520 {
lab=Y0}
N 80 56470 120 56470 {
lab=word941}
N 120 56470 160 56470 {
lab=word941}
N 90 56460 90 56510 {
lab=GND}
N 90 56510 90 56520 {
lab=GND}
N 150 56460 150 56510 {
lab=Y1}
N 150 56510 150 56520 {
lab=Y1}
N 170 56520 200 56520 {
lab=GND}
N 200 56510 200 56520 {
lab=GND}
N 160 56470 200 56470 {
lab=word941}
N 200 56470 240 56470 {
lab=word941}
N 170 56460 170 56510 {
lab=GND}
N 170 56510 170 56520 {
lab=GND}
N 230 56460 230 56510 {
lab=Y2}
N 230 56510 230 56520 {
lab=Y2}
N 250 56520 280 56520 {
lab=GND}
N 280 56510 280 56520 {
lab=GND}
N 240 56470 280 56470 {
lab=word941}
N 280 56470 320 56470 {
lab=word941}
N 250 56460 250 56510 {
lab=GND}
N 250 56510 250 56520 {
lab=GND}
N 310 56460 310 56510 {
lab=Y3}
N 310 56510 310 56520 {
lab=Y3}
N 330 56520 360 56520 {
lab=GND}
N 360 56510 360 56520 {
lab=GND}
N 320 56470 360 56470 {
lab=word941}
N 360 56470 400 56470 {
lab=word941}
N 330 56460 330 56510 {
lab=GND}
N 330 56510 330 56520 {
lab=GND}
N 390 56460 390 56510 {
lab=Y4}
N 390 56510 390 56520 {
lab=Y4}
N 400 56470 440 56470 {
lab=word941}
N 440 56470 480 56470 {
lab=word941}
N 410 56460 410 56510 {
lab=GND}
N 410 56510 410 56520 {
lab=GND}
N 470 56460 470 56510 {
lab=Y5}
N 470 56510 470 56520 {
lab=Y5}
N 480 56470 520 56470 {
lab=word941}
N 520 56470 560 56470 {
lab=word941}
N 490 56460 490 56510 {
lab=GND}
N 490 56510 490 56520 {
lab=GND}
N 550 56460 550 56510 {
lab=Y6}
N 550 56510 550 56520 {
lab=Y6}
N 570 56520 600 56520 {
lab=GND}
N 600 56510 600 56520 {
lab=GND}
N 560 56470 600 56470 {
lab=word941}
N 600 56470 640 56470 {
lab=word941}
N 570 56460 570 56510 {
lab=GND}
N 570 56510 570 56520 {
lab=GND}
N 630 56460 630 56510 {
lab=Y7}
N 630 56510 630 56520 {
lab=Y7}
N 10 56580 40 56580 {
lab=GND}
N 40 56570 40 56580 {
lab=GND}
N 0 56530 40 56530 {
lab=word942}
N 40 56530 80 56530 {
lab=word942}
N 10 56520 10 56570 {
lab=GND}
N 10 56570 10 56580 {
lab=GND}
N 70 56520 70 56570 {
lab=Y0}
N 70 56570 70 56580 {
lab=Y0}
N 80 56530 120 56530 {
lab=word942}
N 120 56530 160 56530 {
lab=word942}
N 90 56520 90 56570 {
lab=GND}
N 90 56570 90 56580 {
lab=GND}
N 150 56520 150 56570 {
lab=Y1}
N 150 56570 150 56580 {
lab=Y1}
N 170 56580 200 56580 {
lab=GND}
N 200 56570 200 56580 {
lab=GND}
N 160 56530 200 56530 {
lab=word942}
N 200 56530 240 56530 {
lab=word942}
N 170 56520 170 56570 {
lab=GND}
N 170 56570 170 56580 {
lab=GND}
N 230 56520 230 56570 {
lab=Y2}
N 230 56570 230 56580 {
lab=Y2}
N 250 56580 280 56580 {
lab=GND}
N 280 56570 280 56580 {
lab=GND}
N 240 56530 280 56530 {
lab=word942}
N 280 56530 320 56530 {
lab=word942}
N 250 56520 250 56570 {
lab=GND}
N 250 56570 250 56580 {
lab=GND}
N 310 56520 310 56570 {
lab=Y3}
N 310 56570 310 56580 {
lab=Y3}
N 320 56530 360 56530 {
lab=word942}
N 360 56530 400 56530 {
lab=word942}
N 330 56520 330 56570 {
lab=GND}
N 330 56570 330 56580 {
lab=GND}
N 390 56520 390 56570 {
lab=Y4}
N 390 56570 390 56580 {
lab=Y4}
N 410 56580 440 56580 {
lab=GND}
N 440 56570 440 56580 {
lab=GND}
N 400 56530 440 56530 {
lab=word942}
N 440 56530 480 56530 {
lab=word942}
N 410 56520 410 56570 {
lab=GND}
N 410 56570 410 56580 {
lab=GND}
N 470 56520 470 56570 {
lab=Y5}
N 470 56570 470 56580 {
lab=Y5}
N 490 56580 520 56580 {
lab=GND}
N 520 56570 520 56580 {
lab=GND}
N 480 56530 520 56530 {
lab=word942}
N 520 56530 560 56530 {
lab=word942}
N 490 56520 490 56570 {
lab=GND}
N 490 56570 490 56580 {
lab=GND}
N 550 56520 550 56570 {
lab=Y6}
N 550 56570 550 56580 {
lab=Y6}
N 560 56530 600 56530 {
lab=word942}
N 600 56530 640 56530 {
lab=word942}
N 570 56520 570 56570 {
lab=GND}
N 570 56570 570 56580 {
lab=GND}
N 630 56520 630 56570 {
lab=Y7}
N 630 56570 630 56580 {
lab=Y7}
N 10 56640 40 56640 {
lab=GND}
N 40 56630 40 56640 {
lab=GND}
N 0 56590 40 56590 {
lab=word943}
N 40 56590 80 56590 {
lab=word943}
N 10 56580 10 56630 {
lab=GND}
N 10 56630 10 56640 {
lab=GND}
N 70 56580 70 56630 {
lab=Y0}
N 70 56630 70 56640 {
lab=Y0}
N 80 56590 120 56590 {
lab=word943}
N 120 56590 160 56590 {
lab=word943}
N 90 56580 90 56630 {
lab=GND}
N 90 56630 90 56640 {
lab=GND}
N 150 56580 150 56630 {
lab=Y1}
N 150 56630 150 56640 {
lab=Y1}
N 170 56640 200 56640 {
lab=GND}
N 200 56630 200 56640 {
lab=GND}
N 160 56590 200 56590 {
lab=word943}
N 200 56590 240 56590 {
lab=word943}
N 170 56580 170 56630 {
lab=GND}
N 170 56630 170 56640 {
lab=GND}
N 230 56580 230 56630 {
lab=Y2}
N 230 56630 230 56640 {
lab=Y2}
N 250 56640 280 56640 {
lab=GND}
N 280 56630 280 56640 {
lab=GND}
N 240 56590 280 56590 {
lab=word943}
N 280 56590 320 56590 {
lab=word943}
N 250 56580 250 56630 {
lab=GND}
N 250 56630 250 56640 {
lab=GND}
N 310 56580 310 56630 {
lab=Y3}
N 310 56630 310 56640 {
lab=Y3}
N 320 56590 360 56590 {
lab=word943}
N 360 56590 400 56590 {
lab=word943}
N 330 56580 330 56630 {
lab=GND}
N 330 56630 330 56640 {
lab=GND}
N 390 56580 390 56630 {
lab=Y4}
N 390 56630 390 56640 {
lab=Y4}
N 400 56590 440 56590 {
lab=word943}
N 440 56590 480 56590 {
lab=word943}
N 410 56580 410 56630 {
lab=GND}
N 410 56630 410 56640 {
lab=GND}
N 470 56580 470 56630 {
lab=Y5}
N 470 56630 470 56640 {
lab=Y5}
N 490 56640 520 56640 {
lab=GND}
N 520 56630 520 56640 {
lab=GND}
N 480 56590 520 56590 {
lab=word943}
N 520 56590 560 56590 {
lab=word943}
N 490 56580 490 56630 {
lab=GND}
N 490 56630 490 56640 {
lab=GND}
N 550 56580 550 56630 {
lab=Y6}
N 550 56630 550 56640 {
lab=Y6}
N 570 56640 600 56640 {
lab=GND}
N 600 56630 600 56640 {
lab=GND}
N 560 56590 600 56590 {
lab=word943}
N 600 56590 640 56590 {
lab=word943}
N 570 56580 570 56630 {
lab=GND}
N 570 56630 570 56640 {
lab=GND}
N 630 56580 630 56630 {
lab=Y7}
N 630 56630 630 56640 {
lab=Y7}
N 10 56700 40 56700 {
lab=GND}
N 40 56690 40 56700 {
lab=GND}
N 0 56650 40 56650 {
lab=word944}
N 40 56650 80 56650 {
lab=word944}
N 10 56640 10 56690 {
lab=GND}
N 10 56690 10 56700 {
lab=GND}
N 70 56640 70 56690 {
lab=Y0}
N 70 56690 70 56700 {
lab=Y0}
N 80 56650 120 56650 {
lab=word944}
N 120 56650 160 56650 {
lab=word944}
N 90 56640 90 56690 {
lab=GND}
N 90 56690 90 56700 {
lab=GND}
N 150 56640 150 56690 {
lab=Y1}
N 150 56690 150 56700 {
lab=Y1}
N 170 56700 200 56700 {
lab=GND}
N 200 56690 200 56700 {
lab=GND}
N 160 56650 200 56650 {
lab=word944}
N 200 56650 240 56650 {
lab=word944}
N 170 56640 170 56690 {
lab=GND}
N 170 56690 170 56700 {
lab=GND}
N 230 56640 230 56690 {
lab=Y2}
N 230 56690 230 56700 {
lab=Y2}
N 250 56700 280 56700 {
lab=GND}
N 280 56690 280 56700 {
lab=GND}
N 240 56650 280 56650 {
lab=word944}
N 280 56650 320 56650 {
lab=word944}
N 250 56640 250 56690 {
lab=GND}
N 250 56690 250 56700 {
lab=GND}
N 310 56640 310 56690 {
lab=Y3}
N 310 56690 310 56700 {
lab=Y3}
N 320 56650 360 56650 {
lab=word944}
N 360 56650 400 56650 {
lab=word944}
N 330 56640 330 56690 {
lab=GND}
N 330 56690 330 56700 {
lab=GND}
N 390 56640 390 56690 {
lab=Y4}
N 390 56690 390 56700 {
lab=Y4}
N 400 56650 440 56650 {
lab=word944}
N 440 56650 480 56650 {
lab=word944}
N 410 56640 410 56690 {
lab=GND}
N 410 56690 410 56700 {
lab=GND}
N 470 56640 470 56690 {
lab=Y5}
N 470 56690 470 56700 {
lab=Y5}
N 480 56650 520 56650 {
lab=word944}
N 520 56650 560 56650 {
lab=word944}
N 490 56640 490 56690 {
lab=GND}
N 490 56690 490 56700 {
lab=GND}
N 550 56640 550 56690 {
lab=Y6}
N 550 56690 550 56700 {
lab=Y6}
N 560 56650 600 56650 {
lab=word944}
N 600 56650 640 56650 {
lab=word944}
N 570 56640 570 56690 {
lab=GND}
N 570 56690 570 56700 {
lab=GND}
N 630 56640 630 56690 {
lab=Y7}
N 630 56690 630 56700 {
lab=Y7}
N 10 56760 40 56760 {
lab=GND}
N 40 56750 40 56760 {
lab=GND}
N 0 56710 40 56710 {
lab=word945}
N 40 56710 80 56710 {
lab=word945}
N 10 56700 10 56750 {
lab=GND}
N 10 56750 10 56760 {
lab=GND}
N 70 56700 70 56750 {
lab=Y0}
N 70 56750 70 56760 {
lab=Y0}
N 80 56710 120 56710 {
lab=word945}
N 120 56710 160 56710 {
lab=word945}
N 90 56700 90 56750 {
lab=GND}
N 90 56750 90 56760 {
lab=GND}
N 150 56700 150 56750 {
lab=Y1}
N 150 56750 150 56760 {
lab=Y1}
N 170 56760 200 56760 {
lab=GND}
N 200 56750 200 56760 {
lab=GND}
N 160 56710 200 56710 {
lab=word945}
N 200 56710 240 56710 {
lab=word945}
N 170 56700 170 56750 {
lab=GND}
N 170 56750 170 56760 {
lab=GND}
N 230 56700 230 56750 {
lab=Y2}
N 230 56750 230 56760 {
lab=Y2}
N 240 56710 280 56710 {
lab=word945}
N 280 56710 320 56710 {
lab=word945}
N 250 56700 250 56750 {
lab=GND}
N 250 56750 250 56760 {
lab=GND}
N 310 56700 310 56750 {
lab=Y3}
N 310 56750 310 56760 {
lab=Y3}
N 330 56760 360 56760 {
lab=GND}
N 360 56750 360 56760 {
lab=GND}
N 320 56710 360 56710 {
lab=word945}
N 360 56710 400 56710 {
lab=word945}
N 330 56700 330 56750 {
lab=GND}
N 330 56750 330 56760 {
lab=GND}
N 390 56700 390 56750 {
lab=Y4}
N 390 56750 390 56760 {
lab=Y4}
N 410 56760 440 56760 {
lab=GND}
N 440 56750 440 56760 {
lab=GND}
N 400 56710 440 56710 {
lab=word945}
N 440 56710 480 56710 {
lab=word945}
N 410 56700 410 56750 {
lab=GND}
N 410 56750 410 56760 {
lab=GND}
N 470 56700 470 56750 {
lab=Y5}
N 470 56750 470 56760 {
lab=Y5}
N 480 56710 520 56710 {
lab=word945}
N 520 56710 560 56710 {
lab=word945}
N 490 56700 490 56750 {
lab=GND}
N 490 56750 490 56760 {
lab=GND}
N 550 56700 550 56750 {
lab=Y6}
N 550 56750 550 56760 {
lab=Y6}
N 570 56760 600 56760 {
lab=GND}
N 600 56750 600 56760 {
lab=GND}
N 560 56710 600 56710 {
lab=word945}
N 600 56710 640 56710 {
lab=word945}
N 570 56700 570 56750 {
lab=GND}
N 570 56750 570 56760 {
lab=GND}
N 630 56700 630 56750 {
lab=Y7}
N 630 56750 630 56760 {
lab=Y7}
N 10 56820 40 56820 {
lab=GND}
N 40 56810 40 56820 {
lab=GND}
N 0 56770 40 56770 {
lab=word946}
N 40 56770 80 56770 {
lab=word946}
N 10 56760 10 56810 {
lab=GND}
N 10 56810 10 56820 {
lab=GND}
N 70 56760 70 56810 {
lab=Y0}
N 70 56810 70 56820 {
lab=Y0}
N 80 56770 120 56770 {
lab=word946}
N 120 56770 160 56770 {
lab=word946}
N 90 56760 90 56810 {
lab=GND}
N 90 56810 90 56820 {
lab=GND}
N 150 56760 150 56810 {
lab=Y1}
N 150 56810 150 56820 {
lab=Y1}
N 170 56820 200 56820 {
lab=GND}
N 200 56810 200 56820 {
lab=GND}
N 160 56770 200 56770 {
lab=word946}
N 200 56770 240 56770 {
lab=word946}
N 170 56760 170 56810 {
lab=GND}
N 170 56810 170 56820 {
lab=GND}
N 230 56760 230 56810 {
lab=Y2}
N 230 56810 230 56820 {
lab=Y2}
N 240 56770 280 56770 {
lab=word946}
N 280 56770 320 56770 {
lab=word946}
N 250 56760 250 56810 {
lab=GND}
N 250 56810 250 56820 {
lab=GND}
N 310 56760 310 56810 {
lab=Y3}
N 310 56810 310 56820 {
lab=Y3}
N 330 56820 360 56820 {
lab=GND}
N 360 56810 360 56820 {
lab=GND}
N 320 56770 360 56770 {
lab=word946}
N 360 56770 400 56770 {
lab=word946}
N 330 56760 330 56810 {
lab=GND}
N 330 56810 330 56820 {
lab=GND}
N 390 56760 390 56810 {
lab=Y4}
N 390 56810 390 56820 {
lab=Y4}
N 400 56770 440 56770 {
lab=word946}
N 440 56770 480 56770 {
lab=word946}
N 410 56760 410 56810 {
lab=GND}
N 410 56810 410 56820 {
lab=GND}
N 470 56760 470 56810 {
lab=Y5}
N 470 56810 470 56820 {
lab=Y5}
N 490 56820 520 56820 {
lab=GND}
N 520 56810 520 56820 {
lab=GND}
N 480 56770 520 56770 {
lab=word946}
N 520 56770 560 56770 {
lab=word946}
N 490 56760 490 56810 {
lab=GND}
N 490 56810 490 56820 {
lab=GND}
N 550 56760 550 56810 {
lab=Y6}
N 550 56810 550 56820 {
lab=Y6}
N 560 56770 600 56770 {
lab=word946}
N 600 56770 640 56770 {
lab=word946}
N 570 56760 570 56810 {
lab=GND}
N 570 56810 570 56820 {
lab=GND}
N 630 56760 630 56810 {
lab=Y7}
N 630 56810 630 56820 {
lab=Y7}
N 10 56880 40 56880 {
lab=GND}
N 40 56870 40 56880 {
lab=GND}
N 0 56830 40 56830 {
lab=word947}
N 40 56830 80 56830 {
lab=word947}
N 10 56820 10 56870 {
lab=GND}
N 10 56870 10 56880 {
lab=GND}
N 70 56820 70 56870 {
lab=Y0}
N 70 56870 70 56880 {
lab=Y0}
N 80 56830 120 56830 {
lab=word947}
N 120 56830 160 56830 {
lab=word947}
N 90 56820 90 56870 {
lab=GND}
N 90 56870 90 56880 {
lab=GND}
N 150 56820 150 56870 {
lab=Y1}
N 150 56870 150 56880 {
lab=Y1}
N 170 56880 200 56880 {
lab=GND}
N 200 56870 200 56880 {
lab=GND}
N 160 56830 200 56830 {
lab=word947}
N 200 56830 240 56830 {
lab=word947}
N 170 56820 170 56870 {
lab=GND}
N 170 56870 170 56880 {
lab=GND}
N 230 56820 230 56870 {
lab=Y2}
N 230 56870 230 56880 {
lab=Y2}
N 240 56830 280 56830 {
lab=word947}
N 280 56830 320 56830 {
lab=word947}
N 250 56820 250 56870 {
lab=GND}
N 250 56870 250 56880 {
lab=GND}
N 310 56820 310 56870 {
lab=Y3}
N 310 56870 310 56880 {
lab=Y3}
N 320 56830 360 56830 {
lab=word947}
N 360 56830 400 56830 {
lab=word947}
N 330 56820 330 56870 {
lab=GND}
N 330 56870 330 56880 {
lab=GND}
N 390 56820 390 56870 {
lab=Y4}
N 390 56870 390 56880 {
lab=Y4}
N 410 56880 440 56880 {
lab=GND}
N 440 56870 440 56880 {
lab=GND}
N 400 56830 440 56830 {
lab=word947}
N 440 56830 480 56830 {
lab=word947}
N 410 56820 410 56870 {
lab=GND}
N 410 56870 410 56880 {
lab=GND}
N 470 56820 470 56870 {
lab=Y5}
N 470 56870 470 56880 {
lab=Y5}
N 490 56880 520 56880 {
lab=GND}
N 520 56870 520 56880 {
lab=GND}
N 480 56830 520 56830 {
lab=word947}
N 520 56830 560 56830 {
lab=word947}
N 490 56820 490 56870 {
lab=GND}
N 490 56870 490 56880 {
lab=GND}
N 550 56820 550 56870 {
lab=Y6}
N 550 56870 550 56880 {
lab=Y6}
N 570 56880 600 56880 {
lab=GND}
N 600 56870 600 56880 {
lab=GND}
N 560 56830 600 56830 {
lab=word947}
N 600 56830 640 56830 {
lab=word947}
N 570 56820 570 56870 {
lab=GND}
N 570 56870 570 56880 {
lab=GND}
N 630 56820 630 56870 {
lab=Y7}
N 630 56870 630 56880 {
lab=Y7}
N 10 56940 40 56940 {
lab=GND}
N 40 56930 40 56940 {
lab=GND}
N 0 56890 40 56890 {
lab=word948}
N 40 56890 80 56890 {
lab=word948}
N 10 56880 10 56930 {
lab=GND}
N 10 56930 10 56940 {
lab=GND}
N 70 56880 70 56930 {
lab=Y0}
N 70 56930 70 56940 {
lab=Y0}
N 80 56890 120 56890 {
lab=word948}
N 120 56890 160 56890 {
lab=word948}
N 90 56880 90 56930 {
lab=GND}
N 90 56930 90 56940 {
lab=GND}
N 150 56880 150 56930 {
lab=Y1}
N 150 56930 150 56940 {
lab=Y1}
N 170 56940 200 56940 {
lab=GND}
N 200 56930 200 56940 {
lab=GND}
N 160 56890 200 56890 {
lab=word948}
N 200 56890 240 56890 {
lab=word948}
N 170 56880 170 56930 {
lab=GND}
N 170 56930 170 56940 {
lab=GND}
N 230 56880 230 56930 {
lab=Y2}
N 230 56930 230 56940 {
lab=Y2}
N 240 56890 280 56890 {
lab=word948}
N 280 56890 320 56890 {
lab=word948}
N 250 56880 250 56930 {
lab=GND}
N 250 56930 250 56940 {
lab=GND}
N 310 56880 310 56930 {
lab=Y3}
N 310 56930 310 56940 {
lab=Y3}
N 320 56890 360 56890 {
lab=word948}
N 360 56890 400 56890 {
lab=word948}
N 330 56880 330 56930 {
lab=GND}
N 330 56930 330 56940 {
lab=GND}
N 390 56880 390 56930 {
lab=Y4}
N 390 56930 390 56940 {
lab=Y4}
N 410 56940 440 56940 {
lab=GND}
N 440 56930 440 56940 {
lab=GND}
N 400 56890 440 56890 {
lab=word948}
N 440 56890 480 56890 {
lab=word948}
N 410 56880 410 56930 {
lab=GND}
N 410 56930 410 56940 {
lab=GND}
N 470 56880 470 56930 {
lab=Y5}
N 470 56930 470 56940 {
lab=Y5}
N 480 56890 520 56890 {
lab=word948}
N 520 56890 560 56890 {
lab=word948}
N 490 56880 490 56930 {
lab=GND}
N 490 56930 490 56940 {
lab=GND}
N 550 56880 550 56930 {
lab=Y6}
N 550 56930 550 56940 {
lab=Y6}
N 570 56940 600 56940 {
lab=GND}
N 600 56930 600 56940 {
lab=GND}
N 560 56890 600 56890 {
lab=word948}
N 600 56890 640 56890 {
lab=word948}
N 570 56880 570 56930 {
lab=GND}
N 570 56930 570 56940 {
lab=GND}
N 630 56880 630 56930 {
lab=Y7}
N 630 56930 630 56940 {
lab=Y7}
N 10 57000 40 57000 {
lab=GND}
N 40 56990 40 57000 {
lab=GND}
N 0 56950 40 56950 {
lab=word949}
N 40 56950 80 56950 {
lab=word949}
N 10 56940 10 56990 {
lab=GND}
N 10 56990 10 57000 {
lab=GND}
N 70 56940 70 56990 {
lab=Y0}
N 70 56990 70 57000 {
lab=Y0}
N 80 56950 120 56950 {
lab=word949}
N 120 56950 160 56950 {
lab=word949}
N 90 56940 90 56990 {
lab=GND}
N 90 56990 90 57000 {
lab=GND}
N 150 56940 150 56990 {
lab=Y1}
N 150 56990 150 57000 {
lab=Y1}
N 170 57000 200 57000 {
lab=GND}
N 200 56990 200 57000 {
lab=GND}
N 160 56950 200 56950 {
lab=word949}
N 200 56950 240 56950 {
lab=word949}
N 170 56940 170 56990 {
lab=GND}
N 170 56990 170 57000 {
lab=GND}
N 230 56940 230 56990 {
lab=Y2}
N 230 56990 230 57000 {
lab=Y2}
N 240 56950 280 56950 {
lab=word949}
N 280 56950 320 56950 {
lab=word949}
N 250 56940 250 56990 {
lab=GND}
N 250 56990 250 57000 {
lab=GND}
N 310 56940 310 56990 {
lab=Y3}
N 310 56990 310 57000 {
lab=Y3}
N 320 56950 360 56950 {
lab=word949}
N 360 56950 400 56950 {
lab=word949}
N 330 56940 330 56990 {
lab=GND}
N 330 56990 330 57000 {
lab=GND}
N 390 56940 390 56990 {
lab=Y4}
N 390 56990 390 57000 {
lab=Y4}
N 400 56950 440 56950 {
lab=word949}
N 440 56950 480 56950 {
lab=word949}
N 410 56940 410 56990 {
lab=GND}
N 410 56990 410 57000 {
lab=GND}
N 470 56940 470 56990 {
lab=Y5}
N 470 56990 470 57000 {
lab=Y5}
N 490 57000 520 57000 {
lab=GND}
N 520 56990 520 57000 {
lab=GND}
N 480 56950 520 56950 {
lab=word949}
N 520 56950 560 56950 {
lab=word949}
N 490 56940 490 56990 {
lab=GND}
N 490 56990 490 57000 {
lab=GND}
N 550 56940 550 56990 {
lab=Y6}
N 550 56990 550 57000 {
lab=Y6}
N 560 56950 600 56950 {
lab=word949}
N 600 56950 640 56950 {
lab=word949}
N 570 56940 570 56990 {
lab=GND}
N 570 56990 570 57000 {
lab=GND}
N 630 56940 630 56990 {
lab=Y7}
N 630 56990 630 57000 {
lab=Y7}
N 10 57060 40 57060 {
lab=GND}
N 40 57050 40 57060 {
lab=GND}
N 0 57010 40 57010 {
lab=word950}
N 40 57010 80 57010 {
lab=word950}
N 10 57000 10 57050 {
lab=GND}
N 10 57050 10 57060 {
lab=GND}
N 70 57000 70 57050 {
lab=Y0}
N 70 57050 70 57060 {
lab=Y0}
N 80 57010 120 57010 {
lab=word950}
N 120 57010 160 57010 {
lab=word950}
N 90 57000 90 57050 {
lab=GND}
N 90 57050 90 57060 {
lab=GND}
N 150 57000 150 57050 {
lab=Y1}
N 150 57050 150 57060 {
lab=Y1}
N 160 57010 200 57010 {
lab=word950}
N 200 57010 240 57010 {
lab=word950}
N 170 57000 170 57050 {
lab=GND}
N 170 57050 170 57060 {
lab=GND}
N 230 57000 230 57050 {
lab=Y2}
N 230 57050 230 57060 {
lab=Y2}
N 250 57060 280 57060 {
lab=GND}
N 280 57050 280 57060 {
lab=GND}
N 240 57010 280 57010 {
lab=word950}
N 280 57010 320 57010 {
lab=word950}
N 250 57000 250 57050 {
lab=GND}
N 250 57050 250 57060 {
lab=GND}
N 310 57000 310 57050 {
lab=Y3}
N 310 57050 310 57060 {
lab=Y3}
N 330 57060 360 57060 {
lab=GND}
N 360 57050 360 57060 {
lab=GND}
N 320 57010 360 57010 {
lab=word950}
N 360 57010 400 57010 {
lab=word950}
N 330 57000 330 57050 {
lab=GND}
N 330 57050 330 57060 {
lab=GND}
N 390 57000 390 57050 {
lab=Y4}
N 390 57050 390 57060 {
lab=Y4}
N 410 57060 440 57060 {
lab=GND}
N 440 57050 440 57060 {
lab=GND}
N 400 57010 440 57010 {
lab=word950}
N 440 57010 480 57010 {
lab=word950}
N 410 57000 410 57050 {
lab=GND}
N 410 57050 410 57060 {
lab=GND}
N 470 57000 470 57050 {
lab=Y5}
N 470 57050 470 57060 {
lab=Y5}
N 490 57060 520 57060 {
lab=GND}
N 520 57050 520 57060 {
lab=GND}
N 480 57010 520 57010 {
lab=word950}
N 520 57010 560 57010 {
lab=word950}
N 490 57000 490 57050 {
lab=GND}
N 490 57050 490 57060 {
lab=GND}
N 550 57000 550 57050 {
lab=Y6}
N 550 57050 550 57060 {
lab=Y6}
N 560 57010 600 57010 {
lab=word950}
N 600 57010 640 57010 {
lab=word950}
N 570 57000 570 57050 {
lab=GND}
N 570 57050 570 57060 {
lab=GND}
N 630 57000 630 57050 {
lab=Y7}
N 630 57050 630 57060 {
lab=Y7}
N 10 57120 40 57120 {
lab=GND}
N 40 57110 40 57120 {
lab=GND}
N 0 57070 40 57070 {
lab=word951}
N 40 57070 80 57070 {
lab=word951}
N 10 57060 10 57110 {
lab=GND}
N 10 57110 10 57120 {
lab=GND}
N 70 57060 70 57110 {
lab=Y0}
N 70 57110 70 57120 {
lab=Y0}
N 80 57070 120 57070 {
lab=word951}
N 120 57070 160 57070 {
lab=word951}
N 90 57060 90 57110 {
lab=GND}
N 90 57110 90 57120 {
lab=GND}
N 150 57060 150 57110 {
lab=Y1}
N 150 57110 150 57120 {
lab=Y1}
N 160 57070 200 57070 {
lab=word951}
N 200 57070 240 57070 {
lab=word951}
N 170 57060 170 57110 {
lab=GND}
N 170 57110 170 57120 {
lab=GND}
N 230 57060 230 57110 {
lab=Y2}
N 230 57110 230 57120 {
lab=Y2}
N 250 57120 280 57120 {
lab=GND}
N 280 57110 280 57120 {
lab=GND}
N 240 57070 280 57070 {
lab=word951}
N 280 57070 320 57070 {
lab=word951}
N 250 57060 250 57110 {
lab=GND}
N 250 57110 250 57120 {
lab=GND}
N 310 57060 310 57110 {
lab=Y3}
N 310 57110 310 57120 {
lab=Y3}
N 330 57120 360 57120 {
lab=GND}
N 360 57110 360 57120 {
lab=GND}
N 320 57070 360 57070 {
lab=word951}
N 360 57070 400 57070 {
lab=word951}
N 330 57060 330 57110 {
lab=GND}
N 330 57110 330 57120 {
lab=GND}
N 390 57060 390 57110 {
lab=Y4}
N 390 57110 390 57120 {
lab=Y4}
N 400 57070 440 57070 {
lab=word951}
N 440 57070 480 57070 {
lab=word951}
N 410 57060 410 57110 {
lab=GND}
N 410 57110 410 57120 {
lab=GND}
N 470 57060 470 57110 {
lab=Y5}
N 470 57110 470 57120 {
lab=Y5}
N 490 57120 520 57120 {
lab=GND}
N 520 57110 520 57120 {
lab=GND}
N 480 57070 520 57070 {
lab=word951}
N 520 57070 560 57070 {
lab=word951}
N 490 57060 490 57110 {
lab=GND}
N 490 57110 490 57120 {
lab=GND}
N 550 57060 550 57110 {
lab=Y6}
N 550 57110 550 57120 {
lab=Y6}
N 570 57120 600 57120 {
lab=GND}
N 600 57110 600 57120 {
lab=GND}
N 560 57070 600 57070 {
lab=word951}
N 600 57070 640 57070 {
lab=word951}
N 570 57060 570 57110 {
lab=GND}
N 570 57110 570 57120 {
lab=GND}
N 630 57060 630 57110 {
lab=Y7}
N 630 57110 630 57120 {
lab=Y7}
N 10 57180 40 57180 {
lab=GND}
N 40 57170 40 57180 {
lab=GND}
N 0 57130 40 57130 {
lab=word952}
N 40 57130 80 57130 {
lab=word952}
N 10 57120 10 57170 {
lab=GND}
N 10 57170 10 57180 {
lab=GND}
N 70 57120 70 57170 {
lab=Y0}
N 70 57170 70 57180 {
lab=Y0}
N 80 57130 120 57130 {
lab=word952}
N 120 57130 160 57130 {
lab=word952}
N 90 57120 90 57170 {
lab=GND}
N 90 57170 90 57180 {
lab=GND}
N 150 57120 150 57170 {
lab=Y1}
N 150 57170 150 57180 {
lab=Y1}
N 160 57130 200 57130 {
lab=word952}
N 200 57130 240 57130 {
lab=word952}
N 170 57120 170 57170 {
lab=GND}
N 170 57170 170 57180 {
lab=GND}
N 230 57120 230 57170 {
lab=Y2}
N 230 57170 230 57180 {
lab=Y2}
N 250 57180 280 57180 {
lab=GND}
N 280 57170 280 57180 {
lab=GND}
N 240 57130 280 57130 {
lab=word952}
N 280 57130 320 57130 {
lab=word952}
N 250 57120 250 57170 {
lab=GND}
N 250 57170 250 57180 {
lab=GND}
N 310 57120 310 57170 {
lab=Y3}
N 310 57170 310 57180 {
lab=Y3}
N 330 57180 360 57180 {
lab=GND}
N 360 57170 360 57180 {
lab=GND}
N 320 57130 360 57130 {
lab=word952}
N 360 57130 400 57130 {
lab=word952}
N 330 57120 330 57170 {
lab=GND}
N 330 57170 330 57180 {
lab=GND}
N 390 57120 390 57170 {
lab=Y4}
N 390 57170 390 57180 {
lab=Y4}
N 400 57130 440 57130 {
lab=word952}
N 440 57130 480 57130 {
lab=word952}
N 410 57120 410 57170 {
lab=GND}
N 410 57170 410 57180 {
lab=GND}
N 470 57120 470 57170 {
lab=Y5}
N 470 57170 470 57180 {
lab=Y5}
N 480 57130 520 57130 {
lab=word952}
N 520 57130 560 57130 {
lab=word952}
N 490 57120 490 57170 {
lab=GND}
N 490 57170 490 57180 {
lab=GND}
N 550 57120 550 57170 {
lab=Y6}
N 550 57170 550 57180 {
lab=Y6}
N 560 57130 600 57130 {
lab=word952}
N 600 57130 640 57130 {
lab=word952}
N 570 57120 570 57170 {
lab=GND}
N 570 57170 570 57180 {
lab=GND}
N 630 57120 630 57170 {
lab=Y7}
N 630 57170 630 57180 {
lab=Y7}
N 10 57240 40 57240 {
lab=GND}
N 40 57230 40 57240 {
lab=GND}
N 0 57190 40 57190 {
lab=word953}
N 40 57190 80 57190 {
lab=word953}
N 10 57180 10 57230 {
lab=GND}
N 10 57230 10 57240 {
lab=GND}
N 70 57180 70 57230 {
lab=Y0}
N 70 57230 70 57240 {
lab=Y0}
N 80 57190 120 57190 {
lab=word953}
N 120 57190 160 57190 {
lab=word953}
N 90 57180 90 57230 {
lab=GND}
N 90 57230 90 57240 {
lab=GND}
N 150 57180 150 57230 {
lab=Y1}
N 150 57230 150 57240 {
lab=Y1}
N 160 57190 200 57190 {
lab=word953}
N 200 57190 240 57190 {
lab=word953}
N 170 57180 170 57230 {
lab=GND}
N 170 57230 170 57240 {
lab=GND}
N 230 57180 230 57230 {
lab=Y2}
N 230 57230 230 57240 {
lab=Y2}
N 250 57240 280 57240 {
lab=GND}
N 280 57230 280 57240 {
lab=GND}
N 240 57190 280 57190 {
lab=word953}
N 280 57190 320 57190 {
lab=word953}
N 250 57180 250 57230 {
lab=GND}
N 250 57230 250 57240 {
lab=GND}
N 310 57180 310 57230 {
lab=Y3}
N 310 57230 310 57240 {
lab=Y3}
N 320 57190 360 57190 {
lab=word953}
N 360 57190 400 57190 {
lab=word953}
N 330 57180 330 57230 {
lab=GND}
N 330 57230 330 57240 {
lab=GND}
N 390 57180 390 57230 {
lab=Y4}
N 390 57230 390 57240 {
lab=Y4}
N 410 57240 440 57240 {
lab=GND}
N 440 57230 440 57240 {
lab=GND}
N 400 57190 440 57190 {
lab=word953}
N 440 57190 480 57190 {
lab=word953}
N 410 57180 410 57230 {
lab=GND}
N 410 57230 410 57240 {
lab=GND}
N 470 57180 470 57230 {
lab=Y5}
N 470 57230 470 57240 {
lab=Y5}
N 480 57190 520 57190 {
lab=word953}
N 520 57190 560 57190 {
lab=word953}
N 490 57180 490 57230 {
lab=GND}
N 490 57230 490 57240 {
lab=GND}
N 550 57180 550 57230 {
lab=Y6}
N 550 57230 550 57240 {
lab=Y6}
N 570 57240 600 57240 {
lab=GND}
N 600 57230 600 57240 {
lab=GND}
N 560 57190 600 57190 {
lab=word953}
N 600 57190 640 57190 {
lab=word953}
N 570 57180 570 57230 {
lab=GND}
N 570 57230 570 57240 {
lab=GND}
N 630 57180 630 57230 {
lab=Y7}
N 630 57230 630 57240 {
lab=Y7}
N 10 57300 40 57300 {
lab=GND}
N 40 57290 40 57300 {
lab=GND}
N 0 57250 40 57250 {
lab=word954}
N 40 57250 80 57250 {
lab=word954}
N 10 57240 10 57290 {
lab=GND}
N 10 57290 10 57300 {
lab=GND}
N 70 57240 70 57290 {
lab=Y0}
N 70 57290 70 57300 {
lab=Y0}
N 80 57250 120 57250 {
lab=word954}
N 120 57250 160 57250 {
lab=word954}
N 90 57240 90 57290 {
lab=GND}
N 90 57290 90 57300 {
lab=GND}
N 150 57240 150 57290 {
lab=Y1}
N 150 57290 150 57300 {
lab=Y1}
N 160 57250 200 57250 {
lab=word954}
N 200 57250 240 57250 {
lab=word954}
N 170 57240 170 57290 {
lab=GND}
N 170 57290 170 57300 {
lab=GND}
N 230 57240 230 57290 {
lab=Y2}
N 230 57290 230 57300 {
lab=Y2}
N 250 57300 280 57300 {
lab=GND}
N 280 57290 280 57300 {
lab=GND}
N 240 57250 280 57250 {
lab=word954}
N 280 57250 320 57250 {
lab=word954}
N 250 57240 250 57290 {
lab=GND}
N 250 57290 250 57300 {
lab=GND}
N 310 57240 310 57290 {
lab=Y3}
N 310 57290 310 57300 {
lab=Y3}
N 320 57250 360 57250 {
lab=word954}
N 360 57250 400 57250 {
lab=word954}
N 330 57240 330 57290 {
lab=GND}
N 330 57290 330 57300 {
lab=GND}
N 390 57240 390 57290 {
lab=Y4}
N 390 57290 390 57300 {
lab=Y4}
N 400 57250 440 57250 {
lab=word954}
N 440 57250 480 57250 {
lab=word954}
N 410 57240 410 57290 {
lab=GND}
N 410 57290 410 57300 {
lab=GND}
N 470 57240 470 57290 {
lab=Y5}
N 470 57290 470 57300 {
lab=Y5}
N 490 57300 520 57300 {
lab=GND}
N 520 57290 520 57300 {
lab=GND}
N 480 57250 520 57250 {
lab=word954}
N 520 57250 560 57250 {
lab=word954}
N 490 57240 490 57290 {
lab=GND}
N 490 57290 490 57300 {
lab=GND}
N 550 57240 550 57290 {
lab=Y6}
N 550 57290 550 57300 {
lab=Y6}
N 560 57250 600 57250 {
lab=word954}
N 600 57250 640 57250 {
lab=word954}
N 570 57240 570 57290 {
lab=GND}
N 570 57290 570 57300 {
lab=GND}
N 630 57240 630 57290 {
lab=Y7}
N 630 57290 630 57300 {
lab=Y7}
N 10 57360 40 57360 {
lab=GND}
N 40 57350 40 57360 {
lab=GND}
N 0 57310 40 57310 {
lab=word955}
N 40 57310 80 57310 {
lab=word955}
N 10 57300 10 57350 {
lab=GND}
N 10 57350 10 57360 {
lab=GND}
N 70 57300 70 57350 {
lab=Y0}
N 70 57350 70 57360 {
lab=Y0}
N 80 57310 120 57310 {
lab=word955}
N 120 57310 160 57310 {
lab=word955}
N 90 57300 90 57350 {
lab=GND}
N 90 57350 90 57360 {
lab=GND}
N 150 57300 150 57350 {
lab=Y1}
N 150 57350 150 57360 {
lab=Y1}
N 160 57310 200 57310 {
lab=word955}
N 200 57310 240 57310 {
lab=word955}
N 170 57300 170 57350 {
lab=GND}
N 170 57350 170 57360 {
lab=GND}
N 230 57300 230 57350 {
lab=Y2}
N 230 57350 230 57360 {
lab=Y2}
N 240 57310 280 57310 {
lab=word955}
N 280 57310 320 57310 {
lab=word955}
N 250 57300 250 57350 {
lab=GND}
N 250 57350 250 57360 {
lab=GND}
N 310 57300 310 57350 {
lab=Y3}
N 310 57350 310 57360 {
lab=Y3}
N 330 57360 360 57360 {
lab=GND}
N 360 57350 360 57360 {
lab=GND}
N 320 57310 360 57310 {
lab=word955}
N 360 57310 400 57310 {
lab=word955}
N 330 57300 330 57350 {
lab=GND}
N 330 57350 330 57360 {
lab=GND}
N 390 57300 390 57350 {
lab=Y4}
N 390 57350 390 57360 {
lab=Y4}
N 410 57360 440 57360 {
lab=GND}
N 440 57350 440 57360 {
lab=GND}
N 400 57310 440 57310 {
lab=word955}
N 440 57310 480 57310 {
lab=word955}
N 410 57300 410 57350 {
lab=GND}
N 410 57350 410 57360 {
lab=GND}
N 470 57300 470 57350 {
lab=Y5}
N 470 57350 470 57360 {
lab=Y5}
N 490 57360 520 57360 {
lab=GND}
N 520 57350 520 57360 {
lab=GND}
N 480 57310 520 57310 {
lab=word955}
N 520 57310 560 57310 {
lab=word955}
N 490 57300 490 57350 {
lab=GND}
N 490 57350 490 57360 {
lab=GND}
N 550 57300 550 57350 {
lab=Y6}
N 550 57350 550 57360 {
lab=Y6}
N 570 57360 600 57360 {
lab=GND}
N 600 57350 600 57360 {
lab=GND}
N 560 57310 600 57310 {
lab=word955}
N 600 57310 640 57310 {
lab=word955}
N 570 57300 570 57350 {
lab=GND}
N 570 57350 570 57360 {
lab=GND}
N 630 57300 630 57350 {
lab=Y7}
N 630 57350 630 57360 {
lab=Y7}
N 10 57420 40 57420 {
lab=GND}
N 40 57410 40 57420 {
lab=GND}
N 0 57370 40 57370 {
lab=word956}
N 40 57370 80 57370 {
lab=word956}
N 10 57360 10 57410 {
lab=GND}
N 10 57410 10 57420 {
lab=GND}
N 70 57360 70 57410 {
lab=Y0}
N 70 57410 70 57420 {
lab=Y0}
N 80 57370 120 57370 {
lab=word956}
N 120 57370 160 57370 {
lab=word956}
N 90 57360 90 57410 {
lab=GND}
N 90 57410 90 57420 {
lab=GND}
N 150 57360 150 57410 {
lab=Y1}
N 150 57410 150 57420 {
lab=Y1}
N 160 57370 200 57370 {
lab=word956}
N 200 57370 240 57370 {
lab=word956}
N 170 57360 170 57410 {
lab=GND}
N 170 57410 170 57420 {
lab=GND}
N 230 57360 230 57410 {
lab=Y2}
N 230 57410 230 57420 {
lab=Y2}
N 240 57370 280 57370 {
lab=word956}
N 280 57370 320 57370 {
lab=word956}
N 250 57360 250 57410 {
lab=GND}
N 250 57410 250 57420 {
lab=GND}
N 310 57360 310 57410 {
lab=Y3}
N 310 57410 310 57420 {
lab=Y3}
N 330 57420 360 57420 {
lab=GND}
N 360 57410 360 57420 {
lab=GND}
N 320 57370 360 57370 {
lab=word956}
N 360 57370 400 57370 {
lab=word956}
N 330 57360 330 57410 {
lab=GND}
N 330 57410 330 57420 {
lab=GND}
N 390 57360 390 57410 {
lab=Y4}
N 390 57410 390 57420 {
lab=Y4}
N 410 57420 440 57420 {
lab=GND}
N 440 57410 440 57420 {
lab=GND}
N 400 57370 440 57370 {
lab=word956}
N 440 57370 480 57370 {
lab=word956}
N 410 57360 410 57410 {
lab=GND}
N 410 57410 410 57420 {
lab=GND}
N 470 57360 470 57410 {
lab=Y5}
N 470 57410 470 57420 {
lab=Y5}
N 480 57370 520 57370 {
lab=word956}
N 520 57370 560 57370 {
lab=word956}
N 490 57360 490 57410 {
lab=GND}
N 490 57410 490 57420 {
lab=GND}
N 550 57360 550 57410 {
lab=Y6}
N 550 57410 550 57420 {
lab=Y6}
N 560 57370 600 57370 {
lab=word956}
N 600 57370 640 57370 {
lab=word956}
N 570 57360 570 57410 {
lab=GND}
N 570 57410 570 57420 {
lab=GND}
N 630 57360 630 57410 {
lab=Y7}
N 630 57410 630 57420 {
lab=Y7}
N 10 57480 40 57480 {
lab=GND}
N 40 57470 40 57480 {
lab=GND}
N 0 57430 40 57430 {
lab=word957}
N 40 57430 80 57430 {
lab=word957}
N 10 57420 10 57470 {
lab=GND}
N 10 57470 10 57480 {
lab=GND}
N 70 57420 70 57470 {
lab=Y0}
N 70 57470 70 57480 {
lab=Y0}
N 80 57430 120 57430 {
lab=word957}
N 120 57430 160 57430 {
lab=word957}
N 90 57420 90 57470 {
lab=GND}
N 90 57470 90 57480 {
lab=GND}
N 150 57420 150 57470 {
lab=Y1}
N 150 57470 150 57480 {
lab=Y1}
N 160 57430 200 57430 {
lab=word957}
N 200 57430 240 57430 {
lab=word957}
N 170 57420 170 57470 {
lab=GND}
N 170 57470 170 57480 {
lab=GND}
N 230 57420 230 57470 {
lab=Y2}
N 230 57470 230 57480 {
lab=Y2}
N 240 57430 280 57430 {
lab=word957}
N 280 57430 320 57430 {
lab=word957}
N 250 57420 250 57470 {
lab=GND}
N 250 57470 250 57480 {
lab=GND}
N 310 57420 310 57470 {
lab=Y3}
N 310 57470 310 57480 {
lab=Y3}
N 330 57480 360 57480 {
lab=GND}
N 360 57470 360 57480 {
lab=GND}
N 320 57430 360 57430 {
lab=word957}
N 360 57430 400 57430 {
lab=word957}
N 330 57420 330 57470 {
lab=GND}
N 330 57470 330 57480 {
lab=GND}
N 390 57420 390 57470 {
lab=Y4}
N 390 57470 390 57480 {
lab=Y4}
N 400 57430 440 57430 {
lab=word957}
N 440 57430 480 57430 {
lab=word957}
N 410 57420 410 57470 {
lab=GND}
N 410 57470 410 57480 {
lab=GND}
N 470 57420 470 57470 {
lab=Y5}
N 470 57470 470 57480 {
lab=Y5}
N 480 57430 520 57430 {
lab=word957}
N 520 57430 560 57430 {
lab=word957}
N 490 57420 490 57470 {
lab=GND}
N 490 57470 490 57480 {
lab=GND}
N 550 57420 550 57470 {
lab=Y6}
N 550 57470 550 57480 {
lab=Y6}
N 570 57480 600 57480 {
lab=GND}
N 600 57470 600 57480 {
lab=GND}
N 560 57430 600 57430 {
lab=word957}
N 600 57430 640 57430 {
lab=word957}
N 570 57420 570 57470 {
lab=GND}
N 570 57470 570 57480 {
lab=GND}
N 630 57420 630 57470 {
lab=Y7}
N 630 57470 630 57480 {
lab=Y7}
N 10 57540 40 57540 {
lab=GND}
N 40 57530 40 57540 {
lab=GND}
N 0 57490 40 57490 {
lab=word958}
N 40 57490 80 57490 {
lab=word958}
N 10 57480 10 57530 {
lab=GND}
N 10 57530 10 57540 {
lab=GND}
N 70 57480 70 57530 {
lab=Y0}
N 70 57530 70 57540 {
lab=Y0}
N 80 57490 120 57490 {
lab=word958}
N 120 57490 160 57490 {
lab=word958}
N 90 57480 90 57530 {
lab=GND}
N 90 57530 90 57540 {
lab=GND}
N 150 57480 150 57530 {
lab=Y1}
N 150 57530 150 57540 {
lab=Y1}
N 160 57490 200 57490 {
lab=word958}
N 200 57490 240 57490 {
lab=word958}
N 170 57480 170 57530 {
lab=GND}
N 170 57530 170 57540 {
lab=GND}
N 230 57480 230 57530 {
lab=Y2}
N 230 57530 230 57540 {
lab=Y2}
N 240 57490 280 57490 {
lab=word958}
N 280 57490 320 57490 {
lab=word958}
N 250 57480 250 57530 {
lab=GND}
N 250 57530 250 57540 {
lab=GND}
N 310 57480 310 57530 {
lab=Y3}
N 310 57530 310 57540 {
lab=Y3}
N 320 57490 360 57490 {
lab=word958}
N 360 57490 400 57490 {
lab=word958}
N 330 57480 330 57530 {
lab=GND}
N 330 57530 330 57540 {
lab=GND}
N 390 57480 390 57530 {
lab=Y4}
N 390 57530 390 57540 {
lab=Y4}
N 410 57540 440 57540 {
lab=GND}
N 440 57530 440 57540 {
lab=GND}
N 400 57490 440 57490 {
lab=word958}
N 440 57490 480 57490 {
lab=word958}
N 410 57480 410 57530 {
lab=GND}
N 410 57530 410 57540 {
lab=GND}
N 470 57480 470 57530 {
lab=Y5}
N 470 57530 470 57540 {
lab=Y5}
N 490 57540 520 57540 {
lab=GND}
N 520 57530 520 57540 {
lab=GND}
N 480 57490 520 57490 {
lab=word958}
N 520 57490 560 57490 {
lab=word958}
N 490 57480 490 57530 {
lab=GND}
N 490 57530 490 57540 {
lab=GND}
N 550 57480 550 57530 {
lab=Y6}
N 550 57530 550 57540 {
lab=Y6}
N 560 57490 600 57490 {
lab=word958}
N 600 57490 640 57490 {
lab=word958}
N 570 57480 570 57530 {
lab=GND}
N 570 57530 570 57540 {
lab=GND}
N 630 57480 630 57530 {
lab=Y7}
N 630 57530 630 57540 {
lab=Y7}
N 10 57600 40 57600 {
lab=GND}
N 40 57590 40 57600 {
lab=GND}
N 0 57550 40 57550 {
lab=word959}
N 40 57550 80 57550 {
lab=word959}
N 10 57540 10 57590 {
lab=GND}
N 10 57590 10 57600 {
lab=GND}
N 70 57540 70 57590 {
lab=Y0}
N 70 57590 70 57600 {
lab=Y0}
N 80 57550 120 57550 {
lab=word959}
N 120 57550 160 57550 {
lab=word959}
N 90 57540 90 57590 {
lab=GND}
N 90 57590 90 57600 {
lab=GND}
N 150 57540 150 57590 {
lab=Y1}
N 150 57590 150 57600 {
lab=Y1}
N 160 57550 200 57550 {
lab=word959}
N 200 57550 240 57550 {
lab=word959}
N 170 57540 170 57590 {
lab=GND}
N 170 57590 170 57600 {
lab=GND}
N 230 57540 230 57590 {
lab=Y2}
N 230 57590 230 57600 {
lab=Y2}
N 240 57550 280 57550 {
lab=word959}
N 280 57550 320 57550 {
lab=word959}
N 250 57540 250 57590 {
lab=GND}
N 250 57590 250 57600 {
lab=GND}
N 310 57540 310 57590 {
lab=Y3}
N 310 57590 310 57600 {
lab=Y3}
N 320 57550 360 57550 {
lab=word959}
N 360 57550 400 57550 {
lab=word959}
N 330 57540 330 57590 {
lab=GND}
N 330 57590 330 57600 {
lab=GND}
N 390 57540 390 57590 {
lab=Y4}
N 390 57590 390 57600 {
lab=Y4}
N 400 57550 440 57550 {
lab=word959}
N 440 57550 480 57550 {
lab=word959}
N 410 57540 410 57590 {
lab=GND}
N 410 57590 410 57600 {
lab=GND}
N 470 57540 470 57590 {
lab=Y5}
N 470 57590 470 57600 {
lab=Y5}
N 490 57600 520 57600 {
lab=GND}
N 520 57590 520 57600 {
lab=GND}
N 480 57550 520 57550 {
lab=word959}
N 520 57550 560 57550 {
lab=word959}
N 490 57540 490 57590 {
lab=GND}
N 490 57590 490 57600 {
lab=GND}
N 550 57540 550 57590 {
lab=Y6}
N 550 57590 550 57600 {
lab=Y6}
N 570 57600 600 57600 {
lab=GND}
N 600 57590 600 57600 {
lab=GND}
N 560 57550 600 57550 {
lab=word959}
N 600 57550 640 57550 {
lab=word959}
N 570 57540 570 57590 {
lab=GND}
N 570 57590 570 57600 {
lab=GND}
N 630 57540 630 57590 {
lab=Y7}
N 630 57590 630 57600 {
lab=Y7}
N 10 57660 40 57660 {
lab=GND}
N 40 57650 40 57660 {
lab=GND}
N 0 57610 40 57610 {
lab=word960}
N 40 57610 80 57610 {
lab=word960}
N 10 57600 10 57650 {
lab=GND}
N 10 57650 10 57660 {
lab=GND}
N 70 57600 70 57650 {
lab=Y0}
N 70 57650 70 57660 {
lab=Y0}
N 80 57610 120 57610 {
lab=word960}
N 120 57610 160 57610 {
lab=word960}
N 90 57600 90 57650 {
lab=GND}
N 90 57650 90 57660 {
lab=GND}
N 150 57600 150 57650 {
lab=Y1}
N 150 57650 150 57660 {
lab=Y1}
N 160 57610 200 57610 {
lab=word960}
N 200 57610 240 57610 {
lab=word960}
N 170 57600 170 57650 {
lab=GND}
N 170 57650 170 57660 {
lab=GND}
N 230 57600 230 57650 {
lab=Y2}
N 230 57650 230 57660 {
lab=Y2}
N 240 57610 280 57610 {
lab=word960}
N 280 57610 320 57610 {
lab=word960}
N 250 57600 250 57650 {
lab=GND}
N 250 57650 250 57660 {
lab=GND}
N 310 57600 310 57650 {
lab=Y3}
N 310 57650 310 57660 {
lab=Y3}
N 320 57610 360 57610 {
lab=word960}
N 360 57610 400 57610 {
lab=word960}
N 330 57600 330 57650 {
lab=GND}
N 330 57650 330 57660 {
lab=GND}
N 390 57600 390 57650 {
lab=Y4}
N 390 57650 390 57660 {
lab=Y4}
N 400 57610 440 57610 {
lab=word960}
N 440 57610 480 57610 {
lab=word960}
N 410 57600 410 57650 {
lab=GND}
N 410 57650 410 57660 {
lab=GND}
N 470 57600 470 57650 {
lab=Y5}
N 470 57650 470 57660 {
lab=Y5}
N 480 57610 520 57610 {
lab=word960}
N 520 57610 560 57610 {
lab=word960}
N 490 57600 490 57650 {
lab=GND}
N 490 57650 490 57660 {
lab=GND}
N 550 57600 550 57650 {
lab=Y6}
N 550 57650 550 57660 {
lab=Y6}
N 560 57610 600 57610 {
lab=word960}
N 600 57610 640 57610 {
lab=word960}
N 570 57600 570 57650 {
lab=GND}
N 570 57650 570 57660 {
lab=GND}
N 630 57600 630 57650 {
lab=Y7}
N 630 57650 630 57660 {
lab=Y7}
N 0 57670 40 57670 {
lab=word961}
N 40 57670 80 57670 {
lab=word961}
N 10 57660 10 57710 {
lab=GND}
N 10 57710 10 57720 {
lab=GND}
N 70 57660 70 57710 {
lab=Y0}
N 70 57710 70 57720 {
lab=Y0}
N 90 57720 120 57720 {
lab=GND}
N 120 57710 120 57720 {
lab=GND}
N 80 57670 120 57670 {
lab=word961}
N 120 57670 160 57670 {
lab=word961}
N 90 57660 90 57710 {
lab=GND}
N 90 57710 90 57720 {
lab=GND}
N 150 57660 150 57710 {
lab=Y1}
N 150 57710 150 57720 {
lab=Y1}
N 170 57720 200 57720 {
lab=GND}
N 200 57710 200 57720 {
lab=GND}
N 160 57670 200 57670 {
lab=word961}
N 200 57670 240 57670 {
lab=word961}
N 170 57660 170 57710 {
lab=GND}
N 170 57710 170 57720 {
lab=GND}
N 230 57660 230 57710 {
lab=Y2}
N 230 57710 230 57720 {
lab=Y2}
N 250 57720 280 57720 {
lab=GND}
N 280 57710 280 57720 {
lab=GND}
N 240 57670 280 57670 {
lab=word961}
N 280 57670 320 57670 {
lab=word961}
N 250 57660 250 57710 {
lab=GND}
N 250 57710 250 57720 {
lab=GND}
N 310 57660 310 57710 {
lab=Y3}
N 310 57710 310 57720 {
lab=Y3}
N 330 57720 360 57720 {
lab=GND}
N 360 57710 360 57720 {
lab=GND}
N 320 57670 360 57670 {
lab=word961}
N 360 57670 400 57670 {
lab=word961}
N 330 57660 330 57710 {
lab=GND}
N 330 57710 330 57720 {
lab=GND}
N 390 57660 390 57710 {
lab=Y4}
N 390 57710 390 57720 {
lab=Y4}
N 410 57720 440 57720 {
lab=GND}
N 440 57710 440 57720 {
lab=GND}
N 400 57670 440 57670 {
lab=word961}
N 440 57670 480 57670 {
lab=word961}
N 410 57660 410 57710 {
lab=GND}
N 410 57710 410 57720 {
lab=GND}
N 470 57660 470 57710 {
lab=Y5}
N 470 57710 470 57720 {
lab=Y5}
N 480 57670 520 57670 {
lab=word961}
N 520 57670 560 57670 {
lab=word961}
N 490 57660 490 57710 {
lab=GND}
N 490 57710 490 57720 {
lab=GND}
N 550 57660 550 57710 {
lab=Y6}
N 550 57710 550 57720 {
lab=Y6}
N 560 57670 600 57670 {
lab=word961}
N 600 57670 640 57670 {
lab=word961}
N 570 57660 570 57710 {
lab=GND}
N 570 57710 570 57720 {
lab=GND}
N 630 57660 630 57710 {
lab=Y7}
N 630 57710 630 57720 {
lab=Y7}
N 0 57730 40 57730 {
lab=word962}
N 40 57730 80 57730 {
lab=word962}
N 10 57720 10 57770 {
lab=GND}
N 10 57770 10 57780 {
lab=GND}
N 70 57720 70 57770 {
lab=Y0}
N 70 57770 70 57780 {
lab=Y0}
N 90 57780 120 57780 {
lab=GND}
N 120 57770 120 57780 {
lab=GND}
N 80 57730 120 57730 {
lab=word962}
N 120 57730 160 57730 {
lab=word962}
N 90 57720 90 57770 {
lab=GND}
N 90 57770 90 57780 {
lab=GND}
N 150 57720 150 57770 {
lab=Y1}
N 150 57770 150 57780 {
lab=Y1}
N 170 57780 200 57780 {
lab=GND}
N 200 57770 200 57780 {
lab=GND}
N 160 57730 200 57730 {
lab=word962}
N 200 57730 240 57730 {
lab=word962}
N 170 57720 170 57770 {
lab=GND}
N 170 57770 170 57780 {
lab=GND}
N 230 57720 230 57770 {
lab=Y2}
N 230 57770 230 57780 {
lab=Y2}
N 250 57780 280 57780 {
lab=GND}
N 280 57770 280 57780 {
lab=GND}
N 240 57730 280 57730 {
lab=word962}
N 280 57730 320 57730 {
lab=word962}
N 250 57720 250 57770 {
lab=GND}
N 250 57770 250 57780 {
lab=GND}
N 310 57720 310 57770 {
lab=Y3}
N 310 57770 310 57780 {
lab=Y3}
N 330 57780 360 57780 {
lab=GND}
N 360 57770 360 57780 {
lab=GND}
N 320 57730 360 57730 {
lab=word962}
N 360 57730 400 57730 {
lab=word962}
N 330 57720 330 57770 {
lab=GND}
N 330 57770 330 57780 {
lab=GND}
N 390 57720 390 57770 {
lab=Y4}
N 390 57770 390 57780 {
lab=Y4}
N 400 57730 440 57730 {
lab=word962}
N 440 57730 480 57730 {
lab=word962}
N 410 57720 410 57770 {
lab=GND}
N 410 57770 410 57780 {
lab=GND}
N 470 57720 470 57770 {
lab=Y5}
N 470 57770 470 57780 {
lab=Y5}
N 480 57730 520 57730 {
lab=word962}
N 520 57730 560 57730 {
lab=word962}
N 490 57720 490 57770 {
lab=GND}
N 490 57770 490 57780 {
lab=GND}
N 550 57720 550 57770 {
lab=Y6}
N 550 57770 550 57780 {
lab=Y6}
N 570 57780 600 57780 {
lab=GND}
N 600 57770 600 57780 {
lab=GND}
N 560 57730 600 57730 {
lab=word962}
N 600 57730 640 57730 {
lab=word962}
N 570 57720 570 57770 {
lab=GND}
N 570 57770 570 57780 {
lab=GND}
N 630 57720 630 57770 {
lab=Y7}
N 630 57770 630 57780 {
lab=Y7}
N 0 57790 40 57790 {
lab=word963}
N 40 57790 80 57790 {
lab=word963}
N 10 57780 10 57830 {
lab=GND}
N 10 57830 10 57840 {
lab=GND}
N 70 57780 70 57830 {
lab=Y0}
N 70 57830 70 57840 {
lab=Y0}
N 90 57840 120 57840 {
lab=GND}
N 120 57830 120 57840 {
lab=GND}
N 80 57790 120 57790 {
lab=word963}
N 120 57790 160 57790 {
lab=word963}
N 90 57780 90 57830 {
lab=GND}
N 90 57830 90 57840 {
lab=GND}
N 150 57780 150 57830 {
lab=Y1}
N 150 57830 150 57840 {
lab=Y1}
N 170 57840 200 57840 {
lab=GND}
N 200 57830 200 57840 {
lab=GND}
N 160 57790 200 57790 {
lab=word963}
N 200 57790 240 57790 {
lab=word963}
N 170 57780 170 57830 {
lab=GND}
N 170 57830 170 57840 {
lab=GND}
N 230 57780 230 57830 {
lab=Y2}
N 230 57830 230 57840 {
lab=Y2}
N 250 57840 280 57840 {
lab=GND}
N 280 57830 280 57840 {
lab=GND}
N 240 57790 280 57790 {
lab=word963}
N 280 57790 320 57790 {
lab=word963}
N 250 57780 250 57830 {
lab=GND}
N 250 57830 250 57840 {
lab=GND}
N 310 57780 310 57830 {
lab=Y3}
N 310 57830 310 57840 {
lab=Y3}
N 320 57790 360 57790 {
lab=word963}
N 360 57790 400 57790 {
lab=word963}
N 330 57780 330 57830 {
lab=GND}
N 330 57830 330 57840 {
lab=GND}
N 390 57780 390 57830 {
lab=Y4}
N 390 57830 390 57840 {
lab=Y4}
N 410 57840 440 57840 {
lab=GND}
N 440 57830 440 57840 {
lab=GND}
N 400 57790 440 57790 {
lab=word963}
N 440 57790 480 57790 {
lab=word963}
N 410 57780 410 57830 {
lab=GND}
N 410 57830 410 57840 {
lab=GND}
N 470 57780 470 57830 {
lab=Y5}
N 470 57830 470 57840 {
lab=Y5}
N 490 57840 520 57840 {
lab=GND}
N 520 57830 520 57840 {
lab=GND}
N 480 57790 520 57790 {
lab=word963}
N 520 57790 560 57790 {
lab=word963}
N 490 57780 490 57830 {
lab=GND}
N 490 57830 490 57840 {
lab=GND}
N 550 57780 550 57830 {
lab=Y6}
N 550 57830 550 57840 {
lab=Y6}
N 560 57790 600 57790 {
lab=word963}
N 600 57790 640 57790 {
lab=word963}
N 570 57780 570 57830 {
lab=GND}
N 570 57830 570 57840 {
lab=GND}
N 630 57780 630 57830 {
lab=Y7}
N 630 57830 630 57840 {
lab=Y7}
N 0 57850 40 57850 {
lab=word964}
N 40 57850 80 57850 {
lab=word964}
N 10 57840 10 57890 {
lab=GND}
N 10 57890 10 57900 {
lab=GND}
N 70 57840 70 57890 {
lab=Y0}
N 70 57890 70 57900 {
lab=Y0}
N 90 57900 120 57900 {
lab=GND}
N 120 57890 120 57900 {
lab=GND}
N 80 57850 120 57850 {
lab=word964}
N 120 57850 160 57850 {
lab=word964}
N 90 57840 90 57890 {
lab=GND}
N 90 57890 90 57900 {
lab=GND}
N 150 57840 150 57890 {
lab=Y1}
N 150 57890 150 57900 {
lab=Y1}
N 170 57900 200 57900 {
lab=GND}
N 200 57890 200 57900 {
lab=GND}
N 160 57850 200 57850 {
lab=word964}
N 200 57850 240 57850 {
lab=word964}
N 170 57840 170 57890 {
lab=GND}
N 170 57890 170 57900 {
lab=GND}
N 230 57840 230 57890 {
lab=Y2}
N 230 57890 230 57900 {
lab=Y2}
N 250 57900 280 57900 {
lab=GND}
N 280 57890 280 57900 {
lab=GND}
N 240 57850 280 57850 {
lab=word964}
N 280 57850 320 57850 {
lab=word964}
N 250 57840 250 57890 {
lab=GND}
N 250 57890 250 57900 {
lab=GND}
N 310 57840 310 57890 {
lab=Y3}
N 310 57890 310 57900 {
lab=Y3}
N 320 57850 360 57850 {
lab=word964}
N 360 57850 400 57850 {
lab=word964}
N 330 57840 330 57890 {
lab=GND}
N 330 57890 330 57900 {
lab=GND}
N 390 57840 390 57890 {
lab=Y4}
N 390 57890 390 57900 {
lab=Y4}
N 400 57850 440 57850 {
lab=word964}
N 440 57850 480 57850 {
lab=word964}
N 410 57840 410 57890 {
lab=GND}
N 410 57890 410 57900 {
lab=GND}
N 470 57840 470 57890 {
lab=Y5}
N 470 57890 470 57900 {
lab=Y5}
N 490 57900 520 57900 {
lab=GND}
N 520 57890 520 57900 {
lab=GND}
N 480 57850 520 57850 {
lab=word964}
N 520 57850 560 57850 {
lab=word964}
N 490 57840 490 57890 {
lab=GND}
N 490 57890 490 57900 {
lab=GND}
N 550 57840 550 57890 {
lab=Y6}
N 550 57890 550 57900 {
lab=Y6}
N 570 57900 600 57900 {
lab=GND}
N 600 57890 600 57900 {
lab=GND}
N 560 57850 600 57850 {
lab=word964}
N 600 57850 640 57850 {
lab=word964}
N 570 57840 570 57890 {
lab=GND}
N 570 57890 570 57900 {
lab=GND}
N 630 57840 630 57890 {
lab=Y7}
N 630 57890 630 57900 {
lab=Y7}
N 0 57910 40 57910 {
lab=word965}
N 40 57910 80 57910 {
lab=word965}
N 10 57900 10 57950 {
lab=GND}
N 10 57950 10 57960 {
lab=GND}
N 70 57900 70 57950 {
lab=Y0}
N 70 57950 70 57960 {
lab=Y0}
N 90 57960 120 57960 {
lab=GND}
N 120 57950 120 57960 {
lab=GND}
N 80 57910 120 57910 {
lab=word965}
N 120 57910 160 57910 {
lab=word965}
N 90 57900 90 57950 {
lab=GND}
N 90 57950 90 57960 {
lab=GND}
N 150 57900 150 57950 {
lab=Y1}
N 150 57950 150 57960 {
lab=Y1}
N 170 57960 200 57960 {
lab=GND}
N 200 57950 200 57960 {
lab=GND}
N 160 57910 200 57910 {
lab=word965}
N 200 57910 240 57910 {
lab=word965}
N 170 57900 170 57950 {
lab=GND}
N 170 57950 170 57960 {
lab=GND}
N 230 57900 230 57950 {
lab=Y2}
N 230 57950 230 57960 {
lab=Y2}
N 250 57960 280 57960 {
lab=GND}
N 280 57950 280 57960 {
lab=GND}
N 240 57910 280 57910 {
lab=word965}
N 280 57910 320 57910 {
lab=word965}
N 250 57900 250 57950 {
lab=GND}
N 250 57950 250 57960 {
lab=GND}
N 310 57900 310 57950 {
lab=Y3}
N 310 57950 310 57960 {
lab=Y3}
N 320 57910 360 57910 {
lab=word965}
N 360 57910 400 57910 {
lab=word965}
N 330 57900 330 57950 {
lab=GND}
N 330 57950 330 57960 {
lab=GND}
N 390 57900 390 57950 {
lab=Y4}
N 390 57950 390 57960 {
lab=Y4}
N 400 57910 440 57910 {
lab=word965}
N 440 57910 480 57910 {
lab=word965}
N 410 57900 410 57950 {
lab=GND}
N 410 57950 410 57960 {
lab=GND}
N 470 57900 470 57950 {
lab=Y5}
N 470 57950 470 57960 {
lab=Y5}
N 480 57910 520 57910 {
lab=word965}
N 520 57910 560 57910 {
lab=word965}
N 490 57900 490 57950 {
lab=GND}
N 490 57950 490 57960 {
lab=GND}
N 550 57900 550 57950 {
lab=Y6}
N 550 57950 550 57960 {
lab=Y6}
N 560 57910 600 57910 {
lab=word965}
N 600 57910 640 57910 {
lab=word965}
N 570 57900 570 57950 {
lab=GND}
N 570 57950 570 57960 {
lab=GND}
N 630 57900 630 57950 {
lab=Y7}
N 630 57950 630 57960 {
lab=Y7}
N 0 57970 40 57970 {
lab=word966}
N 40 57970 80 57970 {
lab=word966}
N 10 57960 10 58010 {
lab=GND}
N 10 58010 10 58020 {
lab=GND}
N 70 57960 70 58010 {
lab=Y0}
N 70 58010 70 58020 {
lab=Y0}
N 90 58020 120 58020 {
lab=GND}
N 120 58010 120 58020 {
lab=GND}
N 80 57970 120 57970 {
lab=word966}
N 120 57970 160 57970 {
lab=word966}
N 90 57960 90 58010 {
lab=GND}
N 90 58010 90 58020 {
lab=GND}
N 150 57960 150 58010 {
lab=Y1}
N 150 58010 150 58020 {
lab=Y1}
N 170 58020 200 58020 {
lab=GND}
N 200 58010 200 58020 {
lab=GND}
N 160 57970 200 57970 {
lab=word966}
N 200 57970 240 57970 {
lab=word966}
N 170 57960 170 58010 {
lab=GND}
N 170 58010 170 58020 {
lab=GND}
N 230 57960 230 58010 {
lab=Y2}
N 230 58010 230 58020 {
lab=Y2}
N 240 57970 280 57970 {
lab=word966}
N 280 57970 320 57970 {
lab=word966}
N 250 57960 250 58010 {
lab=GND}
N 250 58010 250 58020 {
lab=GND}
N 310 57960 310 58010 {
lab=Y3}
N 310 58010 310 58020 {
lab=Y3}
N 330 58020 360 58020 {
lab=GND}
N 360 58010 360 58020 {
lab=GND}
N 320 57970 360 57970 {
lab=word966}
N 360 57970 400 57970 {
lab=word966}
N 330 57960 330 58010 {
lab=GND}
N 330 58010 330 58020 {
lab=GND}
N 390 57960 390 58010 {
lab=Y4}
N 390 58010 390 58020 {
lab=Y4}
N 410 58020 440 58020 {
lab=GND}
N 440 58010 440 58020 {
lab=GND}
N 400 57970 440 57970 {
lab=word966}
N 440 57970 480 57970 {
lab=word966}
N 410 57960 410 58010 {
lab=GND}
N 410 58010 410 58020 {
lab=GND}
N 470 57960 470 58010 {
lab=Y5}
N 470 58010 470 58020 {
lab=Y5}
N 480 57970 520 57970 {
lab=word966}
N 520 57970 560 57970 {
lab=word966}
N 490 57960 490 58010 {
lab=GND}
N 490 58010 490 58020 {
lab=GND}
N 550 57960 550 58010 {
lab=Y6}
N 550 58010 550 58020 {
lab=Y6}
N 570 58020 600 58020 {
lab=GND}
N 600 58010 600 58020 {
lab=GND}
N 560 57970 600 57970 {
lab=word966}
N 600 57970 640 57970 {
lab=word966}
N 570 57960 570 58010 {
lab=GND}
N 570 58010 570 58020 {
lab=GND}
N 630 57960 630 58010 {
lab=Y7}
N 630 58010 630 58020 {
lab=Y7}
N 0 58030 40 58030 {
lab=word967}
N 40 58030 80 58030 {
lab=word967}
N 10 58020 10 58070 {
lab=GND}
N 10 58070 10 58080 {
lab=GND}
N 70 58020 70 58070 {
lab=Y0}
N 70 58070 70 58080 {
lab=Y0}
N 90 58080 120 58080 {
lab=GND}
N 120 58070 120 58080 {
lab=GND}
N 80 58030 120 58030 {
lab=word967}
N 120 58030 160 58030 {
lab=word967}
N 90 58020 90 58070 {
lab=GND}
N 90 58070 90 58080 {
lab=GND}
N 150 58020 150 58070 {
lab=Y1}
N 150 58070 150 58080 {
lab=Y1}
N 170 58080 200 58080 {
lab=GND}
N 200 58070 200 58080 {
lab=GND}
N 160 58030 200 58030 {
lab=word967}
N 200 58030 240 58030 {
lab=word967}
N 170 58020 170 58070 {
lab=GND}
N 170 58070 170 58080 {
lab=GND}
N 230 58020 230 58070 {
lab=Y2}
N 230 58070 230 58080 {
lab=Y2}
N 240 58030 280 58030 {
lab=word967}
N 280 58030 320 58030 {
lab=word967}
N 250 58020 250 58070 {
lab=GND}
N 250 58070 250 58080 {
lab=GND}
N 310 58020 310 58070 {
lab=Y3}
N 310 58070 310 58080 {
lab=Y3}
N 330 58080 360 58080 {
lab=GND}
N 360 58070 360 58080 {
lab=GND}
N 320 58030 360 58030 {
lab=word967}
N 360 58030 400 58030 {
lab=word967}
N 330 58020 330 58070 {
lab=GND}
N 330 58070 330 58080 {
lab=GND}
N 390 58020 390 58070 {
lab=Y4}
N 390 58070 390 58080 {
lab=Y4}
N 400 58030 440 58030 {
lab=word967}
N 440 58030 480 58030 {
lab=word967}
N 410 58020 410 58070 {
lab=GND}
N 410 58070 410 58080 {
lab=GND}
N 470 58020 470 58070 {
lab=Y5}
N 470 58070 470 58080 {
lab=Y5}
N 490 58080 520 58080 {
lab=GND}
N 520 58070 520 58080 {
lab=GND}
N 480 58030 520 58030 {
lab=word967}
N 520 58030 560 58030 {
lab=word967}
N 490 58020 490 58070 {
lab=GND}
N 490 58070 490 58080 {
lab=GND}
N 550 58020 550 58070 {
lab=Y6}
N 550 58070 550 58080 {
lab=Y6}
N 560 58030 600 58030 {
lab=word967}
N 600 58030 640 58030 {
lab=word967}
N 570 58020 570 58070 {
lab=GND}
N 570 58070 570 58080 {
lab=GND}
N 630 58020 630 58070 {
lab=Y7}
N 630 58070 630 58080 {
lab=Y7}
N 0 58090 40 58090 {
lab=word968}
N 40 58090 80 58090 {
lab=word968}
N 10 58080 10 58130 {
lab=GND}
N 10 58130 10 58140 {
lab=GND}
N 70 58080 70 58130 {
lab=Y0}
N 70 58130 70 58140 {
lab=Y0}
N 90 58140 120 58140 {
lab=GND}
N 120 58130 120 58140 {
lab=GND}
N 80 58090 120 58090 {
lab=word968}
N 120 58090 160 58090 {
lab=word968}
N 90 58080 90 58130 {
lab=GND}
N 90 58130 90 58140 {
lab=GND}
N 150 58080 150 58130 {
lab=Y1}
N 150 58130 150 58140 {
lab=Y1}
N 170 58140 200 58140 {
lab=GND}
N 200 58130 200 58140 {
lab=GND}
N 160 58090 200 58090 {
lab=word968}
N 200 58090 240 58090 {
lab=word968}
N 170 58080 170 58130 {
lab=GND}
N 170 58130 170 58140 {
lab=GND}
N 230 58080 230 58130 {
lab=Y2}
N 230 58130 230 58140 {
lab=Y2}
N 240 58090 280 58090 {
lab=word968}
N 280 58090 320 58090 {
lab=word968}
N 250 58080 250 58130 {
lab=GND}
N 250 58130 250 58140 {
lab=GND}
N 310 58080 310 58130 {
lab=Y3}
N 310 58130 310 58140 {
lab=Y3}
N 320 58090 360 58090 {
lab=word968}
N 360 58090 400 58090 {
lab=word968}
N 330 58080 330 58130 {
lab=GND}
N 330 58130 330 58140 {
lab=GND}
N 390 58080 390 58130 {
lab=Y4}
N 390 58130 390 58140 {
lab=Y4}
N 410 58140 440 58140 {
lab=GND}
N 440 58130 440 58140 {
lab=GND}
N 400 58090 440 58090 {
lab=word968}
N 440 58090 480 58090 {
lab=word968}
N 410 58080 410 58130 {
lab=GND}
N 410 58130 410 58140 {
lab=GND}
N 470 58080 470 58130 {
lab=Y5}
N 470 58130 470 58140 {
lab=Y5}
N 490 58140 520 58140 {
lab=GND}
N 520 58130 520 58140 {
lab=GND}
N 480 58090 520 58090 {
lab=word968}
N 520 58090 560 58090 {
lab=word968}
N 490 58080 490 58130 {
lab=GND}
N 490 58130 490 58140 {
lab=GND}
N 550 58080 550 58130 {
lab=Y6}
N 550 58130 550 58140 {
lab=Y6}
N 570 58140 600 58140 {
lab=GND}
N 600 58130 600 58140 {
lab=GND}
N 560 58090 600 58090 {
lab=word968}
N 600 58090 640 58090 {
lab=word968}
N 570 58080 570 58130 {
lab=GND}
N 570 58130 570 58140 {
lab=GND}
N 630 58080 630 58130 {
lab=Y7}
N 630 58130 630 58140 {
lab=Y7}
N 0 58150 40 58150 {
lab=word969}
N 40 58150 80 58150 {
lab=word969}
N 10 58140 10 58190 {
lab=GND}
N 10 58190 10 58200 {
lab=GND}
N 70 58140 70 58190 {
lab=Y0}
N 70 58190 70 58200 {
lab=Y0}
N 90 58200 120 58200 {
lab=GND}
N 120 58190 120 58200 {
lab=GND}
N 80 58150 120 58150 {
lab=word969}
N 120 58150 160 58150 {
lab=word969}
N 90 58140 90 58190 {
lab=GND}
N 90 58190 90 58200 {
lab=GND}
N 150 58140 150 58190 {
lab=Y1}
N 150 58190 150 58200 {
lab=Y1}
N 170 58200 200 58200 {
lab=GND}
N 200 58190 200 58200 {
lab=GND}
N 160 58150 200 58150 {
lab=word969}
N 200 58150 240 58150 {
lab=word969}
N 170 58140 170 58190 {
lab=GND}
N 170 58190 170 58200 {
lab=GND}
N 230 58140 230 58190 {
lab=Y2}
N 230 58190 230 58200 {
lab=Y2}
N 240 58150 280 58150 {
lab=word969}
N 280 58150 320 58150 {
lab=word969}
N 250 58140 250 58190 {
lab=GND}
N 250 58190 250 58200 {
lab=GND}
N 310 58140 310 58190 {
lab=Y3}
N 310 58190 310 58200 {
lab=Y3}
N 320 58150 360 58150 {
lab=word969}
N 360 58150 400 58150 {
lab=word969}
N 330 58140 330 58190 {
lab=GND}
N 330 58190 330 58200 {
lab=GND}
N 390 58140 390 58190 {
lab=Y4}
N 390 58190 390 58200 {
lab=Y4}
N 410 58200 440 58200 {
lab=GND}
N 440 58190 440 58200 {
lab=GND}
N 400 58150 440 58150 {
lab=word969}
N 440 58150 480 58150 {
lab=word969}
N 410 58140 410 58190 {
lab=GND}
N 410 58190 410 58200 {
lab=GND}
N 470 58140 470 58190 {
lab=Y5}
N 470 58190 470 58200 {
lab=Y5}
N 480 58150 520 58150 {
lab=word969}
N 520 58150 560 58150 {
lab=word969}
N 490 58140 490 58190 {
lab=GND}
N 490 58190 490 58200 {
lab=GND}
N 550 58140 550 58190 {
lab=Y6}
N 550 58190 550 58200 {
lab=Y6}
N 560 58150 600 58150 {
lab=word969}
N 600 58150 640 58150 {
lab=word969}
N 570 58140 570 58190 {
lab=GND}
N 570 58190 570 58200 {
lab=GND}
N 630 58140 630 58190 {
lab=Y7}
N 630 58190 630 58200 {
lab=Y7}
N 0 58210 40 58210 {
lab=word970}
N 40 58210 80 58210 {
lab=word970}
N 10 58200 10 58250 {
lab=GND}
N 10 58250 10 58260 {
lab=GND}
N 70 58200 70 58250 {
lab=Y0}
N 70 58250 70 58260 {
lab=Y0}
N 90 58260 120 58260 {
lab=GND}
N 120 58250 120 58260 {
lab=GND}
N 80 58210 120 58210 {
lab=word970}
N 120 58210 160 58210 {
lab=word970}
N 90 58200 90 58250 {
lab=GND}
N 90 58250 90 58260 {
lab=GND}
N 150 58200 150 58250 {
lab=Y1}
N 150 58250 150 58260 {
lab=Y1}
N 170 58260 200 58260 {
lab=GND}
N 200 58250 200 58260 {
lab=GND}
N 160 58210 200 58210 {
lab=word970}
N 200 58210 240 58210 {
lab=word970}
N 170 58200 170 58250 {
lab=GND}
N 170 58250 170 58260 {
lab=GND}
N 230 58200 230 58250 {
lab=Y2}
N 230 58250 230 58260 {
lab=Y2}
N 240 58210 280 58210 {
lab=word970}
N 280 58210 320 58210 {
lab=word970}
N 250 58200 250 58250 {
lab=GND}
N 250 58250 250 58260 {
lab=GND}
N 310 58200 310 58250 {
lab=Y3}
N 310 58250 310 58260 {
lab=Y3}
N 320 58210 360 58210 {
lab=word970}
N 360 58210 400 58210 {
lab=word970}
N 330 58200 330 58250 {
lab=GND}
N 330 58250 330 58260 {
lab=GND}
N 390 58200 390 58250 {
lab=Y4}
N 390 58250 390 58260 {
lab=Y4}
N 400 58210 440 58210 {
lab=word970}
N 440 58210 480 58210 {
lab=word970}
N 410 58200 410 58250 {
lab=GND}
N 410 58250 410 58260 {
lab=GND}
N 470 58200 470 58250 {
lab=Y5}
N 470 58250 470 58260 {
lab=Y5}
N 480 58210 520 58210 {
lab=word970}
N 520 58210 560 58210 {
lab=word970}
N 490 58200 490 58250 {
lab=GND}
N 490 58250 490 58260 {
lab=GND}
N 550 58200 550 58250 {
lab=Y6}
N 550 58250 550 58260 {
lab=Y6}
N 570 58260 600 58260 {
lab=GND}
N 600 58250 600 58260 {
lab=GND}
N 560 58210 600 58210 {
lab=word970}
N 600 58210 640 58210 {
lab=word970}
N 570 58200 570 58250 {
lab=GND}
N 570 58250 570 58260 {
lab=GND}
N 630 58200 630 58250 {
lab=Y7}
N 630 58250 630 58260 {
lab=Y7}
N 0 58270 40 58270 {
lab=word971}
N 40 58270 80 58270 {
lab=word971}
N 10 58260 10 58310 {
lab=GND}
N 10 58310 10 58320 {
lab=GND}
N 70 58260 70 58310 {
lab=Y0}
N 70 58310 70 58320 {
lab=Y0}
N 90 58320 120 58320 {
lab=GND}
N 120 58310 120 58320 {
lab=GND}
N 80 58270 120 58270 {
lab=word971}
N 120 58270 160 58270 {
lab=word971}
N 90 58260 90 58310 {
lab=GND}
N 90 58310 90 58320 {
lab=GND}
N 150 58260 150 58310 {
lab=Y1}
N 150 58310 150 58320 {
lab=Y1}
N 160 58270 200 58270 {
lab=word971}
N 200 58270 240 58270 {
lab=word971}
N 170 58260 170 58310 {
lab=GND}
N 170 58310 170 58320 {
lab=GND}
N 230 58260 230 58310 {
lab=Y2}
N 230 58310 230 58320 {
lab=Y2}
N 250 58320 280 58320 {
lab=GND}
N 280 58310 280 58320 {
lab=GND}
N 240 58270 280 58270 {
lab=word971}
N 280 58270 320 58270 {
lab=word971}
N 250 58260 250 58310 {
lab=GND}
N 250 58310 250 58320 {
lab=GND}
N 310 58260 310 58310 {
lab=Y3}
N 310 58310 310 58320 {
lab=Y3}
N 330 58320 360 58320 {
lab=GND}
N 360 58310 360 58320 {
lab=GND}
N 320 58270 360 58270 {
lab=word971}
N 360 58270 400 58270 {
lab=word971}
N 330 58260 330 58310 {
lab=GND}
N 330 58310 330 58320 {
lab=GND}
N 390 58260 390 58310 {
lab=Y4}
N 390 58310 390 58320 {
lab=Y4}
N 410 58320 440 58320 {
lab=GND}
N 440 58310 440 58320 {
lab=GND}
N 400 58270 440 58270 {
lab=word971}
N 440 58270 480 58270 {
lab=word971}
N 410 58260 410 58310 {
lab=GND}
N 410 58310 410 58320 {
lab=GND}
N 470 58260 470 58310 {
lab=Y5}
N 470 58310 470 58320 {
lab=Y5}
N 480 58270 520 58270 {
lab=word971}
N 520 58270 560 58270 {
lab=word971}
N 490 58260 490 58310 {
lab=GND}
N 490 58310 490 58320 {
lab=GND}
N 550 58260 550 58310 {
lab=Y6}
N 550 58310 550 58320 {
lab=Y6}
N 570 58320 600 58320 {
lab=GND}
N 600 58310 600 58320 {
lab=GND}
N 560 58270 600 58270 {
lab=word971}
N 600 58270 640 58270 {
lab=word971}
N 570 58260 570 58310 {
lab=GND}
N 570 58310 570 58320 {
lab=GND}
N 630 58260 630 58310 {
lab=Y7}
N 630 58310 630 58320 {
lab=Y7}
N 0 58330 40 58330 {
lab=word972}
N 40 58330 80 58330 {
lab=word972}
N 10 58320 10 58370 {
lab=GND}
N 10 58370 10 58380 {
lab=GND}
N 70 58320 70 58370 {
lab=Y0}
N 70 58370 70 58380 {
lab=Y0}
N 90 58380 120 58380 {
lab=GND}
N 120 58370 120 58380 {
lab=GND}
N 80 58330 120 58330 {
lab=word972}
N 120 58330 160 58330 {
lab=word972}
N 90 58320 90 58370 {
lab=GND}
N 90 58370 90 58380 {
lab=GND}
N 150 58320 150 58370 {
lab=Y1}
N 150 58370 150 58380 {
lab=Y1}
N 160 58330 200 58330 {
lab=word972}
N 200 58330 240 58330 {
lab=word972}
N 170 58320 170 58370 {
lab=GND}
N 170 58370 170 58380 {
lab=GND}
N 230 58320 230 58370 {
lab=Y2}
N 230 58370 230 58380 {
lab=Y2}
N 250 58380 280 58380 {
lab=GND}
N 280 58370 280 58380 {
lab=GND}
N 240 58330 280 58330 {
lab=word972}
N 280 58330 320 58330 {
lab=word972}
N 250 58320 250 58370 {
lab=GND}
N 250 58370 250 58380 {
lab=GND}
N 310 58320 310 58370 {
lab=Y3}
N 310 58370 310 58380 {
lab=Y3}
N 330 58380 360 58380 {
lab=GND}
N 360 58370 360 58380 {
lab=GND}
N 320 58330 360 58330 {
lab=word972}
N 360 58330 400 58330 {
lab=word972}
N 330 58320 330 58370 {
lab=GND}
N 330 58370 330 58380 {
lab=GND}
N 390 58320 390 58370 {
lab=Y4}
N 390 58370 390 58380 {
lab=Y4}
N 400 58330 440 58330 {
lab=word972}
N 440 58330 480 58330 {
lab=word972}
N 410 58320 410 58370 {
lab=GND}
N 410 58370 410 58380 {
lab=GND}
N 470 58320 470 58370 {
lab=Y5}
N 470 58370 470 58380 {
lab=Y5}
N 490 58380 520 58380 {
lab=GND}
N 520 58370 520 58380 {
lab=GND}
N 480 58330 520 58330 {
lab=word972}
N 520 58330 560 58330 {
lab=word972}
N 490 58320 490 58370 {
lab=GND}
N 490 58370 490 58380 {
lab=GND}
N 550 58320 550 58370 {
lab=Y6}
N 550 58370 550 58380 {
lab=Y6}
N 560 58330 600 58330 {
lab=word972}
N 600 58330 640 58330 {
lab=word972}
N 570 58320 570 58370 {
lab=GND}
N 570 58370 570 58380 {
lab=GND}
N 630 58320 630 58370 {
lab=Y7}
N 630 58370 630 58380 {
lab=Y7}
N 0 58390 40 58390 {
lab=word973}
N 40 58390 80 58390 {
lab=word973}
N 10 58380 10 58430 {
lab=GND}
N 10 58430 10 58440 {
lab=GND}
N 70 58380 70 58430 {
lab=Y0}
N 70 58430 70 58440 {
lab=Y0}
N 90 58440 120 58440 {
lab=GND}
N 120 58430 120 58440 {
lab=GND}
N 80 58390 120 58390 {
lab=word973}
N 120 58390 160 58390 {
lab=word973}
N 90 58380 90 58430 {
lab=GND}
N 90 58430 90 58440 {
lab=GND}
N 150 58380 150 58430 {
lab=Y1}
N 150 58430 150 58440 {
lab=Y1}
N 160 58390 200 58390 {
lab=word973}
N 200 58390 240 58390 {
lab=word973}
N 170 58380 170 58430 {
lab=GND}
N 170 58430 170 58440 {
lab=GND}
N 230 58380 230 58430 {
lab=Y2}
N 230 58430 230 58440 {
lab=Y2}
N 250 58440 280 58440 {
lab=GND}
N 280 58430 280 58440 {
lab=GND}
N 240 58390 280 58390 {
lab=word973}
N 280 58390 320 58390 {
lab=word973}
N 250 58380 250 58430 {
lab=GND}
N 250 58430 250 58440 {
lab=GND}
N 310 58380 310 58430 {
lab=Y3}
N 310 58430 310 58440 {
lab=Y3}
N 330 58440 360 58440 {
lab=GND}
N 360 58430 360 58440 {
lab=GND}
N 320 58390 360 58390 {
lab=word973}
N 360 58390 400 58390 {
lab=word973}
N 330 58380 330 58430 {
lab=GND}
N 330 58430 330 58440 {
lab=GND}
N 390 58380 390 58430 {
lab=Y4}
N 390 58430 390 58440 {
lab=Y4}
N 400 58390 440 58390 {
lab=word973}
N 440 58390 480 58390 {
lab=word973}
N 410 58380 410 58430 {
lab=GND}
N 410 58430 410 58440 {
lab=GND}
N 470 58380 470 58430 {
lab=Y5}
N 470 58430 470 58440 {
lab=Y5}
N 480 58390 520 58390 {
lab=word973}
N 520 58390 560 58390 {
lab=word973}
N 490 58380 490 58430 {
lab=GND}
N 490 58430 490 58440 {
lab=GND}
N 550 58380 550 58430 {
lab=Y6}
N 550 58430 550 58440 {
lab=Y6}
N 560 58390 600 58390 {
lab=word973}
N 600 58390 640 58390 {
lab=word973}
N 570 58380 570 58430 {
lab=GND}
N 570 58430 570 58440 {
lab=GND}
N 630 58380 630 58430 {
lab=Y7}
N 630 58430 630 58440 {
lab=Y7}
N 0 58450 40 58450 {
lab=word974}
N 40 58450 80 58450 {
lab=word974}
N 10 58440 10 58490 {
lab=GND}
N 10 58490 10 58500 {
lab=GND}
N 70 58440 70 58490 {
lab=Y0}
N 70 58490 70 58500 {
lab=Y0}
N 90 58500 120 58500 {
lab=GND}
N 120 58490 120 58500 {
lab=GND}
N 80 58450 120 58450 {
lab=word974}
N 120 58450 160 58450 {
lab=word974}
N 90 58440 90 58490 {
lab=GND}
N 90 58490 90 58500 {
lab=GND}
N 150 58440 150 58490 {
lab=Y1}
N 150 58490 150 58500 {
lab=Y1}
N 160 58450 200 58450 {
lab=word974}
N 200 58450 240 58450 {
lab=word974}
N 170 58440 170 58490 {
lab=GND}
N 170 58490 170 58500 {
lab=GND}
N 230 58440 230 58490 {
lab=Y2}
N 230 58490 230 58500 {
lab=Y2}
N 250 58500 280 58500 {
lab=GND}
N 280 58490 280 58500 {
lab=GND}
N 240 58450 280 58450 {
lab=word974}
N 280 58450 320 58450 {
lab=word974}
N 250 58440 250 58490 {
lab=GND}
N 250 58490 250 58500 {
lab=GND}
N 310 58440 310 58490 {
lab=Y3}
N 310 58490 310 58500 {
lab=Y3}
N 320 58450 360 58450 {
lab=word974}
N 360 58450 400 58450 {
lab=word974}
N 330 58440 330 58490 {
lab=GND}
N 330 58490 330 58500 {
lab=GND}
N 390 58440 390 58490 {
lab=Y4}
N 390 58490 390 58500 {
lab=Y4}
N 410 58500 440 58500 {
lab=GND}
N 440 58490 440 58500 {
lab=GND}
N 400 58450 440 58450 {
lab=word974}
N 440 58450 480 58450 {
lab=word974}
N 410 58440 410 58490 {
lab=GND}
N 410 58490 410 58500 {
lab=GND}
N 470 58440 470 58490 {
lab=Y5}
N 470 58490 470 58500 {
lab=Y5}
N 480 58450 520 58450 {
lab=word974}
N 520 58450 560 58450 {
lab=word974}
N 490 58440 490 58490 {
lab=GND}
N 490 58490 490 58500 {
lab=GND}
N 550 58440 550 58490 {
lab=Y6}
N 550 58490 550 58500 {
lab=Y6}
N 570 58500 600 58500 {
lab=GND}
N 600 58490 600 58500 {
lab=GND}
N 560 58450 600 58450 {
lab=word974}
N 600 58450 640 58450 {
lab=word974}
N 570 58440 570 58490 {
lab=GND}
N 570 58490 570 58500 {
lab=GND}
N 630 58440 630 58490 {
lab=Y7}
N 630 58490 630 58500 {
lab=Y7}
N 0 58510 40 58510 {
lab=word975}
N 40 58510 80 58510 {
lab=word975}
N 10 58500 10 58550 {
lab=GND}
N 10 58550 10 58560 {
lab=GND}
N 70 58500 70 58550 {
lab=Y0}
N 70 58550 70 58560 {
lab=Y0}
N 90 58560 120 58560 {
lab=GND}
N 120 58550 120 58560 {
lab=GND}
N 80 58510 120 58510 {
lab=word975}
N 120 58510 160 58510 {
lab=word975}
N 90 58500 90 58550 {
lab=GND}
N 90 58550 90 58560 {
lab=GND}
N 150 58500 150 58550 {
lab=Y1}
N 150 58550 150 58560 {
lab=Y1}
N 160 58510 200 58510 {
lab=word975}
N 200 58510 240 58510 {
lab=word975}
N 170 58500 170 58550 {
lab=GND}
N 170 58550 170 58560 {
lab=GND}
N 230 58500 230 58550 {
lab=Y2}
N 230 58550 230 58560 {
lab=Y2}
N 250 58560 280 58560 {
lab=GND}
N 280 58550 280 58560 {
lab=GND}
N 240 58510 280 58510 {
lab=word975}
N 280 58510 320 58510 {
lab=word975}
N 250 58500 250 58550 {
lab=GND}
N 250 58550 250 58560 {
lab=GND}
N 310 58500 310 58550 {
lab=Y3}
N 310 58550 310 58560 {
lab=Y3}
N 320 58510 360 58510 {
lab=word975}
N 360 58510 400 58510 {
lab=word975}
N 330 58500 330 58550 {
lab=GND}
N 330 58550 330 58560 {
lab=GND}
N 390 58500 390 58550 {
lab=Y4}
N 390 58550 390 58560 {
lab=Y4}
N 400 58510 440 58510 {
lab=word975}
N 440 58510 480 58510 {
lab=word975}
N 410 58500 410 58550 {
lab=GND}
N 410 58550 410 58560 {
lab=GND}
N 470 58500 470 58550 {
lab=Y5}
N 470 58550 470 58560 {
lab=Y5}
N 490 58560 520 58560 {
lab=GND}
N 520 58550 520 58560 {
lab=GND}
N 480 58510 520 58510 {
lab=word975}
N 520 58510 560 58510 {
lab=word975}
N 490 58500 490 58550 {
lab=GND}
N 490 58550 490 58560 {
lab=GND}
N 550 58500 550 58550 {
lab=Y6}
N 550 58550 550 58560 {
lab=Y6}
N 560 58510 600 58510 {
lab=word975}
N 600 58510 640 58510 {
lab=word975}
N 570 58500 570 58550 {
lab=GND}
N 570 58550 570 58560 {
lab=GND}
N 630 58500 630 58550 {
lab=Y7}
N 630 58550 630 58560 {
lab=Y7}
N 0 58570 40 58570 {
lab=word976}
N 40 58570 80 58570 {
lab=word976}
N 10 58560 10 58610 {
lab=GND}
N 10 58610 10 58620 {
lab=GND}
N 70 58560 70 58610 {
lab=Y0}
N 70 58610 70 58620 {
lab=Y0}
N 90 58620 120 58620 {
lab=GND}
N 120 58610 120 58620 {
lab=GND}
N 80 58570 120 58570 {
lab=word976}
N 120 58570 160 58570 {
lab=word976}
N 90 58560 90 58610 {
lab=GND}
N 90 58610 90 58620 {
lab=GND}
N 150 58560 150 58610 {
lab=Y1}
N 150 58610 150 58620 {
lab=Y1}
N 160 58570 200 58570 {
lab=word976}
N 200 58570 240 58570 {
lab=word976}
N 170 58560 170 58610 {
lab=GND}
N 170 58610 170 58620 {
lab=GND}
N 230 58560 230 58610 {
lab=Y2}
N 230 58610 230 58620 {
lab=Y2}
N 240 58570 280 58570 {
lab=word976}
N 280 58570 320 58570 {
lab=word976}
N 250 58560 250 58610 {
lab=GND}
N 250 58610 250 58620 {
lab=GND}
N 310 58560 310 58610 {
lab=Y3}
N 310 58610 310 58620 {
lab=Y3}
N 330 58620 360 58620 {
lab=GND}
N 360 58610 360 58620 {
lab=GND}
N 320 58570 360 58570 {
lab=word976}
N 360 58570 400 58570 {
lab=word976}
N 330 58560 330 58610 {
lab=GND}
N 330 58610 330 58620 {
lab=GND}
N 390 58560 390 58610 {
lab=Y4}
N 390 58610 390 58620 {
lab=Y4}
N 410 58620 440 58620 {
lab=GND}
N 440 58610 440 58620 {
lab=GND}
N 400 58570 440 58570 {
lab=word976}
N 440 58570 480 58570 {
lab=word976}
N 410 58560 410 58610 {
lab=GND}
N 410 58610 410 58620 {
lab=GND}
N 470 58560 470 58610 {
lab=Y5}
N 470 58610 470 58620 {
lab=Y5}
N 490 58620 520 58620 {
lab=GND}
N 520 58610 520 58620 {
lab=GND}
N 480 58570 520 58570 {
lab=word976}
N 520 58570 560 58570 {
lab=word976}
N 490 58560 490 58610 {
lab=GND}
N 490 58610 490 58620 {
lab=GND}
N 550 58560 550 58610 {
lab=Y6}
N 550 58610 550 58620 {
lab=Y6}
N 570 58620 600 58620 {
lab=GND}
N 600 58610 600 58620 {
lab=GND}
N 560 58570 600 58570 {
lab=word976}
N 600 58570 640 58570 {
lab=word976}
N 570 58560 570 58610 {
lab=GND}
N 570 58610 570 58620 {
lab=GND}
N 630 58560 630 58610 {
lab=Y7}
N 630 58610 630 58620 {
lab=Y7}
N 0 58630 40 58630 {
lab=word977}
N 40 58630 80 58630 {
lab=word977}
N 10 58620 10 58670 {
lab=GND}
N 10 58670 10 58680 {
lab=GND}
N 70 58620 70 58670 {
lab=Y0}
N 70 58670 70 58680 {
lab=Y0}
N 90 58680 120 58680 {
lab=GND}
N 120 58670 120 58680 {
lab=GND}
N 80 58630 120 58630 {
lab=word977}
N 120 58630 160 58630 {
lab=word977}
N 90 58620 90 58670 {
lab=GND}
N 90 58670 90 58680 {
lab=GND}
N 150 58620 150 58670 {
lab=Y1}
N 150 58670 150 58680 {
lab=Y1}
N 160 58630 200 58630 {
lab=word977}
N 200 58630 240 58630 {
lab=word977}
N 170 58620 170 58670 {
lab=GND}
N 170 58670 170 58680 {
lab=GND}
N 230 58620 230 58670 {
lab=Y2}
N 230 58670 230 58680 {
lab=Y2}
N 240 58630 280 58630 {
lab=word977}
N 280 58630 320 58630 {
lab=word977}
N 250 58620 250 58670 {
lab=GND}
N 250 58670 250 58680 {
lab=GND}
N 310 58620 310 58670 {
lab=Y3}
N 310 58670 310 58680 {
lab=Y3}
N 330 58680 360 58680 {
lab=GND}
N 360 58670 360 58680 {
lab=GND}
N 320 58630 360 58630 {
lab=word977}
N 360 58630 400 58630 {
lab=word977}
N 330 58620 330 58670 {
lab=GND}
N 330 58670 330 58680 {
lab=GND}
N 390 58620 390 58670 {
lab=Y4}
N 390 58670 390 58680 {
lab=Y4}
N 410 58680 440 58680 {
lab=GND}
N 440 58670 440 58680 {
lab=GND}
N 400 58630 440 58630 {
lab=word977}
N 440 58630 480 58630 {
lab=word977}
N 410 58620 410 58670 {
lab=GND}
N 410 58670 410 58680 {
lab=GND}
N 470 58620 470 58670 {
lab=Y5}
N 470 58670 470 58680 {
lab=Y5}
N 480 58630 520 58630 {
lab=word977}
N 520 58630 560 58630 {
lab=word977}
N 490 58620 490 58670 {
lab=GND}
N 490 58670 490 58680 {
lab=GND}
N 550 58620 550 58670 {
lab=Y6}
N 550 58670 550 58680 {
lab=Y6}
N 560 58630 600 58630 {
lab=word977}
N 600 58630 640 58630 {
lab=word977}
N 570 58620 570 58670 {
lab=GND}
N 570 58670 570 58680 {
lab=GND}
N 630 58620 630 58670 {
lab=Y7}
N 630 58670 630 58680 {
lab=Y7}
N 0 58690 40 58690 {
lab=word978}
N 40 58690 80 58690 {
lab=word978}
N 10 58680 10 58730 {
lab=GND}
N 10 58730 10 58740 {
lab=GND}
N 70 58680 70 58730 {
lab=Y0}
N 70 58730 70 58740 {
lab=Y0}
N 90 58740 120 58740 {
lab=GND}
N 120 58730 120 58740 {
lab=GND}
N 80 58690 120 58690 {
lab=word978}
N 120 58690 160 58690 {
lab=word978}
N 90 58680 90 58730 {
lab=GND}
N 90 58730 90 58740 {
lab=GND}
N 150 58680 150 58730 {
lab=Y1}
N 150 58730 150 58740 {
lab=Y1}
N 160 58690 200 58690 {
lab=word978}
N 200 58690 240 58690 {
lab=word978}
N 170 58680 170 58730 {
lab=GND}
N 170 58730 170 58740 {
lab=GND}
N 230 58680 230 58730 {
lab=Y2}
N 230 58730 230 58740 {
lab=Y2}
N 240 58690 280 58690 {
lab=word978}
N 280 58690 320 58690 {
lab=word978}
N 250 58680 250 58730 {
lab=GND}
N 250 58730 250 58740 {
lab=GND}
N 310 58680 310 58730 {
lab=Y3}
N 310 58730 310 58740 {
lab=Y3}
N 330 58740 360 58740 {
lab=GND}
N 360 58730 360 58740 {
lab=GND}
N 320 58690 360 58690 {
lab=word978}
N 360 58690 400 58690 {
lab=word978}
N 330 58680 330 58730 {
lab=GND}
N 330 58730 330 58740 {
lab=GND}
N 390 58680 390 58730 {
lab=Y4}
N 390 58730 390 58740 {
lab=Y4}
N 400 58690 440 58690 {
lab=word978}
N 440 58690 480 58690 {
lab=word978}
N 410 58680 410 58730 {
lab=GND}
N 410 58730 410 58740 {
lab=GND}
N 470 58680 470 58730 {
lab=Y5}
N 470 58730 470 58740 {
lab=Y5}
N 480 58690 520 58690 {
lab=word978}
N 520 58690 560 58690 {
lab=word978}
N 490 58680 490 58730 {
lab=GND}
N 490 58730 490 58740 {
lab=GND}
N 550 58680 550 58730 {
lab=Y6}
N 550 58730 550 58740 {
lab=Y6}
N 570 58740 600 58740 {
lab=GND}
N 600 58730 600 58740 {
lab=GND}
N 560 58690 600 58690 {
lab=word978}
N 600 58690 640 58690 {
lab=word978}
N 570 58680 570 58730 {
lab=GND}
N 570 58730 570 58740 {
lab=GND}
N 630 58680 630 58730 {
lab=Y7}
N 630 58730 630 58740 {
lab=Y7}
N 0 58750 40 58750 {
lab=word979}
N 40 58750 80 58750 {
lab=word979}
N 10 58740 10 58790 {
lab=GND}
N 10 58790 10 58800 {
lab=GND}
N 70 58740 70 58790 {
lab=Y0}
N 70 58790 70 58800 {
lab=Y0}
N 90 58800 120 58800 {
lab=GND}
N 120 58790 120 58800 {
lab=GND}
N 80 58750 120 58750 {
lab=word979}
N 120 58750 160 58750 {
lab=word979}
N 90 58740 90 58790 {
lab=GND}
N 90 58790 90 58800 {
lab=GND}
N 150 58740 150 58790 {
lab=Y1}
N 150 58790 150 58800 {
lab=Y1}
N 160 58750 200 58750 {
lab=word979}
N 200 58750 240 58750 {
lab=word979}
N 170 58740 170 58790 {
lab=GND}
N 170 58790 170 58800 {
lab=GND}
N 230 58740 230 58790 {
lab=Y2}
N 230 58790 230 58800 {
lab=Y2}
N 240 58750 280 58750 {
lab=word979}
N 280 58750 320 58750 {
lab=word979}
N 250 58740 250 58790 {
lab=GND}
N 250 58790 250 58800 {
lab=GND}
N 310 58740 310 58790 {
lab=Y3}
N 310 58790 310 58800 {
lab=Y3}
N 320 58750 360 58750 {
lab=word979}
N 360 58750 400 58750 {
lab=word979}
N 330 58740 330 58790 {
lab=GND}
N 330 58790 330 58800 {
lab=GND}
N 390 58740 390 58790 {
lab=Y4}
N 390 58790 390 58800 {
lab=Y4}
N 410 58800 440 58800 {
lab=GND}
N 440 58790 440 58800 {
lab=GND}
N 400 58750 440 58750 {
lab=word979}
N 440 58750 480 58750 {
lab=word979}
N 410 58740 410 58790 {
lab=GND}
N 410 58790 410 58800 {
lab=GND}
N 470 58740 470 58790 {
lab=Y5}
N 470 58790 470 58800 {
lab=Y5}
N 490 58800 520 58800 {
lab=GND}
N 520 58790 520 58800 {
lab=GND}
N 480 58750 520 58750 {
lab=word979}
N 520 58750 560 58750 {
lab=word979}
N 490 58740 490 58790 {
lab=GND}
N 490 58790 490 58800 {
lab=GND}
N 550 58740 550 58790 {
lab=Y6}
N 550 58790 550 58800 {
lab=Y6}
N 560 58750 600 58750 {
lab=word979}
N 600 58750 640 58750 {
lab=word979}
N 570 58740 570 58790 {
lab=GND}
N 570 58790 570 58800 {
lab=GND}
N 630 58740 630 58790 {
lab=Y7}
N 630 58790 630 58800 {
lab=Y7}
N 0 58810 40 58810 {
lab=word980}
N 40 58810 80 58810 {
lab=word980}
N 10 58800 10 58850 {
lab=GND}
N 10 58850 10 58860 {
lab=GND}
N 70 58800 70 58850 {
lab=Y0}
N 70 58850 70 58860 {
lab=Y0}
N 90 58860 120 58860 {
lab=GND}
N 120 58850 120 58860 {
lab=GND}
N 80 58810 120 58810 {
lab=word980}
N 120 58810 160 58810 {
lab=word980}
N 90 58800 90 58850 {
lab=GND}
N 90 58850 90 58860 {
lab=GND}
N 150 58800 150 58850 {
lab=Y1}
N 150 58850 150 58860 {
lab=Y1}
N 160 58810 200 58810 {
lab=word980}
N 200 58810 240 58810 {
lab=word980}
N 170 58800 170 58850 {
lab=GND}
N 170 58850 170 58860 {
lab=GND}
N 230 58800 230 58850 {
lab=Y2}
N 230 58850 230 58860 {
lab=Y2}
N 240 58810 280 58810 {
lab=word980}
N 280 58810 320 58810 {
lab=word980}
N 250 58800 250 58850 {
lab=GND}
N 250 58850 250 58860 {
lab=GND}
N 310 58800 310 58850 {
lab=Y3}
N 310 58850 310 58860 {
lab=Y3}
N 320 58810 360 58810 {
lab=word980}
N 360 58810 400 58810 {
lab=word980}
N 330 58800 330 58850 {
lab=GND}
N 330 58850 330 58860 {
lab=GND}
N 390 58800 390 58850 {
lab=Y4}
N 390 58850 390 58860 {
lab=Y4}
N 400 58810 440 58810 {
lab=word980}
N 440 58810 480 58810 {
lab=word980}
N 410 58800 410 58850 {
lab=GND}
N 410 58850 410 58860 {
lab=GND}
N 470 58800 470 58850 {
lab=Y5}
N 470 58850 470 58860 {
lab=Y5}
N 490 58860 520 58860 {
lab=GND}
N 520 58850 520 58860 {
lab=GND}
N 480 58810 520 58810 {
lab=word980}
N 520 58810 560 58810 {
lab=word980}
N 490 58800 490 58850 {
lab=GND}
N 490 58850 490 58860 {
lab=GND}
N 550 58800 550 58850 {
lab=Y6}
N 550 58850 550 58860 {
lab=Y6}
N 570 58860 600 58860 {
lab=GND}
N 600 58850 600 58860 {
lab=GND}
N 560 58810 600 58810 {
lab=word980}
N 600 58810 640 58810 {
lab=word980}
N 570 58800 570 58850 {
lab=GND}
N 570 58850 570 58860 {
lab=GND}
N 630 58800 630 58850 {
lab=Y7}
N 630 58850 630 58860 {
lab=Y7}
N 0 58870 40 58870 {
lab=word981}
N 40 58870 80 58870 {
lab=word981}
N 10 58860 10 58910 {
lab=GND}
N 10 58910 10 58920 {
lab=GND}
N 70 58860 70 58910 {
lab=Y0}
N 70 58910 70 58920 {
lab=Y0}
N 90 58920 120 58920 {
lab=GND}
N 120 58910 120 58920 {
lab=GND}
N 80 58870 120 58870 {
lab=word981}
N 120 58870 160 58870 {
lab=word981}
N 90 58860 90 58910 {
lab=GND}
N 90 58910 90 58920 {
lab=GND}
N 150 58860 150 58910 {
lab=Y1}
N 150 58910 150 58920 {
lab=Y1}
N 160 58870 200 58870 {
lab=word981}
N 200 58870 240 58870 {
lab=word981}
N 170 58860 170 58910 {
lab=GND}
N 170 58910 170 58920 {
lab=GND}
N 230 58860 230 58910 {
lab=Y2}
N 230 58910 230 58920 {
lab=Y2}
N 240 58870 280 58870 {
lab=word981}
N 280 58870 320 58870 {
lab=word981}
N 250 58860 250 58910 {
lab=GND}
N 250 58910 250 58920 {
lab=GND}
N 310 58860 310 58910 {
lab=Y3}
N 310 58910 310 58920 {
lab=Y3}
N 320 58870 360 58870 {
lab=word981}
N 360 58870 400 58870 {
lab=word981}
N 330 58860 330 58910 {
lab=GND}
N 330 58910 330 58920 {
lab=GND}
N 390 58860 390 58910 {
lab=Y4}
N 390 58910 390 58920 {
lab=Y4}
N 400 58870 440 58870 {
lab=word981}
N 440 58870 480 58870 {
lab=word981}
N 410 58860 410 58910 {
lab=GND}
N 410 58910 410 58920 {
lab=GND}
N 470 58860 470 58910 {
lab=Y5}
N 470 58910 470 58920 {
lab=Y5}
N 480 58870 520 58870 {
lab=word981}
N 520 58870 560 58870 {
lab=word981}
N 490 58860 490 58910 {
lab=GND}
N 490 58910 490 58920 {
lab=GND}
N 550 58860 550 58910 {
lab=Y6}
N 550 58910 550 58920 {
lab=Y6}
N 570 58920 600 58920 {
lab=GND}
N 600 58910 600 58920 {
lab=GND}
N 560 58870 600 58870 {
lab=word981}
N 600 58870 640 58870 {
lab=word981}
N 570 58860 570 58910 {
lab=GND}
N 570 58910 570 58920 {
lab=GND}
N 630 58860 630 58910 {
lab=Y7}
N 630 58910 630 58920 {
lab=Y7}
N 0 58930 40 58930 {
lab=word982}
N 40 58930 80 58930 {
lab=word982}
N 10 58920 10 58970 {
lab=GND}
N 10 58970 10 58980 {
lab=GND}
N 70 58920 70 58970 {
lab=Y0}
N 70 58970 70 58980 {
lab=Y0}
N 80 58930 120 58930 {
lab=word982}
N 120 58930 160 58930 {
lab=word982}
N 90 58920 90 58970 {
lab=GND}
N 90 58970 90 58980 {
lab=GND}
N 150 58920 150 58970 {
lab=Y1}
N 150 58970 150 58980 {
lab=Y1}
N 170 58980 200 58980 {
lab=GND}
N 200 58970 200 58980 {
lab=GND}
N 160 58930 200 58930 {
lab=word982}
N 200 58930 240 58930 {
lab=word982}
N 170 58920 170 58970 {
lab=GND}
N 170 58970 170 58980 {
lab=GND}
N 230 58920 230 58970 {
lab=Y2}
N 230 58970 230 58980 {
lab=Y2}
N 250 58980 280 58980 {
lab=GND}
N 280 58970 280 58980 {
lab=GND}
N 240 58930 280 58930 {
lab=word982}
N 280 58930 320 58930 {
lab=word982}
N 250 58920 250 58970 {
lab=GND}
N 250 58970 250 58980 {
lab=GND}
N 310 58920 310 58970 {
lab=Y3}
N 310 58970 310 58980 {
lab=Y3}
N 330 58980 360 58980 {
lab=GND}
N 360 58970 360 58980 {
lab=GND}
N 320 58930 360 58930 {
lab=word982}
N 360 58930 400 58930 {
lab=word982}
N 330 58920 330 58970 {
lab=GND}
N 330 58970 330 58980 {
lab=GND}
N 390 58920 390 58970 {
lab=Y4}
N 390 58970 390 58980 {
lab=Y4}
N 410 58980 440 58980 {
lab=GND}
N 440 58970 440 58980 {
lab=GND}
N 400 58930 440 58930 {
lab=word982}
N 440 58930 480 58930 {
lab=word982}
N 410 58920 410 58970 {
lab=GND}
N 410 58970 410 58980 {
lab=GND}
N 470 58920 470 58970 {
lab=Y5}
N 470 58970 470 58980 {
lab=Y5}
N 490 58980 520 58980 {
lab=GND}
N 520 58970 520 58980 {
lab=GND}
N 480 58930 520 58930 {
lab=word982}
N 520 58930 560 58930 {
lab=word982}
N 490 58920 490 58970 {
lab=GND}
N 490 58970 490 58980 {
lab=GND}
N 550 58920 550 58970 {
lab=Y6}
N 550 58970 550 58980 {
lab=Y6}
N 560 58930 600 58930 {
lab=word982}
N 600 58930 640 58930 {
lab=word982}
N 570 58920 570 58970 {
lab=GND}
N 570 58970 570 58980 {
lab=GND}
N 630 58920 630 58970 {
lab=Y7}
N 630 58970 630 58980 {
lab=Y7}
N 0 58990 40 58990 {
lab=word983}
N 40 58990 80 58990 {
lab=word983}
N 10 58980 10 59030 {
lab=GND}
N 10 59030 10 59040 {
lab=GND}
N 70 58980 70 59030 {
lab=Y0}
N 70 59030 70 59040 {
lab=Y0}
N 80 58990 120 58990 {
lab=word983}
N 120 58990 160 58990 {
lab=word983}
N 90 58980 90 59030 {
lab=GND}
N 90 59030 90 59040 {
lab=GND}
N 150 58980 150 59030 {
lab=Y1}
N 150 59030 150 59040 {
lab=Y1}
N 170 59040 200 59040 {
lab=GND}
N 200 59030 200 59040 {
lab=GND}
N 160 58990 200 58990 {
lab=word983}
N 200 58990 240 58990 {
lab=word983}
N 170 58980 170 59030 {
lab=GND}
N 170 59030 170 59040 {
lab=GND}
N 230 58980 230 59030 {
lab=Y2}
N 230 59030 230 59040 {
lab=Y2}
N 250 59040 280 59040 {
lab=GND}
N 280 59030 280 59040 {
lab=GND}
N 240 58990 280 58990 {
lab=word983}
N 280 58990 320 58990 {
lab=word983}
N 250 58980 250 59030 {
lab=GND}
N 250 59030 250 59040 {
lab=GND}
N 310 58980 310 59030 {
lab=Y3}
N 310 59030 310 59040 {
lab=Y3}
N 330 59040 360 59040 {
lab=GND}
N 360 59030 360 59040 {
lab=GND}
N 320 58990 360 58990 {
lab=word983}
N 360 58990 400 58990 {
lab=word983}
N 330 58980 330 59030 {
lab=GND}
N 330 59030 330 59040 {
lab=GND}
N 390 58980 390 59030 {
lab=Y4}
N 390 59030 390 59040 {
lab=Y4}
N 400 58990 440 58990 {
lab=word983}
N 440 58990 480 58990 {
lab=word983}
N 410 58980 410 59030 {
lab=GND}
N 410 59030 410 59040 {
lab=GND}
N 470 58980 470 59030 {
lab=Y5}
N 470 59030 470 59040 {
lab=Y5}
N 490 59040 520 59040 {
lab=GND}
N 520 59030 520 59040 {
lab=GND}
N 480 58990 520 58990 {
lab=word983}
N 520 58990 560 58990 {
lab=word983}
N 490 58980 490 59030 {
lab=GND}
N 490 59030 490 59040 {
lab=GND}
N 550 58980 550 59030 {
lab=Y6}
N 550 59030 550 59040 {
lab=Y6}
N 570 59040 600 59040 {
lab=GND}
N 600 59030 600 59040 {
lab=GND}
N 560 58990 600 58990 {
lab=word983}
N 600 58990 640 58990 {
lab=word983}
N 570 58980 570 59030 {
lab=GND}
N 570 59030 570 59040 {
lab=GND}
N 630 58980 630 59030 {
lab=Y7}
N 630 59030 630 59040 {
lab=Y7}
N 0 59050 40 59050 {
lab=word984}
N 40 59050 80 59050 {
lab=word984}
N 10 59040 10 59090 {
lab=GND}
N 10 59090 10 59100 {
lab=GND}
N 70 59040 70 59090 {
lab=Y0}
N 70 59090 70 59100 {
lab=Y0}
N 80 59050 120 59050 {
lab=word984}
N 120 59050 160 59050 {
lab=word984}
N 90 59040 90 59090 {
lab=GND}
N 90 59090 90 59100 {
lab=GND}
N 150 59040 150 59090 {
lab=Y1}
N 150 59090 150 59100 {
lab=Y1}
N 170 59100 200 59100 {
lab=GND}
N 200 59090 200 59100 {
lab=GND}
N 160 59050 200 59050 {
lab=word984}
N 200 59050 240 59050 {
lab=word984}
N 170 59040 170 59090 {
lab=GND}
N 170 59090 170 59100 {
lab=GND}
N 230 59040 230 59090 {
lab=Y2}
N 230 59090 230 59100 {
lab=Y2}
N 250 59100 280 59100 {
lab=GND}
N 280 59090 280 59100 {
lab=GND}
N 240 59050 280 59050 {
lab=word984}
N 280 59050 320 59050 {
lab=word984}
N 250 59040 250 59090 {
lab=GND}
N 250 59090 250 59100 {
lab=GND}
N 310 59040 310 59090 {
lab=Y3}
N 310 59090 310 59100 {
lab=Y3}
N 330 59100 360 59100 {
lab=GND}
N 360 59090 360 59100 {
lab=GND}
N 320 59050 360 59050 {
lab=word984}
N 360 59050 400 59050 {
lab=word984}
N 330 59040 330 59090 {
lab=GND}
N 330 59090 330 59100 {
lab=GND}
N 390 59040 390 59090 {
lab=Y4}
N 390 59090 390 59100 {
lab=Y4}
N 400 59050 440 59050 {
lab=word984}
N 440 59050 480 59050 {
lab=word984}
N 410 59040 410 59090 {
lab=GND}
N 410 59090 410 59100 {
lab=GND}
N 470 59040 470 59090 {
lab=Y5}
N 470 59090 470 59100 {
lab=Y5}
N 480 59050 520 59050 {
lab=word984}
N 520 59050 560 59050 {
lab=word984}
N 490 59040 490 59090 {
lab=GND}
N 490 59090 490 59100 {
lab=GND}
N 550 59040 550 59090 {
lab=Y6}
N 550 59090 550 59100 {
lab=Y6}
N 570 59100 600 59100 {
lab=GND}
N 600 59090 600 59100 {
lab=GND}
N 560 59050 600 59050 {
lab=word984}
N 600 59050 640 59050 {
lab=word984}
N 570 59040 570 59090 {
lab=GND}
N 570 59090 570 59100 {
lab=GND}
N 630 59040 630 59090 {
lab=Y7}
N 630 59090 630 59100 {
lab=Y7}
N 0 59110 40 59110 {
lab=word985}
N 40 59110 80 59110 {
lab=word985}
N 10 59100 10 59150 {
lab=GND}
N 10 59150 10 59160 {
lab=GND}
N 70 59100 70 59150 {
lab=Y0}
N 70 59150 70 59160 {
lab=Y0}
N 80 59110 120 59110 {
lab=word985}
N 120 59110 160 59110 {
lab=word985}
N 90 59100 90 59150 {
lab=GND}
N 90 59150 90 59160 {
lab=GND}
N 150 59100 150 59150 {
lab=Y1}
N 150 59150 150 59160 {
lab=Y1}
N 170 59160 200 59160 {
lab=GND}
N 200 59150 200 59160 {
lab=GND}
N 160 59110 200 59110 {
lab=word985}
N 200 59110 240 59110 {
lab=word985}
N 170 59100 170 59150 {
lab=GND}
N 170 59150 170 59160 {
lab=GND}
N 230 59100 230 59150 {
lab=Y2}
N 230 59150 230 59160 {
lab=Y2}
N 250 59160 280 59160 {
lab=GND}
N 280 59150 280 59160 {
lab=GND}
N 240 59110 280 59110 {
lab=word985}
N 280 59110 320 59110 {
lab=word985}
N 250 59100 250 59150 {
lab=GND}
N 250 59150 250 59160 {
lab=GND}
N 310 59100 310 59150 {
lab=Y3}
N 310 59150 310 59160 {
lab=Y3}
N 320 59110 360 59110 {
lab=word985}
N 360 59110 400 59110 {
lab=word985}
N 330 59100 330 59150 {
lab=GND}
N 330 59150 330 59160 {
lab=GND}
N 390 59100 390 59150 {
lab=Y4}
N 390 59150 390 59160 {
lab=Y4}
N 410 59160 440 59160 {
lab=GND}
N 440 59150 440 59160 {
lab=GND}
N 400 59110 440 59110 {
lab=word985}
N 440 59110 480 59110 {
lab=word985}
N 410 59100 410 59150 {
lab=GND}
N 410 59150 410 59160 {
lab=GND}
N 470 59100 470 59150 {
lab=Y5}
N 470 59150 470 59160 {
lab=Y5}
N 490 59160 520 59160 {
lab=GND}
N 520 59150 520 59160 {
lab=GND}
N 480 59110 520 59110 {
lab=word985}
N 520 59110 560 59110 {
lab=word985}
N 490 59100 490 59150 {
lab=GND}
N 490 59150 490 59160 {
lab=GND}
N 550 59100 550 59150 {
lab=Y6}
N 550 59150 550 59160 {
lab=Y6}
N 560 59110 600 59110 {
lab=word985}
N 600 59110 640 59110 {
lab=word985}
N 570 59100 570 59150 {
lab=GND}
N 570 59150 570 59160 {
lab=GND}
N 630 59100 630 59150 {
lab=Y7}
N 630 59150 630 59160 {
lab=Y7}
N 0 59170 40 59170 {
lab=word986}
N 40 59170 80 59170 {
lab=word986}
N 10 59160 10 59210 {
lab=GND}
N 10 59210 10 59220 {
lab=GND}
N 70 59160 70 59210 {
lab=Y0}
N 70 59210 70 59220 {
lab=Y0}
N 80 59170 120 59170 {
lab=word986}
N 120 59170 160 59170 {
lab=word986}
N 90 59160 90 59210 {
lab=GND}
N 90 59210 90 59220 {
lab=GND}
N 150 59160 150 59210 {
lab=Y1}
N 150 59210 150 59220 {
lab=Y1}
N 170 59220 200 59220 {
lab=GND}
N 200 59210 200 59220 {
lab=GND}
N 160 59170 200 59170 {
lab=word986}
N 200 59170 240 59170 {
lab=word986}
N 170 59160 170 59210 {
lab=GND}
N 170 59210 170 59220 {
lab=GND}
N 230 59160 230 59210 {
lab=Y2}
N 230 59210 230 59220 {
lab=Y2}
N 250 59220 280 59220 {
lab=GND}
N 280 59210 280 59220 {
lab=GND}
N 240 59170 280 59170 {
lab=word986}
N 280 59170 320 59170 {
lab=word986}
N 250 59160 250 59210 {
lab=GND}
N 250 59210 250 59220 {
lab=GND}
N 310 59160 310 59210 {
lab=Y3}
N 310 59210 310 59220 {
lab=Y3}
N 320 59170 360 59170 {
lab=word986}
N 360 59170 400 59170 {
lab=word986}
N 330 59160 330 59210 {
lab=GND}
N 330 59210 330 59220 {
lab=GND}
N 390 59160 390 59210 {
lab=Y4}
N 390 59210 390 59220 {
lab=Y4}
N 410 59220 440 59220 {
lab=GND}
N 440 59210 440 59220 {
lab=GND}
N 400 59170 440 59170 {
lab=word986}
N 440 59170 480 59170 {
lab=word986}
N 410 59160 410 59210 {
lab=GND}
N 410 59210 410 59220 {
lab=GND}
N 470 59160 470 59210 {
lab=Y5}
N 470 59210 470 59220 {
lab=Y5}
N 480 59170 520 59170 {
lab=word986}
N 520 59170 560 59170 {
lab=word986}
N 490 59160 490 59210 {
lab=GND}
N 490 59210 490 59220 {
lab=GND}
N 550 59160 550 59210 {
lab=Y6}
N 550 59210 550 59220 {
lab=Y6}
N 560 59170 600 59170 {
lab=word986}
N 600 59170 640 59170 {
lab=word986}
N 570 59160 570 59210 {
lab=GND}
N 570 59210 570 59220 {
lab=GND}
N 630 59160 630 59210 {
lab=Y7}
N 630 59210 630 59220 {
lab=Y7}
N 0 59230 40 59230 {
lab=word987}
N 40 59230 80 59230 {
lab=word987}
N 10 59220 10 59270 {
lab=GND}
N 10 59270 10 59280 {
lab=GND}
N 70 59220 70 59270 {
lab=Y0}
N 70 59270 70 59280 {
lab=Y0}
N 80 59230 120 59230 {
lab=word987}
N 120 59230 160 59230 {
lab=word987}
N 90 59220 90 59270 {
lab=GND}
N 90 59270 90 59280 {
lab=GND}
N 150 59220 150 59270 {
lab=Y1}
N 150 59270 150 59280 {
lab=Y1}
N 170 59280 200 59280 {
lab=GND}
N 200 59270 200 59280 {
lab=GND}
N 160 59230 200 59230 {
lab=word987}
N 200 59230 240 59230 {
lab=word987}
N 170 59220 170 59270 {
lab=GND}
N 170 59270 170 59280 {
lab=GND}
N 230 59220 230 59270 {
lab=Y2}
N 230 59270 230 59280 {
lab=Y2}
N 250 59280 280 59280 {
lab=GND}
N 280 59270 280 59280 {
lab=GND}
N 240 59230 280 59230 {
lab=word987}
N 280 59230 320 59230 {
lab=word987}
N 250 59220 250 59270 {
lab=GND}
N 250 59270 250 59280 {
lab=GND}
N 310 59220 310 59270 {
lab=Y3}
N 310 59270 310 59280 {
lab=Y3}
N 320 59230 360 59230 {
lab=word987}
N 360 59230 400 59230 {
lab=word987}
N 330 59220 330 59270 {
lab=GND}
N 330 59270 330 59280 {
lab=GND}
N 390 59220 390 59270 {
lab=Y4}
N 390 59270 390 59280 {
lab=Y4}
N 400 59230 440 59230 {
lab=word987}
N 440 59230 480 59230 {
lab=word987}
N 410 59220 410 59270 {
lab=GND}
N 410 59270 410 59280 {
lab=GND}
N 470 59220 470 59270 {
lab=Y5}
N 470 59270 470 59280 {
lab=Y5}
N 480 59230 520 59230 {
lab=word987}
N 520 59230 560 59230 {
lab=word987}
N 490 59220 490 59270 {
lab=GND}
N 490 59270 490 59280 {
lab=GND}
N 550 59220 550 59270 {
lab=Y6}
N 550 59270 550 59280 {
lab=Y6}
N 570 59280 600 59280 {
lab=GND}
N 600 59270 600 59280 {
lab=GND}
N 560 59230 600 59230 {
lab=word987}
N 600 59230 640 59230 {
lab=word987}
N 570 59220 570 59270 {
lab=GND}
N 570 59270 570 59280 {
lab=GND}
N 630 59220 630 59270 {
lab=Y7}
N 630 59270 630 59280 {
lab=Y7}
N 0 59290 40 59290 {
lab=word988}
N 40 59290 80 59290 {
lab=word988}
N 10 59280 10 59330 {
lab=GND}
N 10 59330 10 59340 {
lab=GND}
N 70 59280 70 59330 {
lab=Y0}
N 70 59330 70 59340 {
lab=Y0}
N 80 59290 120 59290 {
lab=word988}
N 120 59290 160 59290 {
lab=word988}
N 90 59280 90 59330 {
lab=GND}
N 90 59330 90 59340 {
lab=GND}
N 150 59280 150 59330 {
lab=Y1}
N 150 59330 150 59340 {
lab=Y1}
N 170 59340 200 59340 {
lab=GND}
N 200 59330 200 59340 {
lab=GND}
N 160 59290 200 59290 {
lab=word988}
N 200 59290 240 59290 {
lab=word988}
N 170 59280 170 59330 {
lab=GND}
N 170 59330 170 59340 {
lab=GND}
N 230 59280 230 59330 {
lab=Y2}
N 230 59330 230 59340 {
lab=Y2}
N 240 59290 280 59290 {
lab=word988}
N 280 59290 320 59290 {
lab=word988}
N 250 59280 250 59330 {
lab=GND}
N 250 59330 250 59340 {
lab=GND}
N 310 59280 310 59330 {
lab=Y3}
N 310 59330 310 59340 {
lab=Y3}
N 330 59340 360 59340 {
lab=GND}
N 360 59330 360 59340 {
lab=GND}
N 320 59290 360 59290 {
lab=word988}
N 360 59290 400 59290 {
lab=word988}
N 330 59280 330 59330 {
lab=GND}
N 330 59330 330 59340 {
lab=GND}
N 390 59280 390 59330 {
lab=Y4}
N 390 59330 390 59340 {
lab=Y4}
N 410 59340 440 59340 {
lab=GND}
N 440 59330 440 59340 {
lab=GND}
N 400 59290 440 59290 {
lab=word988}
N 440 59290 480 59290 {
lab=word988}
N 410 59280 410 59330 {
lab=GND}
N 410 59330 410 59340 {
lab=GND}
N 470 59280 470 59330 {
lab=Y5}
N 470 59330 470 59340 {
lab=Y5}
N 490 59340 520 59340 {
lab=GND}
N 520 59330 520 59340 {
lab=GND}
N 480 59290 520 59290 {
lab=word988}
N 520 59290 560 59290 {
lab=word988}
N 490 59280 490 59330 {
lab=GND}
N 490 59330 490 59340 {
lab=GND}
N 550 59280 550 59330 {
lab=Y6}
N 550 59330 550 59340 {
lab=Y6}
N 570 59340 600 59340 {
lab=GND}
N 600 59330 600 59340 {
lab=GND}
N 560 59290 600 59290 {
lab=word988}
N 600 59290 640 59290 {
lab=word988}
N 570 59280 570 59330 {
lab=GND}
N 570 59330 570 59340 {
lab=GND}
N 630 59280 630 59330 {
lab=Y7}
N 630 59330 630 59340 {
lab=Y7}
N 0 59350 40 59350 {
lab=word989}
N 40 59350 80 59350 {
lab=word989}
N 10 59340 10 59390 {
lab=GND}
N 10 59390 10 59400 {
lab=GND}
N 70 59340 70 59390 {
lab=Y0}
N 70 59390 70 59400 {
lab=Y0}
N 80 59350 120 59350 {
lab=word989}
N 120 59350 160 59350 {
lab=word989}
N 90 59340 90 59390 {
lab=GND}
N 90 59390 90 59400 {
lab=GND}
N 150 59340 150 59390 {
lab=Y1}
N 150 59390 150 59400 {
lab=Y1}
N 170 59400 200 59400 {
lab=GND}
N 200 59390 200 59400 {
lab=GND}
N 160 59350 200 59350 {
lab=word989}
N 200 59350 240 59350 {
lab=word989}
N 170 59340 170 59390 {
lab=GND}
N 170 59390 170 59400 {
lab=GND}
N 230 59340 230 59390 {
lab=Y2}
N 230 59390 230 59400 {
lab=Y2}
N 240 59350 280 59350 {
lab=word989}
N 280 59350 320 59350 {
lab=word989}
N 250 59340 250 59390 {
lab=GND}
N 250 59390 250 59400 {
lab=GND}
N 310 59340 310 59390 {
lab=Y3}
N 310 59390 310 59400 {
lab=Y3}
N 330 59400 360 59400 {
lab=GND}
N 360 59390 360 59400 {
lab=GND}
N 320 59350 360 59350 {
lab=word989}
N 360 59350 400 59350 {
lab=word989}
N 330 59340 330 59390 {
lab=GND}
N 330 59390 330 59400 {
lab=GND}
N 390 59340 390 59390 {
lab=Y4}
N 390 59390 390 59400 {
lab=Y4}
N 410 59400 440 59400 {
lab=GND}
N 440 59390 440 59400 {
lab=GND}
N 400 59350 440 59350 {
lab=word989}
N 440 59350 480 59350 {
lab=word989}
N 410 59340 410 59390 {
lab=GND}
N 410 59390 410 59400 {
lab=GND}
N 470 59340 470 59390 {
lab=Y5}
N 470 59390 470 59400 {
lab=Y5}
N 480 59350 520 59350 {
lab=word989}
N 520 59350 560 59350 {
lab=word989}
N 490 59340 490 59390 {
lab=GND}
N 490 59390 490 59400 {
lab=GND}
N 550 59340 550 59390 {
lab=Y6}
N 550 59390 550 59400 {
lab=Y6}
N 560 59350 600 59350 {
lab=word989}
N 600 59350 640 59350 {
lab=word989}
N 570 59340 570 59390 {
lab=GND}
N 570 59390 570 59400 {
lab=GND}
N 630 59340 630 59390 {
lab=Y7}
N 630 59390 630 59400 {
lab=Y7}
N 0 59410 40 59410 {
lab=word990}
N 40 59410 80 59410 {
lab=word990}
N 10 59400 10 59450 {
lab=GND}
N 10 59450 10 59460 {
lab=GND}
N 70 59400 70 59450 {
lab=Y0}
N 70 59450 70 59460 {
lab=Y0}
N 80 59410 120 59410 {
lab=word990}
N 120 59410 160 59410 {
lab=word990}
N 90 59400 90 59450 {
lab=GND}
N 90 59450 90 59460 {
lab=GND}
N 150 59400 150 59450 {
lab=Y1}
N 150 59450 150 59460 {
lab=Y1}
N 170 59460 200 59460 {
lab=GND}
N 200 59450 200 59460 {
lab=GND}
N 160 59410 200 59410 {
lab=word990}
N 200 59410 240 59410 {
lab=word990}
N 170 59400 170 59450 {
lab=GND}
N 170 59450 170 59460 {
lab=GND}
N 230 59400 230 59450 {
lab=Y2}
N 230 59450 230 59460 {
lab=Y2}
N 240 59410 280 59410 {
lab=word990}
N 280 59410 320 59410 {
lab=word990}
N 250 59400 250 59450 {
lab=GND}
N 250 59450 250 59460 {
lab=GND}
N 310 59400 310 59450 {
lab=Y3}
N 310 59450 310 59460 {
lab=Y3}
N 330 59460 360 59460 {
lab=GND}
N 360 59450 360 59460 {
lab=GND}
N 320 59410 360 59410 {
lab=word990}
N 360 59410 400 59410 {
lab=word990}
N 330 59400 330 59450 {
lab=GND}
N 330 59450 330 59460 {
lab=GND}
N 390 59400 390 59450 {
lab=Y4}
N 390 59450 390 59460 {
lab=Y4}
N 400 59410 440 59410 {
lab=word990}
N 440 59410 480 59410 {
lab=word990}
N 410 59400 410 59450 {
lab=GND}
N 410 59450 410 59460 {
lab=GND}
N 470 59400 470 59450 {
lab=Y5}
N 470 59450 470 59460 {
lab=Y5}
N 490 59460 520 59460 {
lab=GND}
N 520 59450 520 59460 {
lab=GND}
N 480 59410 520 59410 {
lab=word990}
N 520 59410 560 59410 {
lab=word990}
N 490 59400 490 59450 {
lab=GND}
N 490 59450 490 59460 {
lab=GND}
N 550 59400 550 59450 {
lab=Y6}
N 550 59450 550 59460 {
lab=Y6}
N 560 59410 600 59410 {
lab=word990}
N 600 59410 640 59410 {
lab=word990}
N 570 59400 570 59450 {
lab=GND}
N 570 59450 570 59460 {
lab=GND}
N 630 59400 630 59450 {
lab=Y7}
N 630 59450 630 59460 {
lab=Y7}
N 0 59470 40 59470 {
lab=word991}
N 40 59470 80 59470 {
lab=word991}
N 10 59460 10 59510 {
lab=GND}
N 10 59510 10 59520 {
lab=GND}
N 70 59460 70 59510 {
lab=Y0}
N 70 59510 70 59520 {
lab=Y0}
N 80 59470 120 59470 {
lab=word991}
N 120 59470 160 59470 {
lab=word991}
N 90 59460 90 59510 {
lab=GND}
N 90 59510 90 59520 {
lab=GND}
N 150 59460 150 59510 {
lab=Y1}
N 150 59510 150 59520 {
lab=Y1}
N 170 59520 200 59520 {
lab=GND}
N 200 59510 200 59520 {
lab=GND}
N 160 59470 200 59470 {
lab=word991}
N 200 59470 240 59470 {
lab=word991}
N 170 59460 170 59510 {
lab=GND}
N 170 59510 170 59520 {
lab=GND}
N 230 59460 230 59510 {
lab=Y2}
N 230 59510 230 59520 {
lab=Y2}
N 240 59470 280 59470 {
lab=word991}
N 280 59470 320 59470 {
lab=word991}
N 250 59460 250 59510 {
lab=GND}
N 250 59510 250 59520 {
lab=GND}
N 310 59460 310 59510 {
lab=Y3}
N 310 59510 310 59520 {
lab=Y3}
N 330 59520 360 59520 {
lab=GND}
N 360 59510 360 59520 {
lab=GND}
N 320 59470 360 59470 {
lab=word991}
N 360 59470 400 59470 {
lab=word991}
N 330 59460 330 59510 {
lab=GND}
N 330 59510 330 59520 {
lab=GND}
N 390 59460 390 59510 {
lab=Y4}
N 390 59510 390 59520 {
lab=Y4}
N 400 59470 440 59470 {
lab=word991}
N 440 59470 480 59470 {
lab=word991}
N 410 59460 410 59510 {
lab=GND}
N 410 59510 410 59520 {
lab=GND}
N 470 59460 470 59510 {
lab=Y5}
N 470 59510 470 59520 {
lab=Y5}
N 480 59470 520 59470 {
lab=word991}
N 520 59470 560 59470 {
lab=word991}
N 490 59460 490 59510 {
lab=GND}
N 490 59510 490 59520 {
lab=GND}
N 550 59460 550 59510 {
lab=Y6}
N 550 59510 550 59520 {
lab=Y6}
N 560 59470 600 59470 {
lab=word991}
N 600 59470 640 59470 {
lab=word991}
N 570 59460 570 59510 {
lab=GND}
N 570 59510 570 59520 {
lab=GND}
N 630 59460 630 59510 {
lab=Y7}
N 630 59510 630 59520 {
lab=Y7}
N 0 59530 40 59530 {
lab=word992}
N 40 59530 80 59530 {
lab=word992}
N 10 59520 10 59570 {
lab=GND}
N 10 59570 10 59580 {
lab=GND}
N 70 59520 70 59570 {
lab=Y0}
N 70 59570 70 59580 {
lab=Y0}
N 80 59530 120 59530 {
lab=word992}
N 120 59530 160 59530 {
lab=word992}
N 90 59520 90 59570 {
lab=GND}
N 90 59570 90 59580 {
lab=GND}
N 150 59520 150 59570 {
lab=Y1}
N 150 59570 150 59580 {
lab=Y1}
N 170 59580 200 59580 {
lab=GND}
N 200 59570 200 59580 {
lab=GND}
N 160 59530 200 59530 {
lab=word992}
N 200 59530 240 59530 {
lab=word992}
N 170 59520 170 59570 {
lab=GND}
N 170 59570 170 59580 {
lab=GND}
N 230 59520 230 59570 {
lab=Y2}
N 230 59570 230 59580 {
lab=Y2}
N 240 59530 280 59530 {
lab=word992}
N 280 59530 320 59530 {
lab=word992}
N 250 59520 250 59570 {
lab=GND}
N 250 59570 250 59580 {
lab=GND}
N 310 59520 310 59570 {
lab=Y3}
N 310 59570 310 59580 {
lab=Y3}
N 320 59530 360 59530 {
lab=word992}
N 360 59530 400 59530 {
lab=word992}
N 330 59520 330 59570 {
lab=GND}
N 330 59570 330 59580 {
lab=GND}
N 390 59520 390 59570 {
lab=Y4}
N 390 59570 390 59580 {
lab=Y4}
N 410 59580 440 59580 {
lab=GND}
N 440 59570 440 59580 {
lab=GND}
N 400 59530 440 59530 {
lab=word992}
N 440 59530 480 59530 {
lab=word992}
N 410 59520 410 59570 {
lab=GND}
N 410 59570 410 59580 {
lab=GND}
N 470 59520 470 59570 {
lab=Y5}
N 470 59570 470 59580 {
lab=Y5}
N 480 59530 520 59530 {
lab=word992}
N 520 59530 560 59530 {
lab=word992}
N 490 59520 490 59570 {
lab=GND}
N 490 59570 490 59580 {
lab=GND}
N 550 59520 550 59570 {
lab=Y6}
N 550 59570 550 59580 {
lab=Y6}
N 570 59580 600 59580 {
lab=GND}
N 600 59570 600 59580 {
lab=GND}
N 560 59530 600 59530 {
lab=word992}
N 600 59530 640 59530 {
lab=word992}
N 570 59520 570 59570 {
lab=GND}
N 570 59570 570 59580 {
lab=GND}
N 630 59520 630 59570 {
lab=Y7}
N 630 59570 630 59580 {
lab=Y7}
N 0 59590 40 59590 {
lab=word993}
N 40 59590 80 59590 {
lab=word993}
N 10 59580 10 59630 {
lab=GND}
N 10 59630 10 59640 {
lab=GND}
N 70 59580 70 59630 {
lab=Y0}
N 70 59630 70 59640 {
lab=Y0}
N 80 59590 120 59590 {
lab=word993}
N 120 59590 160 59590 {
lab=word993}
N 90 59580 90 59630 {
lab=GND}
N 90 59630 90 59640 {
lab=GND}
N 150 59580 150 59630 {
lab=Y1}
N 150 59630 150 59640 {
lab=Y1}
N 170 59640 200 59640 {
lab=GND}
N 200 59630 200 59640 {
lab=GND}
N 160 59590 200 59590 {
lab=word993}
N 200 59590 240 59590 {
lab=word993}
N 170 59580 170 59630 {
lab=GND}
N 170 59630 170 59640 {
lab=GND}
N 230 59580 230 59630 {
lab=Y2}
N 230 59630 230 59640 {
lab=Y2}
N 240 59590 280 59590 {
lab=word993}
N 280 59590 320 59590 {
lab=word993}
N 250 59580 250 59630 {
lab=GND}
N 250 59630 250 59640 {
lab=GND}
N 310 59580 310 59630 {
lab=Y3}
N 310 59630 310 59640 {
lab=Y3}
N 320 59590 360 59590 {
lab=word993}
N 360 59590 400 59590 {
lab=word993}
N 330 59580 330 59630 {
lab=GND}
N 330 59630 330 59640 {
lab=GND}
N 390 59580 390 59630 {
lab=Y4}
N 390 59630 390 59640 {
lab=Y4}
N 400 59590 440 59590 {
lab=word993}
N 440 59590 480 59590 {
lab=word993}
N 410 59580 410 59630 {
lab=GND}
N 410 59630 410 59640 {
lab=GND}
N 470 59580 470 59630 {
lab=Y5}
N 470 59630 470 59640 {
lab=Y5}
N 490 59640 520 59640 {
lab=GND}
N 520 59630 520 59640 {
lab=GND}
N 480 59590 520 59590 {
lab=word993}
N 520 59590 560 59590 {
lab=word993}
N 490 59580 490 59630 {
lab=GND}
N 490 59630 490 59640 {
lab=GND}
N 550 59580 550 59630 {
lab=Y6}
N 550 59630 550 59640 {
lab=Y6}
N 570 59640 600 59640 {
lab=GND}
N 600 59630 600 59640 {
lab=GND}
N 560 59590 600 59590 {
lab=word993}
N 600 59590 640 59590 {
lab=word993}
N 570 59580 570 59630 {
lab=GND}
N 570 59630 570 59640 {
lab=GND}
N 630 59580 630 59630 {
lab=Y7}
N 630 59630 630 59640 {
lab=Y7}
N 0 59650 40 59650 {
lab=word994}
N 40 59650 80 59650 {
lab=word994}
N 10 59640 10 59690 {
lab=GND}
N 10 59690 10 59700 {
lab=GND}
N 70 59640 70 59690 {
lab=Y0}
N 70 59690 70 59700 {
lab=Y0}
N 80 59650 120 59650 {
lab=word994}
N 120 59650 160 59650 {
lab=word994}
N 90 59640 90 59690 {
lab=GND}
N 90 59690 90 59700 {
lab=GND}
N 150 59640 150 59690 {
lab=Y1}
N 150 59690 150 59700 {
lab=Y1}
N 170 59700 200 59700 {
lab=GND}
N 200 59690 200 59700 {
lab=GND}
N 160 59650 200 59650 {
lab=word994}
N 200 59650 240 59650 {
lab=word994}
N 170 59640 170 59690 {
lab=GND}
N 170 59690 170 59700 {
lab=GND}
N 230 59640 230 59690 {
lab=Y2}
N 230 59690 230 59700 {
lab=Y2}
N 240 59650 280 59650 {
lab=word994}
N 280 59650 320 59650 {
lab=word994}
N 250 59640 250 59690 {
lab=GND}
N 250 59690 250 59700 {
lab=GND}
N 310 59640 310 59690 {
lab=Y3}
N 310 59690 310 59700 {
lab=Y3}
N 320 59650 360 59650 {
lab=word994}
N 360 59650 400 59650 {
lab=word994}
N 330 59640 330 59690 {
lab=GND}
N 330 59690 330 59700 {
lab=GND}
N 390 59640 390 59690 {
lab=Y4}
N 390 59690 390 59700 {
lab=Y4}
N 400 59650 440 59650 {
lab=word994}
N 440 59650 480 59650 {
lab=word994}
N 410 59640 410 59690 {
lab=GND}
N 410 59690 410 59700 {
lab=GND}
N 470 59640 470 59690 {
lab=Y5}
N 470 59690 470 59700 {
lab=Y5}
N 480 59650 520 59650 {
lab=word994}
N 520 59650 560 59650 {
lab=word994}
N 490 59640 490 59690 {
lab=GND}
N 490 59690 490 59700 {
lab=GND}
N 550 59640 550 59690 {
lab=Y6}
N 550 59690 550 59700 {
lab=Y6}
N 570 59700 600 59700 {
lab=GND}
N 600 59690 600 59700 {
lab=GND}
N 560 59650 600 59650 {
lab=word994}
N 600 59650 640 59650 {
lab=word994}
N 570 59640 570 59690 {
lab=GND}
N 570 59690 570 59700 {
lab=GND}
N 630 59640 630 59690 {
lab=Y7}
N 630 59690 630 59700 {
lab=Y7}
N 0 59710 40 59710 {
lab=word995}
N 40 59710 80 59710 {
lab=word995}
N 10 59700 10 59750 {
lab=GND}
N 10 59750 10 59760 {
lab=GND}
N 70 59700 70 59750 {
lab=Y0}
N 70 59750 70 59760 {
lab=Y0}
N 80 59710 120 59710 {
lab=word995}
N 120 59710 160 59710 {
lab=word995}
N 90 59700 90 59750 {
lab=GND}
N 90 59750 90 59760 {
lab=GND}
N 150 59700 150 59750 {
lab=Y1}
N 150 59750 150 59760 {
lab=Y1}
N 160 59710 200 59710 {
lab=word995}
N 200 59710 240 59710 {
lab=word995}
N 170 59700 170 59750 {
lab=GND}
N 170 59750 170 59760 {
lab=GND}
N 230 59700 230 59750 {
lab=Y2}
N 230 59750 230 59760 {
lab=Y2}
N 250 59760 280 59760 {
lab=GND}
N 280 59750 280 59760 {
lab=GND}
N 240 59710 280 59710 {
lab=word995}
N 280 59710 320 59710 {
lab=word995}
N 250 59700 250 59750 {
lab=GND}
N 250 59750 250 59760 {
lab=GND}
N 310 59700 310 59750 {
lab=Y3}
N 310 59750 310 59760 {
lab=Y3}
N 330 59760 360 59760 {
lab=GND}
N 360 59750 360 59760 {
lab=GND}
N 320 59710 360 59710 {
lab=word995}
N 360 59710 400 59710 {
lab=word995}
N 330 59700 330 59750 {
lab=GND}
N 330 59750 330 59760 {
lab=GND}
N 390 59700 390 59750 {
lab=Y4}
N 390 59750 390 59760 {
lab=Y4}
N 410 59760 440 59760 {
lab=GND}
N 440 59750 440 59760 {
lab=GND}
N 400 59710 440 59710 {
lab=word995}
N 440 59710 480 59710 {
lab=word995}
N 410 59700 410 59750 {
lab=GND}
N 410 59750 410 59760 {
lab=GND}
N 470 59700 470 59750 {
lab=Y5}
N 470 59750 470 59760 {
lab=Y5}
N 490 59760 520 59760 {
lab=GND}
N 520 59750 520 59760 {
lab=GND}
N 480 59710 520 59710 {
lab=word995}
N 520 59710 560 59710 {
lab=word995}
N 490 59700 490 59750 {
lab=GND}
N 490 59750 490 59760 {
lab=GND}
N 550 59700 550 59750 {
lab=Y6}
N 550 59750 550 59760 {
lab=Y6}
N 570 59760 600 59760 {
lab=GND}
N 600 59750 600 59760 {
lab=GND}
N 560 59710 600 59710 {
lab=word995}
N 600 59710 640 59710 {
lab=word995}
N 570 59700 570 59750 {
lab=GND}
N 570 59750 570 59760 {
lab=GND}
N 630 59700 630 59750 {
lab=Y7}
N 630 59750 630 59760 {
lab=Y7}
N 0 59770 40 59770 {
lab=word996}
N 40 59770 80 59770 {
lab=word996}
N 10 59760 10 59810 {
lab=GND}
N 10 59810 10 59820 {
lab=GND}
N 70 59760 70 59810 {
lab=Y0}
N 70 59810 70 59820 {
lab=Y0}
N 80 59770 120 59770 {
lab=word996}
N 120 59770 160 59770 {
lab=word996}
N 90 59760 90 59810 {
lab=GND}
N 90 59810 90 59820 {
lab=GND}
N 150 59760 150 59810 {
lab=Y1}
N 150 59810 150 59820 {
lab=Y1}
N 160 59770 200 59770 {
lab=word996}
N 200 59770 240 59770 {
lab=word996}
N 170 59760 170 59810 {
lab=GND}
N 170 59810 170 59820 {
lab=GND}
N 230 59760 230 59810 {
lab=Y2}
N 230 59810 230 59820 {
lab=Y2}
N 250 59820 280 59820 {
lab=GND}
N 280 59810 280 59820 {
lab=GND}
N 240 59770 280 59770 {
lab=word996}
N 280 59770 320 59770 {
lab=word996}
N 250 59760 250 59810 {
lab=GND}
N 250 59810 250 59820 {
lab=GND}
N 310 59760 310 59810 {
lab=Y3}
N 310 59810 310 59820 {
lab=Y3}
N 330 59820 360 59820 {
lab=GND}
N 360 59810 360 59820 {
lab=GND}
N 320 59770 360 59770 {
lab=word996}
N 360 59770 400 59770 {
lab=word996}
N 330 59760 330 59810 {
lab=GND}
N 330 59810 330 59820 {
lab=GND}
N 390 59760 390 59810 {
lab=Y4}
N 390 59810 390 59820 {
lab=Y4}
N 410 59820 440 59820 {
lab=GND}
N 440 59810 440 59820 {
lab=GND}
N 400 59770 440 59770 {
lab=word996}
N 440 59770 480 59770 {
lab=word996}
N 410 59760 410 59810 {
lab=GND}
N 410 59810 410 59820 {
lab=GND}
N 470 59760 470 59810 {
lab=Y5}
N 470 59810 470 59820 {
lab=Y5}
N 480 59770 520 59770 {
lab=word996}
N 520 59770 560 59770 {
lab=word996}
N 490 59760 490 59810 {
lab=GND}
N 490 59810 490 59820 {
lab=GND}
N 550 59760 550 59810 {
lab=Y6}
N 550 59810 550 59820 {
lab=Y6}
N 570 59820 600 59820 {
lab=GND}
N 600 59810 600 59820 {
lab=GND}
N 560 59770 600 59770 {
lab=word996}
N 600 59770 640 59770 {
lab=word996}
N 570 59760 570 59810 {
lab=GND}
N 570 59810 570 59820 {
lab=GND}
N 630 59760 630 59810 {
lab=Y7}
N 630 59810 630 59820 {
lab=Y7}
N 0 59830 40 59830 {
lab=word997}
N 40 59830 80 59830 {
lab=word997}
N 10 59820 10 59870 {
lab=GND}
N 10 59870 10 59880 {
lab=GND}
N 70 59820 70 59870 {
lab=Y0}
N 70 59870 70 59880 {
lab=Y0}
N 80 59830 120 59830 {
lab=word997}
N 120 59830 160 59830 {
lab=word997}
N 90 59820 90 59870 {
lab=GND}
N 90 59870 90 59880 {
lab=GND}
N 150 59820 150 59870 {
lab=Y1}
N 150 59870 150 59880 {
lab=Y1}
N 160 59830 200 59830 {
lab=word997}
N 200 59830 240 59830 {
lab=word997}
N 170 59820 170 59870 {
lab=GND}
N 170 59870 170 59880 {
lab=GND}
N 230 59820 230 59870 {
lab=Y2}
N 230 59870 230 59880 {
lab=Y2}
N 250 59880 280 59880 {
lab=GND}
N 280 59870 280 59880 {
lab=GND}
N 240 59830 280 59830 {
lab=word997}
N 280 59830 320 59830 {
lab=word997}
N 250 59820 250 59870 {
lab=GND}
N 250 59870 250 59880 {
lab=GND}
N 310 59820 310 59870 {
lab=Y3}
N 310 59870 310 59880 {
lab=Y3}
N 330 59880 360 59880 {
lab=GND}
N 360 59870 360 59880 {
lab=GND}
N 320 59830 360 59830 {
lab=word997}
N 360 59830 400 59830 {
lab=word997}
N 330 59820 330 59870 {
lab=GND}
N 330 59870 330 59880 {
lab=GND}
N 390 59820 390 59870 {
lab=Y4}
N 390 59870 390 59880 {
lab=Y4}
N 400 59830 440 59830 {
lab=word997}
N 440 59830 480 59830 {
lab=word997}
N 410 59820 410 59870 {
lab=GND}
N 410 59870 410 59880 {
lab=GND}
N 470 59820 470 59870 {
lab=Y5}
N 470 59870 470 59880 {
lab=Y5}
N 490 59880 520 59880 {
lab=GND}
N 520 59870 520 59880 {
lab=GND}
N 480 59830 520 59830 {
lab=word997}
N 520 59830 560 59830 {
lab=word997}
N 490 59820 490 59870 {
lab=GND}
N 490 59870 490 59880 {
lab=GND}
N 550 59820 550 59870 {
lab=Y6}
N 550 59870 550 59880 {
lab=Y6}
N 570 59880 600 59880 {
lab=GND}
N 600 59870 600 59880 {
lab=GND}
N 560 59830 600 59830 {
lab=word997}
N 600 59830 640 59830 {
lab=word997}
N 570 59820 570 59870 {
lab=GND}
N 570 59870 570 59880 {
lab=GND}
N 630 59820 630 59870 {
lab=Y7}
N 630 59870 630 59880 {
lab=Y7}
N 0 59890 40 59890 {
lab=word998}
N 40 59890 80 59890 {
lab=word998}
N 10 59880 10 59930 {
lab=GND}
N 10 59930 10 59940 {
lab=GND}
N 70 59880 70 59930 {
lab=Y0}
N 70 59930 70 59940 {
lab=Y0}
N 80 59890 120 59890 {
lab=word998}
N 120 59890 160 59890 {
lab=word998}
N 90 59880 90 59930 {
lab=GND}
N 90 59930 90 59940 {
lab=GND}
N 150 59880 150 59930 {
lab=Y1}
N 150 59930 150 59940 {
lab=Y1}
N 160 59890 200 59890 {
lab=word998}
N 200 59890 240 59890 {
lab=word998}
N 170 59880 170 59930 {
lab=GND}
N 170 59930 170 59940 {
lab=GND}
N 230 59880 230 59930 {
lab=Y2}
N 230 59930 230 59940 {
lab=Y2}
N 250 59940 280 59940 {
lab=GND}
N 280 59930 280 59940 {
lab=GND}
N 240 59890 280 59890 {
lab=word998}
N 280 59890 320 59890 {
lab=word998}
N 250 59880 250 59930 {
lab=GND}
N 250 59930 250 59940 {
lab=GND}
N 310 59880 310 59930 {
lab=Y3}
N 310 59930 310 59940 {
lab=Y3}
N 330 59940 360 59940 {
lab=GND}
N 360 59930 360 59940 {
lab=GND}
N 320 59890 360 59890 {
lab=word998}
N 360 59890 400 59890 {
lab=word998}
N 330 59880 330 59930 {
lab=GND}
N 330 59930 330 59940 {
lab=GND}
N 390 59880 390 59930 {
lab=Y4}
N 390 59930 390 59940 {
lab=Y4}
N 400 59890 440 59890 {
lab=word998}
N 440 59890 480 59890 {
lab=word998}
N 410 59880 410 59930 {
lab=GND}
N 410 59930 410 59940 {
lab=GND}
N 470 59880 470 59930 {
lab=Y5}
N 470 59930 470 59940 {
lab=Y5}
N 480 59890 520 59890 {
lab=word998}
N 520 59890 560 59890 {
lab=word998}
N 490 59880 490 59930 {
lab=GND}
N 490 59930 490 59940 {
lab=GND}
N 550 59880 550 59930 {
lab=Y6}
N 550 59930 550 59940 {
lab=Y6}
N 570 59940 600 59940 {
lab=GND}
N 600 59930 600 59940 {
lab=GND}
N 560 59890 600 59890 {
lab=word998}
N 600 59890 640 59890 {
lab=word998}
N 570 59880 570 59930 {
lab=GND}
N 570 59930 570 59940 {
lab=GND}
N 630 59880 630 59930 {
lab=Y7}
N 630 59930 630 59940 {
lab=Y7}
N 0 59950 40 59950 {
lab=word999}
N 40 59950 80 59950 {
lab=word999}
N 10 59940 10 59990 {
lab=GND}
N 10 59990 10 60000 {
lab=GND}
N 70 59940 70 59990 {
lab=Y0}
N 70 59990 70 60000 {
lab=Y0}
N 80 59950 120 59950 {
lab=word999}
N 120 59950 160 59950 {
lab=word999}
N 90 59940 90 59990 {
lab=GND}
N 90 59990 90 60000 {
lab=GND}
N 150 59940 150 59990 {
lab=Y1}
N 150 59990 150 60000 {
lab=Y1}
N 160 59950 200 59950 {
lab=word999}
N 200 59950 240 59950 {
lab=word999}
N 170 59940 170 59990 {
lab=GND}
N 170 59990 170 60000 {
lab=GND}
N 230 59940 230 59990 {
lab=Y2}
N 230 59990 230 60000 {
lab=Y2}
N 250 60000 280 60000 {
lab=GND}
N 280 59990 280 60000 {
lab=GND}
N 240 59950 280 59950 {
lab=word999}
N 280 59950 320 59950 {
lab=word999}
N 250 59940 250 59990 {
lab=GND}
N 250 59990 250 60000 {
lab=GND}
N 310 59940 310 59990 {
lab=Y3}
N 310 59990 310 60000 {
lab=Y3}
N 320 59950 360 59950 {
lab=word999}
N 360 59950 400 59950 {
lab=word999}
N 330 59940 330 59990 {
lab=GND}
N 330 59990 330 60000 {
lab=GND}
N 390 59940 390 59990 {
lab=Y4}
N 390 59990 390 60000 {
lab=Y4}
N 410 60000 440 60000 {
lab=GND}
N 440 59990 440 60000 {
lab=GND}
N 400 59950 440 59950 {
lab=word999}
N 440 59950 480 59950 {
lab=word999}
N 410 59940 410 59990 {
lab=GND}
N 410 59990 410 60000 {
lab=GND}
N 470 59940 470 59990 {
lab=Y5}
N 470 59990 470 60000 {
lab=Y5}
N 490 60000 520 60000 {
lab=GND}
N 520 59990 520 60000 {
lab=GND}
N 480 59950 520 59950 {
lab=word999}
N 520 59950 560 59950 {
lab=word999}
N 490 59940 490 59990 {
lab=GND}
N 490 59990 490 60000 {
lab=GND}
N 550 59940 550 59990 {
lab=Y6}
N 550 59990 550 60000 {
lab=Y6}
N 570 60000 600 60000 {
lab=GND}
N 600 59990 600 60000 {
lab=GND}
N 560 59950 600 59950 {
lab=word999}
N 600 59950 640 59950 {
lab=word999}
N 570 59940 570 59990 {
lab=GND}
N 570 59990 570 60000 {
lab=GND}
N 630 59940 630 59990 {
lab=Y7}
N 630 59990 630 60000 {
lab=Y7}
N 0 60010 40 60010 {
lab=word1000}
N 40 60010 80 60010 {
lab=word1000}
N 10 60000 10 60050 {
lab=GND}
N 10 60050 10 60060 {
lab=GND}
N 70 60000 70 60050 {
lab=Y0}
N 70 60050 70 60060 {
lab=Y0}
N 80 60010 120 60010 {
lab=word1000}
N 120 60010 160 60010 {
lab=word1000}
N 90 60000 90 60050 {
lab=GND}
N 90 60050 90 60060 {
lab=GND}
N 150 60000 150 60050 {
lab=Y1}
N 150 60050 150 60060 {
lab=Y1}
N 160 60010 200 60010 {
lab=word1000}
N 200 60010 240 60010 {
lab=word1000}
N 170 60000 170 60050 {
lab=GND}
N 170 60050 170 60060 {
lab=GND}
N 230 60000 230 60050 {
lab=Y2}
N 230 60050 230 60060 {
lab=Y2}
N 250 60060 280 60060 {
lab=GND}
N 280 60050 280 60060 {
lab=GND}
N 240 60010 280 60010 {
lab=word1000}
N 280 60010 320 60010 {
lab=word1000}
N 250 60000 250 60050 {
lab=GND}
N 250 60050 250 60060 {
lab=GND}
N 310 60000 310 60050 {
lab=Y3}
N 310 60050 310 60060 {
lab=Y3}
N 320 60010 360 60010 {
lab=word1000}
N 360 60010 400 60010 {
lab=word1000}
N 330 60000 330 60050 {
lab=GND}
N 330 60050 330 60060 {
lab=GND}
N 390 60000 390 60050 {
lab=Y4}
N 390 60050 390 60060 {
lab=Y4}
N 410 60060 440 60060 {
lab=GND}
N 440 60050 440 60060 {
lab=GND}
N 400 60010 440 60010 {
lab=word1000}
N 440 60010 480 60010 {
lab=word1000}
N 410 60000 410 60050 {
lab=GND}
N 410 60050 410 60060 {
lab=GND}
N 470 60000 470 60050 {
lab=Y5}
N 470 60050 470 60060 {
lab=Y5}
N 480 60010 520 60010 {
lab=word1000}
N 520 60010 560 60010 {
lab=word1000}
N 490 60000 490 60050 {
lab=GND}
N 490 60050 490 60060 {
lab=GND}
N 550 60000 550 60050 {
lab=Y6}
N 550 60050 550 60060 {
lab=Y6}
N 570 60060 600 60060 {
lab=GND}
N 600 60050 600 60060 {
lab=GND}
N 560 60010 600 60010 {
lab=word1000}
N 600 60010 640 60010 {
lab=word1000}
N 570 60000 570 60050 {
lab=GND}
N 570 60050 570 60060 {
lab=GND}
N 630 60000 630 60050 {
lab=Y7}
N 630 60050 630 60060 {
lab=Y7}
N 0 60070 40 60070 {
lab=word1001}
N 40 60070 80 60070 {
lab=word1001}
N 10 60060 10 60110 {
lab=GND}
N 10 60110 10 60120 {
lab=GND}
N 70 60060 70 60110 {
lab=Y0}
N 70 60110 70 60120 {
lab=Y0}
N 80 60070 120 60070 {
lab=word1001}
N 120 60070 160 60070 {
lab=word1001}
N 90 60060 90 60110 {
lab=GND}
N 90 60110 90 60120 {
lab=GND}
N 150 60060 150 60110 {
lab=Y1}
N 150 60110 150 60120 {
lab=Y1}
N 160 60070 200 60070 {
lab=word1001}
N 200 60070 240 60070 {
lab=word1001}
N 170 60060 170 60110 {
lab=GND}
N 170 60110 170 60120 {
lab=GND}
N 230 60060 230 60110 {
lab=Y2}
N 230 60110 230 60120 {
lab=Y2}
N 250 60120 280 60120 {
lab=GND}
N 280 60110 280 60120 {
lab=GND}
N 240 60070 280 60070 {
lab=word1001}
N 280 60070 320 60070 {
lab=word1001}
N 250 60060 250 60110 {
lab=GND}
N 250 60110 250 60120 {
lab=GND}
N 310 60060 310 60110 {
lab=Y3}
N 310 60110 310 60120 {
lab=Y3}
N 320 60070 360 60070 {
lab=word1001}
N 360 60070 400 60070 {
lab=word1001}
N 330 60060 330 60110 {
lab=GND}
N 330 60110 330 60120 {
lab=GND}
N 390 60060 390 60110 {
lab=Y4}
N 390 60110 390 60120 {
lab=Y4}
N 410 60120 440 60120 {
lab=GND}
N 440 60110 440 60120 {
lab=GND}
N 400 60070 440 60070 {
lab=word1001}
N 440 60070 480 60070 {
lab=word1001}
N 410 60060 410 60110 {
lab=GND}
N 410 60110 410 60120 {
lab=GND}
N 470 60060 470 60110 {
lab=Y5}
N 470 60110 470 60120 {
lab=Y5}
N 480 60070 520 60070 {
lab=word1001}
N 520 60070 560 60070 {
lab=word1001}
N 490 60060 490 60110 {
lab=GND}
N 490 60110 490 60120 {
lab=GND}
N 550 60060 550 60110 {
lab=Y6}
N 550 60110 550 60120 {
lab=Y6}
N 560 60070 600 60070 {
lab=word1001}
N 600 60070 640 60070 {
lab=word1001}
N 570 60060 570 60110 {
lab=GND}
N 570 60110 570 60120 {
lab=GND}
N 630 60060 630 60110 {
lab=Y7}
N 630 60110 630 60120 {
lab=Y7}
N 0 60130 40 60130 {
lab=word1002}
N 40 60130 80 60130 {
lab=word1002}
N 10 60120 10 60170 {
lab=GND}
N 10 60170 10 60180 {
lab=GND}
N 70 60120 70 60170 {
lab=Y0}
N 70 60170 70 60180 {
lab=Y0}
N 80 60130 120 60130 {
lab=word1002}
N 120 60130 160 60130 {
lab=word1002}
N 90 60120 90 60170 {
lab=GND}
N 90 60170 90 60180 {
lab=GND}
N 150 60120 150 60170 {
lab=Y1}
N 150 60170 150 60180 {
lab=Y1}
N 160 60130 200 60130 {
lab=word1002}
N 200 60130 240 60130 {
lab=word1002}
N 170 60120 170 60170 {
lab=GND}
N 170 60170 170 60180 {
lab=GND}
N 230 60120 230 60170 {
lab=Y2}
N 230 60170 230 60180 {
lab=Y2}
N 250 60180 280 60180 {
lab=GND}
N 280 60170 280 60180 {
lab=GND}
N 240 60130 280 60130 {
lab=word1002}
N 280 60130 320 60130 {
lab=word1002}
N 250 60120 250 60170 {
lab=GND}
N 250 60170 250 60180 {
lab=GND}
N 310 60120 310 60170 {
lab=Y3}
N 310 60170 310 60180 {
lab=Y3}
N 320 60130 360 60130 {
lab=word1002}
N 360 60130 400 60130 {
lab=word1002}
N 330 60120 330 60170 {
lab=GND}
N 330 60170 330 60180 {
lab=GND}
N 390 60120 390 60170 {
lab=Y4}
N 390 60170 390 60180 {
lab=Y4}
N 400 60130 440 60130 {
lab=word1002}
N 440 60130 480 60130 {
lab=word1002}
N 410 60120 410 60170 {
lab=GND}
N 410 60170 410 60180 {
lab=GND}
N 470 60120 470 60170 {
lab=Y5}
N 470 60170 470 60180 {
lab=Y5}
N 490 60180 520 60180 {
lab=GND}
N 520 60170 520 60180 {
lab=GND}
N 480 60130 520 60130 {
lab=word1002}
N 520 60130 560 60130 {
lab=word1002}
N 490 60120 490 60170 {
lab=GND}
N 490 60170 490 60180 {
lab=GND}
N 550 60120 550 60170 {
lab=Y6}
N 550 60170 550 60180 {
lab=Y6}
N 560 60130 600 60130 {
lab=word1002}
N 600 60130 640 60130 {
lab=word1002}
N 570 60120 570 60170 {
lab=GND}
N 570 60170 570 60180 {
lab=GND}
N 630 60120 630 60170 {
lab=Y7}
N 630 60170 630 60180 {
lab=Y7}
N 0 60190 40 60190 {
lab=word1003}
N 40 60190 80 60190 {
lab=word1003}
N 10 60180 10 60230 {
lab=GND}
N 10 60230 10 60240 {
lab=GND}
N 70 60180 70 60230 {
lab=Y0}
N 70 60230 70 60240 {
lab=Y0}
N 80 60190 120 60190 {
lab=word1003}
N 120 60190 160 60190 {
lab=word1003}
N 90 60180 90 60230 {
lab=GND}
N 90 60230 90 60240 {
lab=GND}
N 150 60180 150 60230 {
lab=Y1}
N 150 60230 150 60240 {
lab=Y1}
N 160 60190 200 60190 {
lab=word1003}
N 200 60190 240 60190 {
lab=word1003}
N 170 60180 170 60230 {
lab=GND}
N 170 60230 170 60240 {
lab=GND}
N 230 60180 230 60230 {
lab=Y2}
N 230 60230 230 60240 {
lab=Y2}
N 250 60240 280 60240 {
lab=GND}
N 280 60230 280 60240 {
lab=GND}
N 240 60190 280 60190 {
lab=word1003}
N 280 60190 320 60190 {
lab=word1003}
N 250 60180 250 60230 {
lab=GND}
N 250 60230 250 60240 {
lab=GND}
N 310 60180 310 60230 {
lab=Y3}
N 310 60230 310 60240 {
lab=Y3}
N 320 60190 360 60190 {
lab=word1003}
N 360 60190 400 60190 {
lab=word1003}
N 330 60180 330 60230 {
lab=GND}
N 330 60230 330 60240 {
lab=GND}
N 390 60180 390 60230 {
lab=Y4}
N 390 60230 390 60240 {
lab=Y4}
N 400 60190 440 60190 {
lab=word1003}
N 440 60190 480 60190 {
lab=word1003}
N 410 60180 410 60230 {
lab=GND}
N 410 60230 410 60240 {
lab=GND}
N 470 60180 470 60230 {
lab=Y5}
N 470 60230 470 60240 {
lab=Y5}
N 480 60190 520 60190 {
lab=word1003}
N 520 60190 560 60190 {
lab=word1003}
N 490 60180 490 60230 {
lab=GND}
N 490 60230 490 60240 {
lab=GND}
N 550 60180 550 60230 {
lab=Y6}
N 550 60230 550 60240 {
lab=Y6}
N 570 60240 600 60240 {
lab=GND}
N 600 60230 600 60240 {
lab=GND}
N 560 60190 600 60190 {
lab=word1003}
N 600 60190 640 60190 {
lab=word1003}
N 570 60180 570 60230 {
lab=GND}
N 570 60230 570 60240 {
lab=GND}
N 630 60180 630 60230 {
lab=Y7}
N 630 60230 630 60240 {
lab=Y7}
N 0 60250 40 60250 {
lab=word1004}
N 40 60250 80 60250 {
lab=word1004}
N 10 60240 10 60290 {
lab=GND}
N 10 60290 10 60300 {
lab=GND}
N 70 60240 70 60290 {
lab=Y0}
N 70 60290 70 60300 {
lab=Y0}
N 80 60250 120 60250 {
lab=word1004}
N 120 60250 160 60250 {
lab=word1004}
N 90 60240 90 60290 {
lab=GND}
N 90 60290 90 60300 {
lab=GND}
N 150 60240 150 60290 {
lab=Y1}
N 150 60290 150 60300 {
lab=Y1}
N 160 60250 200 60250 {
lab=word1004}
N 200 60250 240 60250 {
lab=word1004}
N 170 60240 170 60290 {
lab=GND}
N 170 60290 170 60300 {
lab=GND}
N 230 60240 230 60290 {
lab=Y2}
N 230 60290 230 60300 {
lab=Y2}
N 240 60250 280 60250 {
lab=word1004}
N 280 60250 320 60250 {
lab=word1004}
N 250 60240 250 60290 {
lab=GND}
N 250 60290 250 60300 {
lab=GND}
N 310 60240 310 60290 {
lab=Y3}
N 310 60290 310 60300 {
lab=Y3}
N 330 60300 360 60300 {
lab=GND}
N 360 60290 360 60300 {
lab=GND}
N 320 60250 360 60250 {
lab=word1004}
N 360 60250 400 60250 {
lab=word1004}
N 330 60240 330 60290 {
lab=GND}
N 330 60290 330 60300 {
lab=GND}
N 390 60240 390 60290 {
lab=Y4}
N 390 60290 390 60300 {
lab=Y4}
N 410 60300 440 60300 {
lab=GND}
N 440 60290 440 60300 {
lab=GND}
N 400 60250 440 60250 {
lab=word1004}
N 440 60250 480 60250 {
lab=word1004}
N 410 60240 410 60290 {
lab=GND}
N 410 60290 410 60300 {
lab=GND}
N 470 60240 470 60290 {
lab=Y5}
N 470 60290 470 60300 {
lab=Y5}
N 490 60300 520 60300 {
lab=GND}
N 520 60290 520 60300 {
lab=GND}
N 480 60250 520 60250 {
lab=word1004}
N 520 60250 560 60250 {
lab=word1004}
N 490 60240 490 60290 {
lab=GND}
N 490 60290 490 60300 {
lab=GND}
N 550 60240 550 60290 {
lab=Y6}
N 550 60290 550 60300 {
lab=Y6}
N 570 60300 600 60300 {
lab=GND}
N 600 60290 600 60300 {
lab=GND}
N 560 60250 600 60250 {
lab=word1004}
N 600 60250 640 60250 {
lab=word1004}
N 570 60240 570 60290 {
lab=GND}
N 570 60290 570 60300 {
lab=GND}
N 630 60240 630 60290 {
lab=Y7}
N 630 60290 630 60300 {
lab=Y7}
N 0 60310 40 60310 {
lab=word1005}
N 40 60310 80 60310 {
lab=word1005}
N 10 60300 10 60350 {
lab=GND}
N 10 60350 10 60360 {
lab=GND}
N 70 60300 70 60350 {
lab=Y0}
N 70 60350 70 60360 {
lab=Y0}
N 80 60310 120 60310 {
lab=word1005}
N 120 60310 160 60310 {
lab=word1005}
N 90 60300 90 60350 {
lab=GND}
N 90 60350 90 60360 {
lab=GND}
N 150 60300 150 60350 {
lab=Y1}
N 150 60350 150 60360 {
lab=Y1}
N 160 60310 200 60310 {
lab=word1005}
N 200 60310 240 60310 {
lab=word1005}
N 170 60300 170 60350 {
lab=GND}
N 170 60350 170 60360 {
lab=GND}
N 230 60300 230 60350 {
lab=Y2}
N 230 60350 230 60360 {
lab=Y2}
N 240 60310 280 60310 {
lab=word1005}
N 280 60310 320 60310 {
lab=word1005}
N 250 60300 250 60350 {
lab=GND}
N 250 60350 250 60360 {
lab=GND}
N 310 60300 310 60350 {
lab=Y3}
N 310 60350 310 60360 {
lab=Y3}
N 330 60360 360 60360 {
lab=GND}
N 360 60350 360 60360 {
lab=GND}
N 320 60310 360 60310 {
lab=word1005}
N 360 60310 400 60310 {
lab=word1005}
N 330 60300 330 60350 {
lab=GND}
N 330 60350 330 60360 {
lab=GND}
N 390 60300 390 60350 {
lab=Y4}
N 390 60350 390 60360 {
lab=Y4}
N 410 60360 440 60360 {
lab=GND}
N 440 60350 440 60360 {
lab=GND}
N 400 60310 440 60310 {
lab=word1005}
N 440 60310 480 60310 {
lab=word1005}
N 410 60300 410 60350 {
lab=GND}
N 410 60350 410 60360 {
lab=GND}
N 470 60300 470 60350 {
lab=Y5}
N 470 60350 470 60360 {
lab=Y5}
N 490 60360 520 60360 {
lab=GND}
N 520 60350 520 60360 {
lab=GND}
N 480 60310 520 60310 {
lab=word1005}
N 520 60310 560 60310 {
lab=word1005}
N 490 60300 490 60350 {
lab=GND}
N 490 60350 490 60360 {
lab=GND}
N 550 60300 550 60350 {
lab=Y6}
N 550 60350 550 60360 {
lab=Y6}
N 560 60310 600 60310 {
lab=word1005}
N 600 60310 640 60310 {
lab=word1005}
N 570 60300 570 60350 {
lab=GND}
N 570 60350 570 60360 {
lab=GND}
N 630 60300 630 60350 {
lab=Y7}
N 630 60350 630 60360 {
lab=Y7}
N 0 60370 40 60370 {
lab=word1006}
N 40 60370 80 60370 {
lab=word1006}
N 10 60360 10 60410 {
lab=GND}
N 10 60410 10 60420 {
lab=GND}
N 70 60360 70 60410 {
lab=Y0}
N 70 60410 70 60420 {
lab=Y0}
N 80 60370 120 60370 {
lab=word1006}
N 120 60370 160 60370 {
lab=word1006}
N 90 60360 90 60410 {
lab=GND}
N 90 60410 90 60420 {
lab=GND}
N 150 60360 150 60410 {
lab=Y1}
N 150 60410 150 60420 {
lab=Y1}
N 160 60370 200 60370 {
lab=word1006}
N 200 60370 240 60370 {
lab=word1006}
N 170 60360 170 60410 {
lab=GND}
N 170 60410 170 60420 {
lab=GND}
N 230 60360 230 60410 {
lab=Y2}
N 230 60410 230 60420 {
lab=Y2}
N 240 60370 280 60370 {
lab=word1006}
N 280 60370 320 60370 {
lab=word1006}
N 250 60360 250 60410 {
lab=GND}
N 250 60410 250 60420 {
lab=GND}
N 310 60360 310 60410 {
lab=Y3}
N 310 60410 310 60420 {
lab=Y3}
N 330 60420 360 60420 {
lab=GND}
N 360 60410 360 60420 {
lab=GND}
N 320 60370 360 60370 {
lab=word1006}
N 360 60370 400 60370 {
lab=word1006}
N 330 60360 330 60410 {
lab=GND}
N 330 60410 330 60420 {
lab=GND}
N 390 60360 390 60410 {
lab=Y4}
N 390 60410 390 60420 {
lab=Y4}
N 410 60420 440 60420 {
lab=GND}
N 440 60410 440 60420 {
lab=GND}
N 400 60370 440 60370 {
lab=word1006}
N 440 60370 480 60370 {
lab=word1006}
N 410 60360 410 60410 {
lab=GND}
N 410 60410 410 60420 {
lab=GND}
N 470 60360 470 60410 {
lab=Y5}
N 470 60410 470 60420 {
lab=Y5}
N 480 60370 520 60370 {
lab=word1006}
N 520 60370 560 60370 {
lab=word1006}
N 490 60360 490 60410 {
lab=GND}
N 490 60410 490 60420 {
lab=GND}
N 550 60360 550 60410 {
lab=Y6}
N 550 60410 550 60420 {
lab=Y6}
N 560 60370 600 60370 {
lab=word1006}
N 600 60370 640 60370 {
lab=word1006}
N 570 60360 570 60410 {
lab=GND}
N 570 60410 570 60420 {
lab=GND}
N 630 60360 630 60410 {
lab=Y7}
N 630 60410 630 60420 {
lab=Y7}
N 0 60430 40 60430 {
lab=word1007}
N 40 60430 80 60430 {
lab=word1007}
N 10 60420 10 60470 {
lab=GND}
N 10 60470 10 60480 {
lab=GND}
N 70 60420 70 60470 {
lab=Y0}
N 70 60470 70 60480 {
lab=Y0}
N 80 60430 120 60430 {
lab=word1007}
N 120 60430 160 60430 {
lab=word1007}
N 90 60420 90 60470 {
lab=GND}
N 90 60470 90 60480 {
lab=GND}
N 150 60420 150 60470 {
lab=Y1}
N 150 60470 150 60480 {
lab=Y1}
N 160 60430 200 60430 {
lab=word1007}
N 200 60430 240 60430 {
lab=word1007}
N 170 60420 170 60470 {
lab=GND}
N 170 60470 170 60480 {
lab=GND}
N 230 60420 230 60470 {
lab=Y2}
N 230 60470 230 60480 {
lab=Y2}
N 240 60430 280 60430 {
lab=word1007}
N 280 60430 320 60430 {
lab=word1007}
N 250 60420 250 60470 {
lab=GND}
N 250 60470 250 60480 {
lab=GND}
N 310 60420 310 60470 {
lab=Y3}
N 310 60470 310 60480 {
lab=Y3}
N 330 60480 360 60480 {
lab=GND}
N 360 60470 360 60480 {
lab=GND}
N 320 60430 360 60430 {
lab=word1007}
N 360 60430 400 60430 {
lab=word1007}
N 330 60420 330 60470 {
lab=GND}
N 330 60470 330 60480 {
lab=GND}
N 390 60420 390 60470 {
lab=Y4}
N 390 60470 390 60480 {
lab=Y4}
N 400 60430 440 60430 {
lab=word1007}
N 440 60430 480 60430 {
lab=word1007}
N 410 60420 410 60470 {
lab=GND}
N 410 60470 410 60480 {
lab=GND}
N 470 60420 470 60470 {
lab=Y5}
N 470 60470 470 60480 {
lab=Y5}
N 490 60480 520 60480 {
lab=GND}
N 520 60470 520 60480 {
lab=GND}
N 480 60430 520 60430 {
lab=word1007}
N 520 60430 560 60430 {
lab=word1007}
N 490 60420 490 60470 {
lab=GND}
N 490 60470 490 60480 {
lab=GND}
N 550 60420 550 60470 {
lab=Y6}
N 550 60470 550 60480 {
lab=Y6}
N 570 60480 600 60480 {
lab=GND}
N 600 60470 600 60480 {
lab=GND}
N 560 60430 600 60430 {
lab=word1007}
N 600 60430 640 60430 {
lab=word1007}
N 570 60420 570 60470 {
lab=GND}
N 570 60470 570 60480 {
lab=GND}
N 630 60420 630 60470 {
lab=Y7}
N 630 60470 630 60480 {
lab=Y7}
N 0 60490 40 60490 {
lab=word1008}
N 40 60490 80 60490 {
lab=word1008}
N 10 60480 10 60530 {
lab=GND}
N 10 60530 10 60540 {
lab=GND}
N 70 60480 70 60530 {
lab=Y0}
N 70 60530 70 60540 {
lab=Y0}
N 80 60490 120 60490 {
lab=word1008}
N 120 60490 160 60490 {
lab=word1008}
N 90 60480 90 60530 {
lab=GND}
N 90 60530 90 60540 {
lab=GND}
N 150 60480 150 60530 {
lab=Y1}
N 150 60530 150 60540 {
lab=Y1}
N 160 60490 200 60490 {
lab=word1008}
N 200 60490 240 60490 {
lab=word1008}
N 170 60480 170 60530 {
lab=GND}
N 170 60530 170 60540 {
lab=GND}
N 230 60480 230 60530 {
lab=Y2}
N 230 60530 230 60540 {
lab=Y2}
N 240 60490 280 60490 {
lab=word1008}
N 280 60490 320 60490 {
lab=word1008}
N 250 60480 250 60530 {
lab=GND}
N 250 60530 250 60540 {
lab=GND}
N 310 60480 310 60530 {
lab=Y3}
N 310 60530 310 60540 {
lab=Y3}
N 330 60540 360 60540 {
lab=GND}
N 360 60530 360 60540 {
lab=GND}
N 320 60490 360 60490 {
lab=word1008}
N 360 60490 400 60490 {
lab=word1008}
N 330 60480 330 60530 {
lab=GND}
N 330 60530 330 60540 {
lab=GND}
N 390 60480 390 60530 {
lab=Y4}
N 390 60530 390 60540 {
lab=Y4}
N 400 60490 440 60490 {
lab=word1008}
N 440 60490 480 60490 {
lab=word1008}
N 410 60480 410 60530 {
lab=GND}
N 410 60530 410 60540 {
lab=GND}
N 470 60480 470 60530 {
lab=Y5}
N 470 60530 470 60540 {
lab=Y5}
N 490 60540 520 60540 {
lab=GND}
N 520 60530 520 60540 {
lab=GND}
N 480 60490 520 60490 {
lab=word1008}
N 520 60490 560 60490 {
lab=word1008}
N 490 60480 490 60530 {
lab=GND}
N 490 60530 490 60540 {
lab=GND}
N 550 60480 550 60530 {
lab=Y6}
N 550 60530 550 60540 {
lab=Y6}
N 560 60490 600 60490 {
lab=word1008}
N 600 60490 640 60490 {
lab=word1008}
N 570 60480 570 60530 {
lab=GND}
N 570 60530 570 60540 {
lab=GND}
N 630 60480 630 60530 {
lab=Y7}
N 630 60530 630 60540 {
lab=Y7}
N 0 60550 40 60550 {
lab=word1009}
N 40 60550 80 60550 {
lab=word1009}
N 10 60540 10 60590 {
lab=GND}
N 10 60590 10 60600 {
lab=GND}
N 70 60540 70 60590 {
lab=Y0}
N 70 60590 70 60600 {
lab=Y0}
N 80 60550 120 60550 {
lab=word1009}
N 120 60550 160 60550 {
lab=word1009}
N 90 60540 90 60590 {
lab=GND}
N 90 60590 90 60600 {
lab=GND}
N 150 60540 150 60590 {
lab=Y1}
N 150 60590 150 60600 {
lab=Y1}
N 160 60550 200 60550 {
lab=word1009}
N 200 60550 240 60550 {
lab=word1009}
N 170 60540 170 60590 {
lab=GND}
N 170 60590 170 60600 {
lab=GND}
N 230 60540 230 60590 {
lab=Y2}
N 230 60590 230 60600 {
lab=Y2}
N 240 60550 280 60550 {
lab=word1009}
N 280 60550 320 60550 {
lab=word1009}
N 250 60540 250 60590 {
lab=GND}
N 250 60590 250 60600 {
lab=GND}
N 310 60540 310 60590 {
lab=Y3}
N 310 60590 310 60600 {
lab=Y3}
N 330 60600 360 60600 {
lab=GND}
N 360 60590 360 60600 {
lab=GND}
N 320 60550 360 60550 {
lab=word1009}
N 360 60550 400 60550 {
lab=word1009}
N 330 60540 330 60590 {
lab=GND}
N 330 60590 330 60600 {
lab=GND}
N 390 60540 390 60590 {
lab=Y4}
N 390 60590 390 60600 {
lab=Y4}
N 400 60550 440 60550 {
lab=word1009}
N 440 60550 480 60550 {
lab=word1009}
N 410 60540 410 60590 {
lab=GND}
N 410 60590 410 60600 {
lab=GND}
N 470 60540 470 60590 {
lab=Y5}
N 470 60590 470 60600 {
lab=Y5}
N 480 60550 520 60550 {
lab=word1009}
N 520 60550 560 60550 {
lab=word1009}
N 490 60540 490 60590 {
lab=GND}
N 490 60590 490 60600 {
lab=GND}
N 550 60540 550 60590 {
lab=Y6}
N 550 60590 550 60600 {
lab=Y6}
N 570 60600 600 60600 {
lab=GND}
N 600 60590 600 60600 {
lab=GND}
N 560 60550 600 60550 {
lab=word1009}
N 600 60550 640 60550 {
lab=word1009}
N 570 60540 570 60590 {
lab=GND}
N 570 60590 570 60600 {
lab=GND}
N 630 60540 630 60590 {
lab=Y7}
N 630 60590 630 60600 {
lab=Y7}
N 0 60610 40 60610 {
lab=word1010}
N 40 60610 80 60610 {
lab=word1010}
N 10 60600 10 60650 {
lab=GND}
N 10 60650 10 60660 {
lab=GND}
N 70 60600 70 60650 {
lab=Y0}
N 70 60650 70 60660 {
lab=Y0}
N 80 60610 120 60610 {
lab=word1010}
N 120 60610 160 60610 {
lab=word1010}
N 90 60600 90 60650 {
lab=GND}
N 90 60650 90 60660 {
lab=GND}
N 150 60600 150 60650 {
lab=Y1}
N 150 60650 150 60660 {
lab=Y1}
N 160 60610 200 60610 {
lab=word1010}
N 200 60610 240 60610 {
lab=word1010}
N 170 60600 170 60650 {
lab=GND}
N 170 60650 170 60660 {
lab=GND}
N 230 60600 230 60650 {
lab=Y2}
N 230 60650 230 60660 {
lab=Y2}
N 240 60610 280 60610 {
lab=word1010}
N 280 60610 320 60610 {
lab=word1010}
N 250 60600 250 60650 {
lab=GND}
N 250 60650 250 60660 {
lab=GND}
N 310 60600 310 60650 {
lab=Y3}
N 310 60650 310 60660 {
lab=Y3}
N 320 60610 360 60610 {
lab=word1010}
N 360 60610 400 60610 {
lab=word1010}
N 330 60600 330 60650 {
lab=GND}
N 330 60650 330 60660 {
lab=GND}
N 390 60600 390 60650 {
lab=Y4}
N 390 60650 390 60660 {
lab=Y4}
N 410 60660 440 60660 {
lab=GND}
N 440 60650 440 60660 {
lab=GND}
N 400 60610 440 60610 {
lab=word1010}
N 440 60610 480 60610 {
lab=word1010}
N 410 60600 410 60650 {
lab=GND}
N 410 60650 410 60660 {
lab=GND}
N 470 60600 470 60650 {
lab=Y5}
N 470 60650 470 60660 {
lab=Y5}
N 490 60660 520 60660 {
lab=GND}
N 520 60650 520 60660 {
lab=GND}
N 480 60610 520 60610 {
lab=word1010}
N 520 60610 560 60610 {
lab=word1010}
N 490 60600 490 60650 {
lab=GND}
N 490 60650 490 60660 {
lab=GND}
N 550 60600 550 60650 {
lab=Y6}
N 550 60650 550 60660 {
lab=Y6}
N 570 60660 600 60660 {
lab=GND}
N 600 60650 600 60660 {
lab=GND}
N 560 60610 600 60610 {
lab=word1010}
N 600 60610 640 60610 {
lab=word1010}
N 570 60600 570 60650 {
lab=GND}
N 570 60650 570 60660 {
lab=GND}
N 630 60600 630 60650 {
lab=Y7}
N 630 60650 630 60660 {
lab=Y7}
N 0 60670 40 60670 {
lab=word1011}
N 40 60670 80 60670 {
lab=word1011}
N 10 60660 10 60710 {
lab=GND}
N 10 60710 10 60720 {
lab=GND}
N 70 60660 70 60710 {
lab=Y0}
N 70 60710 70 60720 {
lab=Y0}
N 80 60670 120 60670 {
lab=word1011}
N 120 60670 160 60670 {
lab=word1011}
N 90 60660 90 60710 {
lab=GND}
N 90 60710 90 60720 {
lab=GND}
N 150 60660 150 60710 {
lab=Y1}
N 150 60710 150 60720 {
lab=Y1}
N 160 60670 200 60670 {
lab=word1011}
N 200 60670 240 60670 {
lab=word1011}
N 170 60660 170 60710 {
lab=GND}
N 170 60710 170 60720 {
lab=GND}
N 230 60660 230 60710 {
lab=Y2}
N 230 60710 230 60720 {
lab=Y2}
N 240 60670 280 60670 {
lab=word1011}
N 280 60670 320 60670 {
lab=word1011}
N 250 60660 250 60710 {
lab=GND}
N 250 60710 250 60720 {
lab=GND}
N 310 60660 310 60710 {
lab=Y3}
N 310 60710 310 60720 {
lab=Y3}
N 320 60670 360 60670 {
lab=word1011}
N 360 60670 400 60670 {
lab=word1011}
N 330 60660 330 60710 {
lab=GND}
N 330 60710 330 60720 {
lab=GND}
N 390 60660 390 60710 {
lab=Y4}
N 390 60710 390 60720 {
lab=Y4}
N 410 60720 440 60720 {
lab=GND}
N 440 60710 440 60720 {
lab=GND}
N 400 60670 440 60670 {
lab=word1011}
N 440 60670 480 60670 {
lab=word1011}
N 410 60660 410 60710 {
lab=GND}
N 410 60710 410 60720 {
lab=GND}
N 470 60660 470 60710 {
lab=Y5}
N 470 60710 470 60720 {
lab=Y5}
N 490 60720 520 60720 {
lab=GND}
N 520 60710 520 60720 {
lab=GND}
N 480 60670 520 60670 {
lab=word1011}
N 520 60670 560 60670 {
lab=word1011}
N 490 60660 490 60710 {
lab=GND}
N 490 60710 490 60720 {
lab=GND}
N 550 60660 550 60710 {
lab=Y6}
N 550 60710 550 60720 {
lab=Y6}
N 560 60670 600 60670 {
lab=word1011}
N 600 60670 640 60670 {
lab=word1011}
N 570 60660 570 60710 {
lab=GND}
N 570 60710 570 60720 {
lab=GND}
N 630 60660 630 60710 {
lab=Y7}
N 630 60710 630 60720 {
lab=Y7}
N 0 60730 40 60730 {
lab=word1012}
N 40 60730 80 60730 {
lab=word1012}
N 10 60720 10 60770 {
lab=GND}
N 10 60770 10 60780 {
lab=GND}
N 70 60720 70 60770 {
lab=Y0}
N 70 60770 70 60780 {
lab=Y0}
N 80 60730 120 60730 {
lab=word1012}
N 120 60730 160 60730 {
lab=word1012}
N 90 60720 90 60770 {
lab=GND}
N 90 60770 90 60780 {
lab=GND}
N 150 60720 150 60770 {
lab=Y1}
N 150 60770 150 60780 {
lab=Y1}
N 160 60730 200 60730 {
lab=word1012}
N 200 60730 240 60730 {
lab=word1012}
N 170 60720 170 60770 {
lab=GND}
N 170 60770 170 60780 {
lab=GND}
N 230 60720 230 60770 {
lab=Y2}
N 230 60770 230 60780 {
lab=Y2}
N 240 60730 280 60730 {
lab=word1012}
N 280 60730 320 60730 {
lab=word1012}
N 250 60720 250 60770 {
lab=GND}
N 250 60770 250 60780 {
lab=GND}
N 310 60720 310 60770 {
lab=Y3}
N 310 60770 310 60780 {
lab=Y3}
N 320 60730 360 60730 {
lab=word1012}
N 360 60730 400 60730 {
lab=word1012}
N 330 60720 330 60770 {
lab=GND}
N 330 60770 330 60780 {
lab=GND}
N 390 60720 390 60770 {
lab=Y4}
N 390 60770 390 60780 {
lab=Y4}
N 410 60780 440 60780 {
lab=GND}
N 440 60770 440 60780 {
lab=GND}
N 400 60730 440 60730 {
lab=word1012}
N 440 60730 480 60730 {
lab=word1012}
N 410 60720 410 60770 {
lab=GND}
N 410 60770 410 60780 {
lab=GND}
N 470 60720 470 60770 {
lab=Y5}
N 470 60770 470 60780 {
lab=Y5}
N 480 60730 520 60730 {
lab=word1012}
N 520 60730 560 60730 {
lab=word1012}
N 490 60720 490 60770 {
lab=GND}
N 490 60770 490 60780 {
lab=GND}
N 550 60720 550 60770 {
lab=Y6}
N 550 60770 550 60780 {
lab=Y6}
N 570 60780 600 60780 {
lab=GND}
N 600 60770 600 60780 {
lab=GND}
N 560 60730 600 60730 {
lab=word1012}
N 600 60730 640 60730 {
lab=word1012}
N 570 60720 570 60770 {
lab=GND}
N 570 60770 570 60780 {
lab=GND}
N 630 60720 630 60770 {
lab=Y7}
N 630 60770 630 60780 {
lab=Y7}
N 0 60790 40 60790 {
lab=word1013}
N 40 60790 80 60790 {
lab=word1013}
N 10 60780 10 60830 {
lab=GND}
N 10 60830 10 60840 {
lab=GND}
N 70 60780 70 60830 {
lab=Y0}
N 70 60830 70 60840 {
lab=Y0}
N 80 60790 120 60790 {
lab=word1013}
N 120 60790 160 60790 {
lab=word1013}
N 90 60780 90 60830 {
lab=GND}
N 90 60830 90 60840 {
lab=GND}
N 150 60780 150 60830 {
lab=Y1}
N 150 60830 150 60840 {
lab=Y1}
N 160 60790 200 60790 {
lab=word1013}
N 200 60790 240 60790 {
lab=word1013}
N 170 60780 170 60830 {
lab=GND}
N 170 60830 170 60840 {
lab=GND}
N 230 60780 230 60830 {
lab=Y2}
N 230 60830 230 60840 {
lab=Y2}
N 240 60790 280 60790 {
lab=word1013}
N 280 60790 320 60790 {
lab=word1013}
N 250 60780 250 60830 {
lab=GND}
N 250 60830 250 60840 {
lab=GND}
N 310 60780 310 60830 {
lab=Y3}
N 310 60830 310 60840 {
lab=Y3}
N 320 60790 360 60790 {
lab=word1013}
N 360 60790 400 60790 {
lab=word1013}
N 330 60780 330 60830 {
lab=GND}
N 330 60830 330 60840 {
lab=GND}
N 390 60780 390 60830 {
lab=Y4}
N 390 60830 390 60840 {
lab=Y4}
N 410 60840 440 60840 {
lab=GND}
N 440 60830 440 60840 {
lab=GND}
N 400 60790 440 60790 {
lab=word1013}
N 440 60790 480 60790 {
lab=word1013}
N 410 60780 410 60830 {
lab=GND}
N 410 60830 410 60840 {
lab=GND}
N 470 60780 470 60830 {
lab=Y5}
N 470 60830 470 60840 {
lab=Y5}
N 480 60790 520 60790 {
lab=word1013}
N 520 60790 560 60790 {
lab=word1013}
N 490 60780 490 60830 {
lab=GND}
N 490 60830 490 60840 {
lab=GND}
N 550 60780 550 60830 {
lab=Y6}
N 550 60830 550 60840 {
lab=Y6}
N 570 60840 600 60840 {
lab=GND}
N 600 60830 600 60840 {
lab=GND}
N 560 60790 600 60790 {
lab=word1013}
N 600 60790 640 60790 {
lab=word1013}
N 570 60780 570 60830 {
lab=GND}
N 570 60830 570 60840 {
lab=GND}
N 630 60780 630 60830 {
lab=Y7}
N 630 60830 630 60840 {
lab=Y7}
N 0 60850 40 60850 {
lab=word1014}
N 40 60850 80 60850 {
lab=word1014}
N 10 60840 10 60890 {
lab=GND}
N 10 60890 10 60900 {
lab=GND}
N 70 60840 70 60890 {
lab=Y0}
N 70 60890 70 60900 {
lab=Y0}
N 80 60850 120 60850 {
lab=word1014}
N 120 60850 160 60850 {
lab=word1014}
N 90 60840 90 60890 {
lab=GND}
N 90 60890 90 60900 {
lab=GND}
N 150 60840 150 60890 {
lab=Y1}
N 150 60890 150 60900 {
lab=Y1}
N 160 60850 200 60850 {
lab=word1014}
N 200 60850 240 60850 {
lab=word1014}
N 170 60840 170 60890 {
lab=GND}
N 170 60890 170 60900 {
lab=GND}
N 230 60840 230 60890 {
lab=Y2}
N 230 60890 230 60900 {
lab=Y2}
N 240 60850 280 60850 {
lab=word1014}
N 280 60850 320 60850 {
lab=word1014}
N 250 60840 250 60890 {
lab=GND}
N 250 60890 250 60900 {
lab=GND}
N 310 60840 310 60890 {
lab=Y3}
N 310 60890 310 60900 {
lab=Y3}
N 320 60850 360 60850 {
lab=word1014}
N 360 60850 400 60850 {
lab=word1014}
N 330 60840 330 60890 {
lab=GND}
N 330 60890 330 60900 {
lab=GND}
N 390 60840 390 60890 {
lab=Y4}
N 390 60890 390 60900 {
lab=Y4}
N 410 60900 440 60900 {
lab=GND}
N 440 60890 440 60900 {
lab=GND}
N 400 60850 440 60850 {
lab=word1014}
N 440 60850 480 60850 {
lab=word1014}
N 410 60840 410 60890 {
lab=GND}
N 410 60890 410 60900 {
lab=GND}
N 470 60840 470 60890 {
lab=Y5}
N 470 60890 470 60900 {
lab=Y5}
N 480 60850 520 60850 {
lab=word1014}
N 520 60850 560 60850 {
lab=word1014}
N 490 60840 490 60890 {
lab=GND}
N 490 60890 490 60900 {
lab=GND}
N 550 60840 550 60890 {
lab=Y6}
N 550 60890 550 60900 {
lab=Y6}
N 560 60850 600 60850 {
lab=word1014}
N 600 60850 640 60850 {
lab=word1014}
N 570 60840 570 60890 {
lab=GND}
N 570 60890 570 60900 {
lab=GND}
N 630 60840 630 60890 {
lab=Y7}
N 630 60890 630 60900 {
lab=Y7}
N 0 60910 40 60910 {
lab=word1015}
N 40 60910 80 60910 {
lab=word1015}
N 10 60900 10 60950 {
lab=GND}
N 10 60950 10 60960 {
lab=GND}
N 70 60900 70 60950 {
lab=Y0}
N 70 60950 70 60960 {
lab=Y0}
N 80 60910 120 60910 {
lab=word1015}
N 120 60910 160 60910 {
lab=word1015}
N 90 60900 90 60950 {
lab=GND}
N 90 60950 90 60960 {
lab=GND}
N 150 60900 150 60950 {
lab=Y1}
N 150 60950 150 60960 {
lab=Y1}
N 160 60910 200 60910 {
lab=word1015}
N 200 60910 240 60910 {
lab=word1015}
N 170 60900 170 60950 {
lab=GND}
N 170 60950 170 60960 {
lab=GND}
N 230 60900 230 60950 {
lab=Y2}
N 230 60950 230 60960 {
lab=Y2}
N 240 60910 280 60910 {
lab=word1015}
N 280 60910 320 60910 {
lab=word1015}
N 250 60900 250 60950 {
lab=GND}
N 250 60950 250 60960 {
lab=GND}
N 310 60900 310 60950 {
lab=Y3}
N 310 60950 310 60960 {
lab=Y3}
N 320 60910 360 60910 {
lab=word1015}
N 360 60910 400 60910 {
lab=word1015}
N 330 60900 330 60950 {
lab=GND}
N 330 60950 330 60960 {
lab=GND}
N 390 60900 390 60950 {
lab=Y4}
N 390 60950 390 60960 {
lab=Y4}
N 400 60910 440 60910 {
lab=word1015}
N 440 60910 480 60910 {
lab=word1015}
N 410 60900 410 60950 {
lab=GND}
N 410 60950 410 60960 {
lab=GND}
N 470 60900 470 60950 {
lab=Y5}
N 470 60950 470 60960 {
lab=Y5}
N 490 60960 520 60960 {
lab=GND}
N 520 60950 520 60960 {
lab=GND}
N 480 60910 520 60910 {
lab=word1015}
N 520 60910 560 60910 {
lab=word1015}
N 490 60900 490 60950 {
lab=GND}
N 490 60950 490 60960 {
lab=GND}
N 550 60900 550 60950 {
lab=Y6}
N 550 60950 550 60960 {
lab=Y6}
N 570 60960 600 60960 {
lab=GND}
N 600 60950 600 60960 {
lab=GND}
N 560 60910 600 60910 {
lab=word1015}
N 600 60910 640 60910 {
lab=word1015}
N 570 60900 570 60950 {
lab=GND}
N 570 60950 570 60960 {
lab=GND}
N 630 60900 630 60950 {
lab=Y7}
N 630 60950 630 60960 {
lab=Y7}
N 0 60970 40 60970 {
lab=word1016}
N 40 60970 80 60970 {
lab=word1016}
N 10 60960 10 61010 {
lab=GND}
N 10 61010 10 61020 {
lab=GND}
N 70 60960 70 61010 {
lab=Y0}
N 70 61010 70 61020 {
lab=Y0}
N 80 60970 120 60970 {
lab=word1016}
N 120 60970 160 60970 {
lab=word1016}
N 90 60960 90 61010 {
lab=GND}
N 90 61010 90 61020 {
lab=GND}
N 150 60960 150 61010 {
lab=Y1}
N 150 61010 150 61020 {
lab=Y1}
N 160 60970 200 60970 {
lab=word1016}
N 200 60970 240 60970 {
lab=word1016}
N 170 60960 170 61010 {
lab=GND}
N 170 61010 170 61020 {
lab=GND}
N 230 60960 230 61010 {
lab=Y2}
N 230 61010 230 61020 {
lab=Y2}
N 240 60970 280 60970 {
lab=word1016}
N 280 60970 320 60970 {
lab=word1016}
N 250 60960 250 61010 {
lab=GND}
N 250 61010 250 61020 {
lab=GND}
N 310 60960 310 61010 {
lab=Y3}
N 310 61010 310 61020 {
lab=Y3}
N 320 60970 360 60970 {
lab=word1016}
N 360 60970 400 60970 {
lab=word1016}
N 330 60960 330 61010 {
lab=GND}
N 330 61010 330 61020 {
lab=GND}
N 390 60960 390 61010 {
lab=Y4}
N 390 61010 390 61020 {
lab=Y4}
N 400 60970 440 60970 {
lab=word1016}
N 440 60970 480 60970 {
lab=word1016}
N 410 60960 410 61010 {
lab=GND}
N 410 61010 410 61020 {
lab=GND}
N 470 60960 470 61010 {
lab=Y5}
N 470 61010 470 61020 {
lab=Y5}
N 490 61020 520 61020 {
lab=GND}
N 520 61010 520 61020 {
lab=GND}
N 480 60970 520 60970 {
lab=word1016}
N 520 60970 560 60970 {
lab=word1016}
N 490 60960 490 61010 {
lab=GND}
N 490 61010 490 61020 {
lab=GND}
N 550 60960 550 61010 {
lab=Y6}
N 550 61010 550 61020 {
lab=Y6}
N 560 60970 600 60970 {
lab=word1016}
N 600 60970 640 60970 {
lab=word1016}
N 570 60960 570 61010 {
lab=GND}
N 570 61010 570 61020 {
lab=GND}
N 630 60960 630 61010 {
lab=Y7}
N 630 61010 630 61020 {
lab=Y7}
N 0 61030 40 61030 {
lab=word1017}
N 40 61030 80 61030 {
lab=word1017}
N 10 61020 10 61070 {
lab=GND}
N 10 61070 10 61080 {
lab=GND}
N 70 61020 70 61070 {
lab=Y0}
N 70 61070 70 61080 {
lab=Y0}
N 80 61030 120 61030 {
lab=word1017}
N 120 61030 160 61030 {
lab=word1017}
N 90 61020 90 61070 {
lab=GND}
N 90 61070 90 61080 {
lab=GND}
N 150 61020 150 61070 {
lab=Y1}
N 150 61070 150 61080 {
lab=Y1}
N 160 61030 200 61030 {
lab=word1017}
N 200 61030 240 61030 {
lab=word1017}
N 170 61020 170 61070 {
lab=GND}
N 170 61070 170 61080 {
lab=GND}
N 230 61020 230 61070 {
lab=Y2}
N 230 61070 230 61080 {
lab=Y2}
N 240 61030 280 61030 {
lab=word1017}
N 280 61030 320 61030 {
lab=word1017}
N 250 61020 250 61070 {
lab=GND}
N 250 61070 250 61080 {
lab=GND}
N 310 61020 310 61070 {
lab=Y3}
N 310 61070 310 61080 {
lab=Y3}
N 320 61030 360 61030 {
lab=word1017}
N 360 61030 400 61030 {
lab=word1017}
N 330 61020 330 61070 {
lab=GND}
N 330 61070 330 61080 {
lab=GND}
N 390 61020 390 61070 {
lab=Y4}
N 390 61070 390 61080 {
lab=Y4}
N 400 61030 440 61030 {
lab=word1017}
N 440 61030 480 61030 {
lab=word1017}
N 410 61020 410 61070 {
lab=GND}
N 410 61070 410 61080 {
lab=GND}
N 470 61020 470 61070 {
lab=Y5}
N 470 61070 470 61080 {
lab=Y5}
N 490 61080 520 61080 {
lab=GND}
N 520 61070 520 61080 {
lab=GND}
N 480 61030 520 61030 {
lab=word1017}
N 520 61030 560 61030 {
lab=word1017}
N 490 61020 490 61070 {
lab=GND}
N 490 61070 490 61080 {
lab=GND}
N 550 61020 550 61070 {
lab=Y6}
N 550 61070 550 61080 {
lab=Y6}
N 560 61030 600 61030 {
lab=word1017}
N 600 61030 640 61030 {
lab=word1017}
N 570 61020 570 61070 {
lab=GND}
N 570 61070 570 61080 {
lab=GND}
N 630 61020 630 61070 {
lab=Y7}
N 630 61070 630 61080 {
lab=Y7}
N 0 61090 40 61090 {
lab=word1018}
N 40 61090 80 61090 {
lab=word1018}
N 10 61080 10 61130 {
lab=GND}
N 10 61130 10 61140 {
lab=GND}
N 70 61080 70 61130 {
lab=Y0}
N 70 61130 70 61140 {
lab=Y0}
N 80 61090 120 61090 {
lab=word1018}
N 120 61090 160 61090 {
lab=word1018}
N 90 61080 90 61130 {
lab=GND}
N 90 61130 90 61140 {
lab=GND}
N 150 61080 150 61130 {
lab=Y1}
N 150 61130 150 61140 {
lab=Y1}
N 160 61090 200 61090 {
lab=word1018}
N 200 61090 240 61090 {
lab=word1018}
N 170 61080 170 61130 {
lab=GND}
N 170 61130 170 61140 {
lab=GND}
N 230 61080 230 61130 {
lab=Y2}
N 230 61130 230 61140 {
lab=Y2}
N 240 61090 280 61090 {
lab=word1018}
N 280 61090 320 61090 {
lab=word1018}
N 250 61080 250 61130 {
lab=GND}
N 250 61130 250 61140 {
lab=GND}
N 310 61080 310 61130 {
lab=Y3}
N 310 61130 310 61140 {
lab=Y3}
N 320 61090 360 61090 {
lab=word1018}
N 360 61090 400 61090 {
lab=word1018}
N 330 61080 330 61130 {
lab=GND}
N 330 61130 330 61140 {
lab=GND}
N 390 61080 390 61130 {
lab=Y4}
N 390 61130 390 61140 {
lab=Y4}
N 400 61090 440 61090 {
lab=word1018}
N 440 61090 480 61090 {
lab=word1018}
N 410 61080 410 61130 {
lab=GND}
N 410 61130 410 61140 {
lab=GND}
N 470 61080 470 61130 {
lab=Y5}
N 470 61130 470 61140 {
lab=Y5}
N 480 61090 520 61090 {
lab=word1018}
N 520 61090 560 61090 {
lab=word1018}
N 490 61080 490 61130 {
lab=GND}
N 490 61130 490 61140 {
lab=GND}
N 550 61080 550 61130 {
lab=Y6}
N 550 61130 550 61140 {
lab=Y6}
N 570 61140 600 61140 {
lab=GND}
N 600 61130 600 61140 {
lab=GND}
N 560 61090 600 61090 {
lab=word1018}
N 600 61090 640 61090 {
lab=word1018}
N 570 61080 570 61130 {
lab=GND}
N 570 61130 570 61140 {
lab=GND}
N 630 61080 630 61130 {
lab=Y7}
N 630 61130 630 61140 {
lab=Y7}
N 0 61150 40 61150 {
lab=word1019}
N 40 61150 80 61150 {
lab=word1019}
N 10 61140 10 61190 {
lab=GND}
N 10 61190 10 61200 {
lab=GND}
N 70 61140 70 61190 {
lab=Y0}
N 70 61190 70 61200 {
lab=Y0}
N 80 61150 120 61150 {
lab=word1019}
N 120 61150 160 61150 {
lab=word1019}
N 90 61140 90 61190 {
lab=GND}
N 90 61190 90 61200 {
lab=GND}
N 150 61140 150 61190 {
lab=Y1}
N 150 61190 150 61200 {
lab=Y1}
N 160 61150 200 61150 {
lab=word1019}
N 200 61150 240 61150 {
lab=word1019}
N 170 61140 170 61190 {
lab=GND}
N 170 61190 170 61200 {
lab=GND}
N 230 61140 230 61190 {
lab=Y2}
N 230 61190 230 61200 {
lab=Y2}
N 240 61150 280 61150 {
lab=word1019}
N 280 61150 320 61150 {
lab=word1019}
N 250 61140 250 61190 {
lab=GND}
N 250 61190 250 61200 {
lab=GND}
N 310 61140 310 61190 {
lab=Y3}
N 310 61190 310 61200 {
lab=Y3}
N 320 61150 360 61150 {
lab=word1019}
N 360 61150 400 61150 {
lab=word1019}
N 330 61140 330 61190 {
lab=GND}
N 330 61190 330 61200 {
lab=GND}
N 390 61140 390 61190 {
lab=Y4}
N 390 61190 390 61200 {
lab=Y4}
N 400 61150 440 61150 {
lab=word1019}
N 440 61150 480 61150 {
lab=word1019}
N 410 61140 410 61190 {
lab=GND}
N 410 61190 410 61200 {
lab=GND}
N 470 61140 470 61190 {
lab=Y5}
N 470 61190 470 61200 {
lab=Y5}
N 480 61150 520 61150 {
lab=word1019}
N 520 61150 560 61150 {
lab=word1019}
N 490 61140 490 61190 {
lab=GND}
N 490 61190 490 61200 {
lab=GND}
N 550 61140 550 61190 {
lab=Y6}
N 550 61190 550 61200 {
lab=Y6}
N 570 61200 600 61200 {
lab=GND}
N 600 61190 600 61200 {
lab=GND}
N 560 61150 600 61150 {
lab=word1019}
N 600 61150 640 61150 {
lab=word1019}
N 570 61140 570 61190 {
lab=GND}
N 570 61190 570 61200 {
lab=GND}
N 630 61140 630 61190 {
lab=Y7}
N 630 61190 630 61200 {
lab=Y7}
N 0 61210 40 61210 {
lab=word1020}
N 40 61210 80 61210 {
lab=word1020}
N 10 61200 10 61250 {
lab=GND}
N 10 61250 10 61260 {
lab=GND}
N 70 61200 70 61250 {
lab=Y0}
N 70 61250 70 61260 {
lab=Y0}
N 80 61210 120 61210 {
lab=word1020}
N 120 61210 160 61210 {
lab=word1020}
N 90 61200 90 61250 {
lab=GND}
N 90 61250 90 61260 {
lab=GND}
N 150 61200 150 61250 {
lab=Y1}
N 150 61250 150 61260 {
lab=Y1}
N 160 61210 200 61210 {
lab=word1020}
N 200 61210 240 61210 {
lab=word1020}
N 170 61200 170 61250 {
lab=GND}
N 170 61250 170 61260 {
lab=GND}
N 230 61200 230 61250 {
lab=Y2}
N 230 61250 230 61260 {
lab=Y2}
N 240 61210 280 61210 {
lab=word1020}
N 280 61210 320 61210 {
lab=word1020}
N 250 61200 250 61250 {
lab=GND}
N 250 61250 250 61260 {
lab=GND}
N 310 61200 310 61250 {
lab=Y3}
N 310 61250 310 61260 {
lab=Y3}
N 320 61210 360 61210 {
lab=word1020}
N 360 61210 400 61210 {
lab=word1020}
N 330 61200 330 61250 {
lab=GND}
N 330 61250 330 61260 {
lab=GND}
N 390 61200 390 61250 {
lab=Y4}
N 390 61250 390 61260 {
lab=Y4}
N 400 61210 440 61210 {
lab=word1020}
N 440 61210 480 61210 {
lab=word1020}
N 410 61200 410 61250 {
lab=GND}
N 410 61250 410 61260 {
lab=GND}
N 470 61200 470 61250 {
lab=Y5}
N 470 61250 470 61260 {
lab=Y5}
N 480 61210 520 61210 {
lab=word1020}
N 520 61210 560 61210 {
lab=word1020}
N 490 61200 490 61250 {
lab=GND}
N 490 61250 490 61260 {
lab=GND}
N 550 61200 550 61250 {
lab=Y6}
N 550 61250 550 61260 {
lab=Y6}
N 570 61260 600 61260 {
lab=GND}
N 600 61250 600 61260 {
lab=GND}
N 560 61210 600 61210 {
lab=word1020}
N 600 61210 640 61210 {
lab=word1020}
N 570 61200 570 61250 {
lab=GND}
N 570 61250 570 61260 {
lab=GND}
N 630 61200 630 61250 {
lab=Y7}
N 630 61250 630 61260 {
lab=Y7}
N 0 61270 40 61270 {
lab=word1021}
N 40 61270 80 61270 {
lab=word1021}
N 10 61260 10 61310 {
lab=GND}
N 10 61310 10 61320 {
lab=GND}
N 70 61260 70 61310 {
lab=Y0}
N 70 61310 70 61320 {
lab=Y0}
N 80 61270 120 61270 {
lab=word1021}
N 120 61270 160 61270 {
lab=word1021}
N 90 61260 90 61310 {
lab=GND}
N 90 61310 90 61320 {
lab=GND}
N 150 61260 150 61310 {
lab=Y1}
N 150 61310 150 61320 {
lab=Y1}
N 160 61270 200 61270 {
lab=word1021}
N 200 61270 240 61270 {
lab=word1021}
N 170 61260 170 61310 {
lab=GND}
N 170 61310 170 61320 {
lab=GND}
N 230 61260 230 61310 {
lab=Y2}
N 230 61310 230 61320 {
lab=Y2}
N 240 61270 280 61270 {
lab=word1021}
N 280 61270 320 61270 {
lab=word1021}
N 250 61260 250 61310 {
lab=GND}
N 250 61310 250 61320 {
lab=GND}
N 310 61260 310 61310 {
lab=Y3}
N 310 61310 310 61320 {
lab=Y3}
N 320 61270 360 61270 {
lab=word1021}
N 360 61270 400 61270 {
lab=word1021}
N 330 61260 330 61310 {
lab=GND}
N 330 61310 330 61320 {
lab=GND}
N 390 61260 390 61310 {
lab=Y4}
N 390 61310 390 61320 {
lab=Y4}
N 400 61270 440 61270 {
lab=word1021}
N 440 61270 480 61270 {
lab=word1021}
N 410 61260 410 61310 {
lab=GND}
N 410 61310 410 61320 {
lab=GND}
N 470 61260 470 61310 {
lab=Y5}
N 470 61310 470 61320 {
lab=Y5}
N 480 61270 520 61270 {
lab=word1021}
N 520 61270 560 61270 {
lab=word1021}
N 490 61260 490 61310 {
lab=GND}
N 490 61310 490 61320 {
lab=GND}
N 550 61260 550 61310 {
lab=Y6}
N 550 61310 550 61320 {
lab=Y6}
N 560 61270 600 61270 {
lab=word1021}
N 600 61270 640 61270 {
lab=word1021}
N 570 61260 570 61310 {
lab=GND}
N 570 61310 570 61320 {
lab=GND}
N 630 61260 630 61310 {
lab=Y7}
N 630 61310 630 61320 {
lab=Y7}
N 0 61330 40 61330 {
lab=word1022}
N 40 61330 80 61330 {
lab=word1022}
N 10 61320 10 61370 {
lab=GND}
N 10 61370 10 61380 {
lab=GND}
N 70 61320 70 61370 {
lab=Y0}
N 70 61370 70 61380 {
lab=Y0}
N 80 61330 120 61330 {
lab=word1022}
N 120 61330 160 61330 {
lab=word1022}
N 90 61320 90 61370 {
lab=GND}
N 90 61370 90 61380 {
lab=GND}
N 150 61320 150 61370 {
lab=Y1}
N 150 61370 150 61380 {
lab=Y1}
N 160 61330 200 61330 {
lab=word1022}
N 200 61330 240 61330 {
lab=word1022}
N 170 61320 170 61370 {
lab=GND}
N 170 61370 170 61380 {
lab=GND}
N 230 61320 230 61370 {
lab=Y2}
N 230 61370 230 61380 {
lab=Y2}
N 240 61330 280 61330 {
lab=word1022}
N 280 61330 320 61330 {
lab=word1022}
N 250 61320 250 61370 {
lab=GND}
N 250 61370 250 61380 {
lab=GND}
N 310 61320 310 61370 {
lab=Y3}
N 310 61370 310 61380 {
lab=Y3}
N 320 61330 360 61330 {
lab=word1022}
N 360 61330 400 61330 {
lab=word1022}
N 330 61320 330 61370 {
lab=GND}
N 330 61370 330 61380 {
lab=GND}
N 390 61320 390 61370 {
lab=Y4}
N 390 61370 390 61380 {
lab=Y4}
N 400 61330 440 61330 {
lab=word1022}
N 440 61330 480 61330 {
lab=word1022}
N 410 61320 410 61370 {
lab=GND}
N 410 61370 410 61380 {
lab=GND}
N 470 61320 470 61370 {
lab=Y5}
N 470 61370 470 61380 {
lab=Y5}
N 480 61330 520 61330 {
lab=word1022}
N 520 61330 560 61330 {
lab=word1022}
N 490 61320 490 61370 {
lab=GND}
N 490 61370 490 61380 {
lab=GND}
N 550 61320 550 61370 {
lab=Y6}
N 550 61370 550 61380 {
lab=Y6}
N 560 61330 600 61330 {
lab=word1022}
N 600 61330 640 61330 {
lab=word1022}
N 570 61320 570 61370 {
lab=GND}
N 570 61370 570 61380 {
lab=GND}
N 630 61320 630 61370 {
lab=Y7}
N 630 61370 630 61380 {
lab=Y7}
N 0 61390 40 61390 {
lab=word1023}
N 40 61390 80 61390 {
lab=word1023}
N 10 61380 10 61430 {
lab=GND}
N 10 61430 10 61440 {
lab=GND}
N 70 61380 70 61430 {
lab=Y0}
N 70 61430 70 61440 {
lab=Y0}
N 80 61390 120 61390 {
lab=word1023}
N 120 61390 160 61390 {
lab=word1023}
N 90 61380 90 61430 {
lab=GND}
N 90 61430 90 61440 {
lab=GND}
N 150 61380 150 61430 {
lab=Y1}
N 150 61430 150 61440 {
lab=Y1}
N 160 61390 200 61390 {
lab=word1023}
N 200 61390 240 61390 {
lab=word1023}
N 170 61380 170 61430 {
lab=GND}
N 170 61430 170 61440 {
lab=GND}
N 230 61380 230 61430 {
lab=Y2}
N 230 61430 230 61440 {
lab=Y2}
N 240 61390 280 61390 {
lab=word1023}
N 280 61390 320 61390 {
lab=word1023}
N 250 61380 250 61430 {
lab=GND}
N 250 61430 250 61440 {
lab=GND}
N 310 61380 310 61430 {
lab=Y3}
N 310 61430 310 61440 {
lab=Y3}
N 320 61390 360 61390 {
lab=word1023}
N 360 61390 400 61390 {
lab=word1023}
N 330 61380 330 61430 {
lab=GND}
N 330 61430 330 61440 {
lab=GND}
N 390 61380 390 61430 {
lab=Y4}
N 390 61430 390 61440 {
lab=Y4}
N 400 61390 440 61390 {
lab=word1023}
N 440 61390 480 61390 {
lab=word1023}
N 410 61380 410 61430 {
lab=GND}
N 410 61430 410 61440 {
lab=GND}
N 470 61380 470 61430 {
lab=Y5}
N 470 61430 470 61440 {
lab=Y5}
N 480 61390 520 61390 {
lab=word1023}
N 520 61390 560 61390 {
lab=word1023}
N 490 61380 490 61430 {
lab=GND}
N 490 61430 490 61440 {
lab=GND}
N 550 61380 550 61430 {
lab=Y6}
N 550 61430 550 61440 {
lab=Y6}
N 560 61390 600 61390 {
lab=word1023}
N 600 61390 640 61390 {
lab=word1023}
N 570 61380 570 61430 {
lab=GND}
N 570 61430 570 61440 {
lab=GND}
N 630 61380 630 61430 {
lab=Y7}
N 630 61430 630 61440 {
lab=Y7}
C {devices/gnd.sym} 10 -30 2 0 {name=l1 lab=GND}
C {devices/lab_wire.sym} 90 0 0 1 {name=p1 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 170 0 0 1 {name=p2 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 250 0 0 1 {name=p3 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 330 0 0 1 {name=p4 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 410 0 0 1 {name=p5 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 490 0 0 1 {name=p6 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 570 0 0 1 {name=p7 sig_type=std_logic lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 50 -80 0 0 {name=M1
L=0.17
W=0.51
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 20 -80 0 0 {name=p8 sig_type=std_logic lab=GND}
C {devices/vdd.sym} 70 -120 0 0 {name=l2 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 -80 0 0 {name=M2
L=0.17
W=0.51
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 210 -80 0 0 {name=M3
L=0.17
W=0.51
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 290 -80 0 0 {name=M4
L=0.17
W=0.51
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 370 -80 0 0 {name=M5
L=0.17
W=0.51
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 450 -80 0 0 {name=M6
L=0.17
W=0.51
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 530 -80 0 0 {name=M7
L=0.17
W=0.51
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 610 -80 0 0 {name=M8
L=0.17
W=0.51
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 150 -120 0 1 {name=p9 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 470 -120 0 1 {name=p10 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 550 -120 0 1 {name=p11 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 630 -120 0 1 {name=p12 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 230 -120 0 1 {name=p13 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 310 -120 0 1 {name=p14 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 390 -120 0 1 {name=p15 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 100 -80 0 0 {name=p16 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 180 -80 0 0 {name=p17 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 260 -80 0 0 {name=p18 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 340 -80 0 0 {name=p19 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 420 -80 0 0 {name=p20 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 500 -80 0 0 {name=p21 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 580 -80 0 0 {name=p22 sig_type=std_logic lab=GND}
C {devices/ipin.sym} 0 10 0 0 {name=p23 lab=word0}
C {devices/ipin.sym} 0 70 0 0 {name=p24 lab=word1}
C {devices/ipin.sym} 0 130 0 0 {name=p25 lab=word2}
C {devices/ipin.sym} 0 190 0 0 {name=p26 lab=word3}
C {devices/ipin.sym} 0 250 0 0 {name=p27 lab=word4}
C {devices/ipin.sym} 0 310 0 0 {name=p28 lab=word5}
C {devices/ipin.sym} 0 370 0 0 {name=p29 lab=word6}
C {devices/ipin.sym} 0 430 0 0 {name=p30 lab=word7}
C {devices/ipin.sym} 0 490 0 0 {name=p31 lab=word8}
C {devices/ipin.sym} 0 550 0 0 {name=p32 lab=word9}
C {devices/ipin.sym} 0 610 0 0 {name=p33 lab=word10}
C {devices/ipin.sym} 0 670 0 0 {name=p34 lab=word11}
C {devices/ipin.sym} 0 730 0 0 {name=p35 lab=word12}
C {devices/ipin.sym} 0 790 0 0 {name=p36 lab=word13}
C {devices/ipin.sym} 0 850 0 0 {name=p37 lab=word14}
C {devices/ipin.sym} 0 910 0 0 {name=p38 lab=word15}
C {devices/ipin.sym} 0 970 0 0 {name=p39 lab=word16}
C {devices/ipin.sym} 0 1030 0 0 {name=p40 lab=word17}
C {devices/ipin.sym} 0 1090 0 0 {name=p41 lab=word18}
C {devices/ipin.sym} 0 1150 0 0 {name=p42 lab=word19}
C {devices/ipin.sym} 0 1210 0 0 {name=p43 lab=word20}
C {devices/ipin.sym} 0 1270 0 0 {name=p44 lab=word21}
C {devices/ipin.sym} 0 1330 0 0 {name=p45 lab=word22}
C {devices/ipin.sym} 0 1390 0 0 {name=p46 lab=word23}
C {devices/ipin.sym} 0 1450 0 0 {name=p47 lab=word24}
C {devices/ipin.sym} 0 1510 0 0 {name=p48 lab=word25}
C {devices/ipin.sym} 0 1570 0 0 {name=p49 lab=word26}
C {devices/ipin.sym} 0 1630 0 0 {name=p50 lab=word27}
C {devices/ipin.sym} 0 1690 0 0 {name=p51 lab=word28}
C {devices/ipin.sym} 0 1750 0 0 {name=p52 lab=word29}
C {devices/ipin.sym} 0 1810 0 0 {name=p53 lab=word30}
C {devices/ipin.sym} 0 1870 0 0 {name=p54 lab=word31}
C {devices/ipin.sym} 0 1930 0 0 {name=p55 lab=word32}
C {devices/ipin.sym} 0 1990 0 0 {name=p56 lab=word33}
C {devices/ipin.sym} 0 2050 0 0 {name=p57 lab=word34}
C {devices/ipin.sym} 0 2110 0 0 {name=p58 lab=word35}
C {devices/ipin.sym} 0 2170 0 0 {name=p59 lab=word36}
C {devices/ipin.sym} 0 2230 0 0 {name=p60 lab=word37}
C {devices/ipin.sym} 0 2290 0 0 {name=p61 lab=word38}
C {devices/ipin.sym} 0 2350 0 0 {name=p62 lab=word39}
C {devices/ipin.sym} 0 2410 0 0 {name=p63 lab=word40}
C {devices/ipin.sym} 0 2470 0 0 {name=p64 lab=word41}
C {devices/ipin.sym} 0 2530 0 0 {name=p65 lab=word42}
C {devices/ipin.sym} 0 2590 0 0 {name=p66 lab=word43}
C {devices/ipin.sym} 0 2650 0 0 {name=p67 lab=word44}
C {devices/ipin.sym} 0 2710 0 0 {name=p68 lab=word45}
C {devices/ipin.sym} 0 2770 0 0 {name=p69 lab=word46}
C {devices/ipin.sym} 0 2830 0 0 {name=p70 lab=word47}
C {devices/ipin.sym} 0 2890 0 0 {name=p71 lab=word48}
C {devices/ipin.sym} 0 2950 0 0 {name=p72 lab=word49}
C {devices/ipin.sym} 0 3010 0 0 {name=p73 lab=word50}
C {devices/ipin.sym} 0 3070 0 0 {name=p74 lab=word51}
C {devices/ipin.sym} 0 3130 0 0 {name=p75 lab=word52}
C {devices/ipin.sym} 0 3190 0 0 {name=p76 lab=word53}
C {devices/ipin.sym} 0 3250 0 0 {name=p77 lab=word54}
C {devices/ipin.sym} 0 3310 0 0 {name=p78 lab=word55}
C {devices/ipin.sym} 0 3370 0 0 {name=p79 lab=word56}
C {devices/ipin.sym} 0 3430 0 0 {name=p80 lab=word57}
C {devices/ipin.sym} 0 3490 0 0 {name=p81 lab=word58}
C {devices/ipin.sym} 0 3550 0 0 {name=p82 lab=word59}
C {devices/ipin.sym} 0 3610 0 0 {name=p83 lab=word60}
C {devices/ipin.sym} 0 3670 0 0 {name=p84 lab=word61}
C {devices/ipin.sym} 0 3730 0 0 {name=p85 lab=word62}
C {devices/ipin.sym} 0 3790 0 0 {name=p86 lab=word63}
C {devices/ipin.sym} 0 3850 0 0 {name=p87 lab=word64}
C {devices/ipin.sym} 0 3910 0 0 {name=p88 lab=word65}
C {devices/ipin.sym} 0 3970 0 0 {name=p89 lab=word66}
C {devices/ipin.sym} 0 4030 0 0 {name=p90 lab=word67}
C {devices/ipin.sym} 0 4090 0 0 {name=p91 lab=word68}
C {devices/ipin.sym} 0 4150 0 0 {name=p92 lab=word69}
C {devices/ipin.sym} 0 4210 0 0 {name=p93 lab=word70}
C {devices/ipin.sym} 0 4270 0 0 {name=p94 lab=word71}
C {devices/ipin.sym} 0 4330 0 0 {name=p95 lab=word72}
C {devices/ipin.sym} 0 4390 0 0 {name=p96 lab=word73}
C {devices/ipin.sym} 0 4450 0 0 {name=p97 lab=word74}
C {devices/ipin.sym} 0 4510 0 0 {name=p98 lab=word75}
C {devices/ipin.sym} 0 4570 0 0 {name=p99 lab=word76}
C {devices/ipin.sym} 0 4630 0 0 {name=p100 lab=word77}
C {devices/ipin.sym} 0 4690 0 0 {name=p101 lab=word78}
C {devices/ipin.sym} 0 4750 0 0 {name=p102 lab=word79}
C {devices/ipin.sym} 0 4810 0 0 {name=p103 lab=word80}
C {devices/ipin.sym} 0 4870 0 0 {name=p104 lab=word81}
C {devices/ipin.sym} 0 4930 0 0 {name=p105 lab=word82}
C {devices/ipin.sym} 0 4990 0 0 {name=p106 lab=word83}
C {devices/ipin.sym} 0 5050 0 0 {name=p107 lab=word84}
C {devices/ipin.sym} 0 5110 0 0 {name=p108 lab=word85}
C {devices/ipin.sym} 0 5170 0 0 {name=p109 lab=word86}
C {devices/ipin.sym} 0 5230 0 0 {name=p110 lab=word87}
C {devices/ipin.sym} 0 5290 0 0 {name=p111 lab=word88}
C {devices/ipin.sym} 0 5350 0 0 {name=p112 lab=word89}
C {devices/ipin.sym} 0 5410 0 0 {name=p113 lab=word90}
C {devices/ipin.sym} 0 5470 0 0 {name=p114 lab=word91}
C {devices/ipin.sym} 0 5530 0 0 {name=p115 lab=word92}
C {devices/ipin.sym} 0 5590 0 0 {name=p116 lab=word93}
C {devices/ipin.sym} 0 5650 0 0 {name=p117 lab=word94}
C {devices/ipin.sym} 0 5710 0 0 {name=p118 lab=word95}
C {devices/ipin.sym} 0 5770 0 0 {name=p119 lab=word96}
C {devices/ipin.sym} 0 5830 0 0 {name=p120 lab=word97}
C {devices/ipin.sym} 0 5890 0 0 {name=p121 lab=word98}
C {devices/ipin.sym} 0 5950 0 0 {name=p122 lab=word99}
C {devices/ipin.sym} 0 6010 0 0 {name=p123 lab=word100}
C {devices/ipin.sym} 0 6070 0 0 {name=p124 lab=word101}
C {devices/ipin.sym} 0 6130 0 0 {name=p125 lab=word102}
C {devices/ipin.sym} 0 6190 0 0 {name=p126 lab=word103}
C {devices/ipin.sym} 0 6250 0 0 {name=p127 lab=word104}
C {devices/ipin.sym} 0 6310 0 0 {name=p128 lab=word105}
C {devices/ipin.sym} 0 6370 0 0 {name=p129 lab=word106}
C {devices/ipin.sym} 0 6430 0 0 {name=p130 lab=word107}
C {devices/ipin.sym} 0 6490 0 0 {name=p131 lab=word108}
C {devices/ipin.sym} 0 6550 0 0 {name=p132 lab=word109}
C {devices/ipin.sym} 0 6610 0 0 {name=p133 lab=word110}
C {devices/ipin.sym} 0 6670 0 0 {name=p134 lab=word111}
C {devices/ipin.sym} 0 6730 0 0 {name=p135 lab=word112}
C {devices/ipin.sym} 0 6790 0 0 {name=p136 lab=word113}
C {devices/ipin.sym} 0 6850 0 0 {name=p137 lab=word114}
C {devices/ipin.sym} 0 6910 0 0 {name=p138 lab=word115}
C {devices/ipin.sym} 0 6970 0 0 {name=p139 lab=word116}
C {devices/ipin.sym} 0 7030 0 0 {name=p140 lab=word117}
C {devices/ipin.sym} 0 7090 0 0 {name=p141 lab=word118}
C {devices/ipin.sym} 0 7150 0 0 {name=p142 lab=word119}
C {devices/ipin.sym} 0 7210 0 0 {name=p143 lab=word120}
C {devices/ipin.sym} 0 7270 0 0 {name=p144 lab=word121}
C {devices/ipin.sym} 0 7330 0 0 {name=p145 lab=word122}
C {devices/ipin.sym} 0 7390 0 0 {name=p146 lab=word123}
C {devices/ipin.sym} 0 7450 0 0 {name=p147 lab=word124}
C {devices/ipin.sym} 0 7510 0 0 {name=p148 lab=word125}
C {devices/ipin.sym} 0 7570 0 0 {name=p149 lab=word126}
C {devices/ipin.sym} 0 7630 0 0 {name=p150 lab=word127}
C {devices/ipin.sym} 0 7690 0 0 {name=p151 lab=word128}
C {sky130_fd_pr/nfet_01v8.sym} 40 7710 1 0 {name=M9
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 7710 1 0 {name=M10
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 7710 1 0 {name=M11
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 7710 1 0 {name=M12
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 7710 1 0 {name=M13
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 7710 1 0 {name=M14
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 7710 1 0 {name=M15
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 7710 1 0 {name=M16
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 7750 0 0 {name=p152 lab=word129}
C {sky130_fd_pr/nfet_01v8.sym} 40 7770 1 0 {name=M17
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 7770 1 0 {name=M18
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 7770 1 0 {name=M19
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 7770 1 0 {name=M20
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 7770 1 0 {name=M21
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 7770 1 0 {name=M22
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 7770 1 0 {name=M23
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 7770 1 0 {name=M24
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 7810 0 0 {name=p153 lab=word130}
C {sky130_fd_pr/nfet_01v8.sym} 40 7830 1 0 {name=M25
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 7830 1 0 {name=M26
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 7830 1 0 {name=M27
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 7830 1 0 {name=M28
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 7830 1 0 {name=M29
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 7830 1 0 {name=M30
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 7830 1 0 {name=M31
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 7830 1 0 {name=M32
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 7870 0 0 {name=p154 lab=word131}
C {sky130_fd_pr/nfet_01v8.sym} 40 7890 1 0 {name=M33
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 7890 1 0 {name=M34
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 7890 1 0 {name=M35
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 7890 1 0 {name=M36
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 7890 1 0 {name=M37
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 7890 1 0 {name=M38
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 7890 1 0 {name=M39
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 7890 1 0 {name=M40
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 7930 0 0 {name=p155 lab=word132}
C {sky130_fd_pr/nfet_01v8.sym} 40 7950 1 0 {name=M41
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 7950 1 0 {name=M42
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 7950 1 0 {name=M43
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 7950 1 0 {name=M44
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 7950 1 0 {name=M45
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 7950 1 0 {name=M46
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 7950 1 0 {name=M47
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 7950 1 0 {name=M48
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 7990 0 0 {name=p156 lab=word133}
C {sky130_fd_pr/nfet_01v8.sym} 40 8010 1 0 {name=M49
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8010 1 0 {name=M50
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8010 1 0 {name=M51
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8010 1 0 {name=M52
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8010 1 0 {name=M53
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8010 1 0 {name=M54
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8010 1 0 {name=M55
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8010 1 0 {name=M56
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8050 0 0 {name=p157 lab=word134}
C {sky130_fd_pr/nfet_01v8.sym} 40 8070 1 0 {name=M57
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8070 1 0 {name=M58
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8070 1 0 {name=M59
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8070 1 0 {name=M60
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8070 1 0 {name=M61
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8070 1 0 {name=M62
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8070 1 0 {name=M63
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8070 1 0 {name=M64
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8110 0 0 {name=p158 lab=word135}
C {sky130_fd_pr/nfet_01v8.sym} 40 8130 1 0 {name=M65
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8130 1 0 {name=M66
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8130 1 0 {name=M67
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8130 1 0 {name=M68
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8130 1 0 {name=M69
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8130 1 0 {name=M70
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8130 1 0 {name=M71
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8130 1 0 {name=M72
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8170 0 0 {name=p159 lab=word136}
C {sky130_fd_pr/nfet_01v8.sym} 40 8190 1 0 {name=M73
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8190 1 0 {name=M74
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8190 1 0 {name=M75
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8190 1 0 {name=M76
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8190 1 0 {name=M77
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8190 1 0 {name=M78
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8190 1 0 {name=M79
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8190 1 0 {name=M80
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8230 0 0 {name=p160 lab=word137}
C {sky130_fd_pr/nfet_01v8.sym} 40 8250 1 0 {name=M81
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8250 1 0 {name=M82
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8250 1 0 {name=M83
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8250 1 0 {name=M84
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8250 1 0 {name=M85
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8250 1 0 {name=M86
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8250 1 0 {name=M87
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8250 1 0 {name=M88
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8290 0 0 {name=p161 lab=word138}
C {sky130_fd_pr/nfet_01v8.sym} 40 8310 1 0 {name=M89
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8310 1 0 {name=M90
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8310 1 0 {name=M91
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8310 1 0 {name=M92
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8310 1 0 {name=M93
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8310 1 0 {name=M94
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8310 1 0 {name=M95
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8310 1 0 {name=M96
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8350 0 0 {name=p162 lab=word139}
C {sky130_fd_pr/nfet_01v8.sym} 40 8370 1 0 {name=M97
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8370 1 0 {name=M98
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8370 1 0 {name=M99
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8370 1 0 {name=M100
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8370 1 0 {name=M101
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8370 1 0 {name=M102
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8370 1 0 {name=M103
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8370 1 0 {name=M104
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8410 0 0 {name=p163 lab=word140}
C {sky130_fd_pr/nfet_01v8.sym} 40 8430 1 0 {name=M105
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8430 1 0 {name=M106
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8430 1 0 {name=M107
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8430 1 0 {name=M108
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8430 1 0 {name=M109
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8430 1 0 {name=M110
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8430 1 0 {name=M111
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8430 1 0 {name=M112
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8470 0 0 {name=p164 lab=word141}
C {sky130_fd_pr/nfet_01v8.sym} 40 8490 1 0 {name=M113
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8490 1 0 {name=M114
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8490 1 0 {name=M115
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8490 1 0 {name=M116
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8490 1 0 {name=M117
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8490 1 0 {name=M118
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8490 1 0 {name=M119
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8490 1 0 {name=M120
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8530 0 0 {name=p165 lab=word142}
C {sky130_fd_pr/nfet_01v8.sym} 40 8550 1 0 {name=M121
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8550 1 0 {name=M122
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8550 1 0 {name=M123
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8550 1 0 {name=M124
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8550 1 0 {name=M125
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8550 1 0 {name=M126
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8550 1 0 {name=M127
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8550 1 0 {name=M128
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8590 0 0 {name=p166 lab=word143}
C {sky130_fd_pr/nfet_01v8.sym} 40 8610 1 0 {name=M129
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8610 1 0 {name=M130
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8610 1 0 {name=M131
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8610 1 0 {name=M132
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8610 1 0 {name=M133
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8610 1 0 {name=M134
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8610 1 0 {name=M135
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8610 1 0 {name=M136
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8650 0 0 {name=p167 lab=word144}
C {sky130_fd_pr/nfet_01v8.sym} 40 8670 1 0 {name=M137
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8670 1 0 {name=M138
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8670 1 0 {name=M139
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8670 1 0 {name=M140
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8670 1 0 {name=M141
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8670 1 0 {name=M142
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8670 1 0 {name=M143
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8670 1 0 {name=M144
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8710 0 0 {name=p168 lab=word145}
C {sky130_fd_pr/nfet_01v8.sym} 40 8730 1 0 {name=M145
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8730 1 0 {name=M146
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8730 1 0 {name=M147
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8730 1 0 {name=M148
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8730 1 0 {name=M149
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8730 1 0 {name=M150
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8730 1 0 {name=M151
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8730 1 0 {name=M152
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8770 0 0 {name=p169 lab=word146}
C {sky130_fd_pr/nfet_01v8.sym} 40 8790 1 0 {name=M153
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8790 1 0 {name=M154
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8790 1 0 {name=M155
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8790 1 0 {name=M156
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8790 1 0 {name=M157
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8790 1 0 {name=M158
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8790 1 0 {name=M159
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8790 1 0 {name=M160
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8830 0 0 {name=p170 lab=word147}
C {sky130_fd_pr/nfet_01v8.sym} 40 8850 1 0 {name=M161
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8850 1 0 {name=M162
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8850 1 0 {name=M163
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8850 1 0 {name=M164
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8850 1 0 {name=M165
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8850 1 0 {name=M166
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8850 1 0 {name=M167
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8850 1 0 {name=M168
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8890 0 0 {name=p171 lab=word148}
C {sky130_fd_pr/nfet_01v8.sym} 40 8910 1 0 {name=M169
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8910 1 0 {name=M170
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8910 1 0 {name=M171
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8910 1 0 {name=M172
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8910 1 0 {name=M173
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8910 1 0 {name=M174
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8910 1 0 {name=M175
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8910 1 0 {name=M176
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8950 0 0 {name=p172 lab=word149}
C {sky130_fd_pr/nfet_01v8.sym} 40 8970 1 0 {name=M177
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 8970 1 0 {name=M178
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 8970 1 0 {name=M179
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 8970 1 0 {name=M180
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 8970 1 0 {name=M181
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 8970 1 0 {name=M182
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 8970 1 0 {name=M183
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 8970 1 0 {name=M184
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9010 0 0 {name=p173 lab=word150}
C {sky130_fd_pr/nfet_01v8.sym} 40 9030 1 0 {name=M185
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 9030 1 0 {name=M186
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 9030 1 0 {name=M187
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 9030 1 0 {name=M188
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 9030 1 0 {name=M189
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 9030 1 0 {name=M190
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 9030 1 0 {name=M191
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 9030 1 0 {name=M192
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9070 0 0 {name=p174 lab=word151}
C {sky130_fd_pr/nfet_01v8.sym} 40 9090 1 0 {name=M193
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 9090 1 0 {name=M194
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 9090 1 0 {name=M195
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 9090 1 0 {name=M196
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 9090 1 0 {name=M197
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 9090 1 0 {name=M198
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 9090 1 0 {name=M199
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 9090 1 0 {name=M200
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9130 0 0 {name=p175 lab=word152}
C {sky130_fd_pr/nfet_01v8.sym} 40 9150 1 0 {name=M201
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 9150 1 0 {name=M202
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 9150 1 0 {name=M203
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 9150 1 0 {name=M204
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 9150 1 0 {name=M205
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 9150 1 0 {name=M206
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 9150 1 0 {name=M207
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 9150 1 0 {name=M208
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9190 0 0 {name=p176 lab=word153}
C {sky130_fd_pr/nfet_01v8.sym} 40 9210 1 0 {name=M209
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 9210 1 0 {name=M210
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 9210 1 0 {name=M211
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 9210 1 0 {name=M212
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 9210 1 0 {name=M213
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 9210 1 0 {name=M214
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 9210 1 0 {name=M215
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 9210 1 0 {name=M216
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9250 0 0 {name=p177 lab=word154}
C {sky130_fd_pr/nfet_01v8.sym} 40 9270 1 0 {name=M217
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 9270 1 0 {name=M218
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 9270 1 0 {name=M219
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 9270 1 0 {name=M220
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 9270 1 0 {name=M221
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 9270 1 0 {name=M222
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 9270 1 0 {name=M223
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 9270 1 0 {name=M224
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9310 0 0 {name=p178 lab=word155}
C {sky130_fd_pr/nfet_01v8.sym} 40 9330 1 0 {name=M225
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 9330 1 0 {name=M226
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 9330 1 0 {name=M227
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 9330 1 0 {name=M228
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 9330 1 0 {name=M229
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 9330 1 0 {name=M230
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 9330 1 0 {name=M231
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 9330 1 0 {name=M232
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9370 0 0 {name=p179 lab=word156}
C {sky130_fd_pr/nfet_01v8.sym} 40 9390 1 0 {name=M233
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 9390 1 0 {name=M234
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 9390 1 0 {name=M235
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 9390 1 0 {name=M236
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 9390 1 0 {name=M237
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 9390 1 0 {name=M238
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 9390 1 0 {name=M239
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 9390 1 0 {name=M240
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9430 0 0 {name=p180 lab=word157}
C {sky130_fd_pr/nfet_01v8.sym} 40 9450 1 0 {name=M241
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 9450 1 0 {name=M242
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 9450 1 0 {name=M243
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 9450 1 0 {name=M244
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 9450 1 0 {name=M245
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 9450 1 0 {name=M246
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 9450 1 0 {name=M247
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 9450 1 0 {name=M248
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9490 0 0 {name=p181 lab=word158}
C {sky130_fd_pr/nfet_01v8.sym} 40 9510 1 0 {name=M249
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 9510 1 0 {name=M250
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 9510 1 0 {name=M251
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 280 9510 1 0 {name=M252
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 9510 1 0 {name=M253
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 9510 1 0 {name=M254
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 9510 1 0 {name=M255
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 9510 1 0 {name=M256
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9550 0 0 {name=p182 lab=word159}
C {sky130_fd_pr/nfet_01v8.sym} 40 9570 1 0 {name=M257
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 9570 1 0 {name=M258
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 200 9570 1 0 {name=M259
L=0.17
W=0.51
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
