v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 0 10 40 10 {
lab=#net2}
N 40 10 80 10 {
lab=#net2}
N 10 0 10 50 {
lab=#net1}
N 10 50 10 60 {
lab=#net1}
N 70 0 70 50 {
lab=#net4}
N 70 50 70 60 {
lab=#net4}
