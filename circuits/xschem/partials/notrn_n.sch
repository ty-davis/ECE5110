v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 10 0 10 80 {lab=#net9}
N 0 70 90 70 {lab=#net10}
