v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 430 -20 430 10 {
lab=A0}
N 430 -70 430 -20 {
lab=A0}
N 520 -70 520 -20 {
lab=N_A0}
N 520 -20 520 10 {
lab=N_A0}
N 610 -70 610 -20 {
lab=A1}
N 610 -20 610 10 {
lab=A1}
N 700 -70 700 -20 {
lab=N_A1}
N 700 -20 700 10 {
lab=N_A1}
C {devices/lab_wire.sym} 430 -70 0 0 {name=p5 sig_type=std_logic lab=A0}
C {devices/lab_wire.sym} 520 -70 0 0 {name=p6 sig_type=std_logic lab=N_A0}
C {devices/lab_wire.sym} 610 -70 0 0 {name=p7 sig_type=std_logic lab=A1}
C {devices/lab_wire.sym} 700 -70 0 0 {name=p8 sig_type=std_logic lab=N_A1}
