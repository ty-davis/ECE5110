v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 80 0 80 80 {lab=#net8}
N 0 70 90 70 {lab=#net11}
