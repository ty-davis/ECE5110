N 1850 8170 1860 8170 {lab=GND}
N 1810 8160 1810 8200 {lab=#net5}
N 1810 8200 1810 8240 {lab=#net5}
N 1800 8230 1850 8230 {lab=word102}
N 1850 8230 1890 8230 {lab=word102}
N 1720 8160 1720 8240 {lab=A2}
N 1710 8230 1800 8230 {lab=word102}
N 1670 8200 1680 8200 {lab=GND}
N 1680 8170 1680 8200 {lab=GND}
N 1670 8170 1680 8170 {lab=GND}
N 1630 8160 1630 8200 {lab=#net6}
N 1630 8200 1630 8240 {lab=#net6}
N 1620 8230 1670 8230 {lab=word102}
N 1670 8230 1710 8230 {lab=word102}
N 1540 8160 1540 8240 {lab=A1}
N 1530 8230 1620 8230 {lab=word102}
N 1450 8160 1450 8240 {lab=#net7}
N 1440 8230 1530 8230 {lab=word102}
N 1400 8200 1410 8200 {lab=GND}
N 1410 8170 1410 8200 {lab=GND}
N 1400 8170 1410 8170 {lab=GND}
N 1360 8160 1360 8200 {lab=A0}
N 1360 8200 1360 8240 {lab=A0}
N 1350 8230 1400 8230 {lab=word102}
N 1400 8230 1440 8230 {lab=word102}
N 1260 8230 1350 8230 { lab=word102}
N 1210 8190 1250 8190 {lab=A0}
N 1210 8230 1210 8240 {lab=VDD}
N 1240 8230 1260 8230 {lab=word102}
N 1170 8230 1180 8230 {lab=#net627}
N 1250 8160 1250 8190 {lab=A0}
N 1250 8190 1250 8240 {lab=A0}
N 1160 8160 1160 8240 {lab=#net9}
N 1080 8230 1170 8230 {lab=#net627}
N 1070 8160 1070 8240 {lab=A1}
N 990 8230 1080 8230 {lab=#net627}
N 940 8190 980 8190 {lab=#net11}
N 940 8230 940 8240 {lab=VDD}
N 970 8230 990 8230 {lab=#net627}
N 900 8230 910 8230 {lab=#net628}
N 980 8160 980 8190 {lab=#net11}
N 980 8190 980 8240 {lab=#net11}
N 890 8160 890 8240 {lab=A2}
N 810 8230 900 8230 {lab=#net628}
N 760 8190 800 8190 {lab=#net13}
N 760 8230 760 8240 {lab=VDD}
N 790 8230 810 8230 {lab=#net628}
N 720 8230 730 8230 {lab=#net629}
N 800 8160 800 8190 {lab=#net13}
N 800 8190 800 8240 {lab=#net13}
N 670 8190 710 8190 {lab=A3}
N 670 8230 670 8240 {lab=VDD}
N 700 8230 720 8230 {lab=#net629}
N 630 8230 640 8230 {lab=#net630}
N 710 8160 710 8190 {lab=A3}
N 710 8190 710 8240 {lab=A3}
N 620 8160 620 8240 {lab=#net15}
N 540 8230 630 8230 {lab=#net630}
N 490 8190 530 8190 {lab=A4}
N 490 8230 490 8240 {lab=VDD}
N 520 8230 540 8230 {lab=#net630}
N 450 8230 460 8230 {lab=#net631}
N 530 8160 530 8190 {lab=A4}
N 530 8190 530 8240 {lab=A4}
N 440 8160 440 8240 {lab=#net17}
N 360 8230 450 8230 {lab=#net631}
N 350 8160 350 8240 {lab=A5}
N 270 8230 360 8230 {lab=#net631}
N 220 8190 260 8190 {lab=#net19}
N 220 8230 220 8240 {lab=VDD}
N 250 8230 270 8230 {lab=#net631}
N 180 8230 190 8230 {lab=#net632}
N 260 8160 260 8190 {lab=#net19}
N 260 8190 260 8240 {lab=#net19}
N 170 8160 170 8240 {lab=A6}
N 90 8230 180 8230 {lab=#net632}
N 40 8190 80 8190 {lab=#net20}
N 40 8230 40 8240 {lab=VDD}
N 70 8230 90 8230 {lab=#net632}
N 0 8230 10 8230 {lab=VDD}
N 80 8160 80 8190 {lab=#net20}
N 80 8190 80 8240 {lab=#net20}
N 0 8160 0 8240 { lab=VDD}
N 2570 8280 2580 8280 {lab=GND}
N 2580 8250 2580 8280 {lab=GND}
N 2570 8250 2580 8250 {lab=GND}
N 2530 8240 2530 8280 {lab=#net1}
N 2530 8280 2530 8320 {lab=#net1}
N 2520 8310 2570 8310 {lab=word103}
N 2570 8310 2610 8310 {lab=word103}
N 2440 8240 2440 8320 {lab=A6}
N 2430 8310 2520 8310 {lab=word103}
N 2390 8280 2400 8280 {lab=GND}
N 2400 8250 2400 8280 {lab=GND}
N 2390 8250 2400 8250 {lab=GND}
N 2350 8240 2350 8280 {lab=#net2}
N 2350 8280 2350 8320 {lab=#net2}
N 2340 8310 2390 8310 {lab=word103}
N 2390 8310 2430 8310 {lab=word103}
N 2260 8240 2260 8320 {lab=A5}
N 2250 8310 2340 8310 {lab=word103}
N 2170 8240 2170 8320 {lab=#net3}
N 2160 8310 2250 8310 {lab=word103}
N 2120 8280 2130 8280 {lab=GND}
N 2130 8250 2130 8280 {lab=GND}
N 2120 8250 2130 8250 {lab=GND}
N 2080 8240 2080 8280 {lab=A4}
N 2080 8280 2080 8320 {lab=A4}
N 2070 8310 2120 8310 {lab=word103}
N 2120 8310 2160 8310 {lab=word103}
N 1990 8240 1990 8320 {lab=#net4}
N 1980 8310 2070 8310 {lab=word103}
N 1940 8280 1950 8280 {lab=GND}
N 1950 8250 1950 8280 {lab=GND}
N 1940 8250 1950 8250 {lab=GND}
N 1900 8240 1900 8280 {lab=A3}
N 1900 8280 1900 8320 {lab=A3}
N 1890 8310 1940 8310 {lab=word103}
N 1940 8310 1980 8310 {lab=word103}
N 1850 8280 1860 8280 {lab=GND}
N 1860 8250 1860 8280 {lab=GND}
N 1850 8250 1860 8250 {lab=GND}
N 1810 8240 1810 8280 {lab=#net5}
N 1810 8280 1810 8320 {lab=#net5}
N 1800 8310 1850 8310 {lab=word103}
N 1850 8310 1890 8310 {lab=word103}
N 1720 8240 1720 8320 {lab=A2}
N 1710 8310 1800 8310 {lab=word103}
N 1670 8280 1680 8280 {lab=GND}
N 1680 8250 1680 8280 {lab=GND}
N 1670 8250 1680 8250 {lab=GND}
N 1630 8240 1630 8280 {lab=#net6}
N 1630 8280 1630 8320 {lab=#net6}
N 1620 8310 1670 8310 {lab=word103}
N 1670 8310 1710 8310 {lab=word103}
N 1540 8240 1540 8320 {lab=A1}
N 1530 8310 1620 8310 {lab=word103}
N 1490 8280 1500 8280 {lab=GND}
N 1500 8250 1500 8280 {lab=GND}
N 1490 8250 1500 8250 {lab=GND}
N 1450 8240 1450 8280 {lab=#net7}
N 1450 8280 1450 8320 {lab=#net7}
N 1440 8310 1490 8310 {lab=word103}
N 1490 8310 1530 8310 {lab=word103}
N 1360 8240 1360 8320 {lab=A0}
N 1350 8310 1440 8310 {lab=word103}
N 1260 8310 1350 8310 { lab=word103}
N 1250 8240 1250 8320 {lab=A0}
N 1170 8310 1260 8310 {lab=word103}
N 1120 8270 1160 8270 {lab=#net9}
N 1120 8310 1120 8320 {lab=VDD}
N 1150 8310 1170 8310 {lab=word103}
N 1080 8310 1090 8310 {lab=#net633}
N 1160 8240 1160 8270 {lab=#net9}
N 1160 8270 1160 8320 {lab=#net9}
N 1070 8240 1070 8320 {lab=A1}
N 990 8310 1080 8310 {lab=#net633}
N 940 8270 980 8270 {lab=#net11}
N 940 8310 940 8320 {lab=VDD}
N 970 8310 990 8310 {lab=#net633}
N 900 8310 910 8310 {lab=#net634}
N 980 8240 980 8270 {lab=#net11}
N 980 8270 980 8320 {lab=#net11}
N 890 8240 890 8320 {lab=A2}
N 810 8310 900 8310 {lab=#net634}
N 760 8270 800 8270 {lab=#net13}
N 760 8310 760 8320 {lab=VDD}
N 790 8310 810 8310 {lab=#net634}
N 720 8310 730 8310 {lab=#net635}
N 800 8240 800 8270 {lab=#net13}
N 800 8270 800 8320 {lab=#net13}
N 670 8270 710 8270 {lab=A3}
N 670 8310 670 8320 {lab=VDD}
N 700 8310 720 8310 {lab=#net635}
N 630 8310 640 8310 {lab=#net636}
N 710 8240 710 8270 {lab=A3}
N 710 8270 710 8320 {lab=A3}
N 620 8240 620 8320 {lab=#net15}
N 540 8310 630 8310 {lab=#net636}
N 490 8270 530 8270 {lab=A4}
N 490 8310 490 8320 {lab=VDD}
N 520 8310 540 8310 {lab=#net636}
N 450 8310 460 8310 {lab=#net637}
N 530 8240 530 8270 {lab=A4}
N 530 8270 530 8320 {lab=A4}
N 440 8240 440 8320 {lab=#net17}
N 360 8310 450 8310 {lab=#net637}
N 350 8240 350 8320 {lab=A5}
N 270 8310 360 8310 {lab=#net637}
N 220 8270 260 8270 {lab=#net19}
N 220 8310 220 8320 {lab=VDD}
N 250 8310 270 8310 {lab=#net637}
N 180 8310 190 8310 {lab=#net638}
N 260 8240 260 8270 {lab=#net19}
N 260 8270 260 8320 {lab=#net19}
N 170 8240 170 8320 {lab=A6}
N 90 8310 180 8310 {lab=#net638}
N 40 8270 80 8270 {lab=#net20}
N 40 8310 40 8320 {lab=VDD}
N 70 8310 90 8310 {lab=#net638}
N 0 8310 10 8310 {lab=VDD}
N 80 8240 80 8270 {lab=#net20}
N 80 8270 80 8320 {lab=#net20}
N 0 8240 0 8320 { lab=VDD}
N 2570 8360 2580 8360 {lab=GND}
N 2580 8330 2580 8360 {lab=GND}
N 2570 8330 2580 8330 {lab=GND}
N 2530 8320 2530 8360 {lab=#net1}
N 2530 8360 2530 8400 {lab=#net1}
N 2520 8390 2570 8390 {lab=word104}
N 2570 8390 2610 8390 {lab=word104}
N 2440 8320 2440 8400 {lab=A6}
N 2430 8390 2520 8390 {lab=word104}
N 2390 8360 2400 8360 {lab=GND}
N 2400 8330 2400 8360 {lab=GND}
N 2390 8330 2400 8330 {lab=GND}
N 2350 8320 2350 8360 {lab=#net2}
N 2350 8360 2350 8400 {lab=#net2}
N 2340 8390 2390 8390 {lab=word104}
N 2390 8390 2430 8390 {lab=word104}
N 2260 8320 2260 8400 {lab=A5}
N 2250 8390 2340 8390 {lab=word104}
N 2170 8320 2170 8400 {lab=#net3}
N 2160 8390 2250 8390 {lab=word104}
N 2120 8360 2130 8360 {lab=GND}
N 2130 8330 2130 8360 {lab=GND}
N 2120 8330 2130 8330 {lab=GND}
N 2080 8320 2080 8360 {lab=A4}
N 2080 8360 2080 8400 {lab=A4}
N 2070 8390 2120 8390 {lab=word104}
N 2120 8390 2160 8390 {lab=word104}
N 2030 8360 2040 8360 {lab=GND}
N 2040 8330 2040 8360 {lab=GND}
N 2030 8330 2040 8330 {lab=GND}
N 1990 8320 1990 8360 {lab=#net4}
N 1990 8360 1990 8400 {lab=#net4}
N 1980 8390 2030 8390 {lab=word104}
N 2030 8390 2070 8390 {lab=word104}
N 1900 8320 1900 8400 {lab=A3}
N 1890 8390 1980 8390 {lab=word104}
N 1810 8320 1810 8400 {lab=#net5}
N 1800 8390 1890 8390 {lab=word104}
N 1760 8360 1770 8360 {lab=GND}
N 1770 8330 1770 8360 {lab=GND}
N 1760 8330 1770 8330 {lab=GND}
N 1720 8320 1720 8360 {lab=A2}
N 1720 8360 1720 8400 {lab=A2}
N 1710 8390 1760 8390 {lab=word104}
N 1760 8390 1800 8390 {lab=word104}
N 1630 8320 1630 8400 {lab=#net6}
N 1620 8390 1710 8390 {lab=word104}
N 1580 8360 1590 8360 {lab=GND}
N 1590 8330 1590 8360 {lab=GND}
N 1580 8330 1590 8330 {lab=GND}
N 1540 8320 1540 8360 {lab=A1}
N 1540 8360 1540 8400 {lab=A1}
N 1530 8390 1580 8390 {lab=word104}
N 1580 8390 1620 8390 {lab=word104}
N 1450 8320 1450 8400 {lab=#net7}
N 1440 8390 1530 8390 {lab=word104}
N 1400 8360 1410 8360 {lab=GND}
N 1410 8330 1410 8360 {lab=GND}
N 1400 8330 1410 8330 {lab=GND}
N 1360 8320 1360 8360 {lab=A0}
N 1360 8360 1360 8400 {lab=A0}
N 1350 8390 1400 8390 {lab=word104}
N 1400 8390 1440 8390 {lab=word104}
N 1260 8390 1350 8390 { lab=word104}
N 1210 8350 1250 8350 {lab=A0}
N 1210 8390 1210 8400 {lab=VDD}
N 1240 8390 1260 8390 {lab=word104}
N 1170 8390 1180 8390 {lab=#net639}
N 1250 8320 1250 8350 {lab=A0}
N 1250 8350 1250 8400 {lab=A0}
N 1160 8320 1160 8400 {lab=#net9}
N 1080 8390 1170 8390 {lab=#net639}
N 1030 8350 1070 8350 {lab=A1}
N 1030 8390 1030 8400 {lab=VDD}
N 1060 8390 1080 8390 {lab=#net639}
N 990 8390 1000 8390 {lab=#net640}
N 1070 8320 1070 8350 {lab=A1}
N 1070 8350 1070 8400 {lab=A1}
N 980 8320 980 8400 {lab=#net11}
N 900 8390 990 8390 {lab=#net640}
N 850 8350 890 8350 {lab=A2}
N 850 8390 850 8400 {lab=VDD}
N 880 8390 900 8390 {lab=#net640}
N 810 8390 820 8390 {lab=#net641}
N 890 8320 890 8350 {lab=A2}
N 890 8350 890 8400 {lab=A2}
N 800 8320 800 8400 {lab=#net13}
N 720 8390 810 8390 {lab=#net641}
N 710 8320 710 8400 {lab=A3}
N 630 8390 720 8390 {lab=#net641}
N 580 8350 620 8350 {lab=#net15}
N 580 8390 580 8400 {lab=VDD}
N 610 8390 630 8390 {lab=#net641}
N 540 8390 550 8390 {lab=#net642}
N 620 8320 620 8350 {lab=#net15}
N 620 8350 620 8400 {lab=#net15}
N 490 8350 530 8350 {lab=A4}
N 490 8390 490 8400 {lab=VDD}
N 520 8390 540 8390 {lab=#net642}
N 450 8390 460 8390 {lab=#net643}
N 530 8320 530 8350 {lab=A4}
N 530 8350 530 8400 {lab=A4}
N 440 8320 440 8400 {lab=#net17}
N 360 8390 450 8390 {lab=#net643}
N 350 8320 350 8400 {lab=A5}
N 270 8390 360 8390 {lab=#net643}
N 220 8350 260 8350 {lab=#net19}
N 220 8390 220 8400 {lab=VDD}
N 250 8390 270 8390 {lab=#net643}
N 180 8390 190 8390 {lab=#net644}
N 260 8320 260 8350 {lab=#net19}
N 260 8350 260 8400 {lab=#net19}
N 170 8320 170 8400 {lab=A6}
N 90 8390 180 8390 {lab=#net644}
N 40 8350 80 8350 {lab=#net20}
N 40 8390 40 8400 {lab=VDD}
N 70 8390 90 8390 {lab=#net644}
N 0 8390 10 8390 {lab=VDD}
N 80 8320 80 8350 {lab=#net20}
N 80 8350 80 8400 {lab=#net20}
N 0 8320 0 8400 { lab=VDD}
N 2570 8440 2580 8440 {lab=GND}
N 2580 8410 2580 8440 {lab=GND}
N 2570 8410 2580 8410 {lab=GND}
N 2530 8400 2530 8440 {lab=#net1}
N 2530 8440 2530 8480 {lab=#net1}
N 2520 8470 2570 8470 {lab=word105}
N 2570 8470 2610 8470 {lab=word105}
N 2440 8400 2440 8480 {lab=A6}
N 2430 8470 2520 8470 {lab=word105}
N 2390 8440 2400 8440 {lab=GND}
N 2400 8410 2400 8440 {lab=GND}
N 2390 8410 2400 8410 {lab=GND}
N 2350 8400 2350 8440 {lab=#net2}
N 2350 8440 2350 8480 {lab=#net2}
N 2340 8470 2390 8470 {lab=word105}
N 2390 8470 2430 8470 {lab=word105}
N 2260 8400 2260 8480 {lab=A5}
N 2250 8470 2340 8470 {lab=word105}
N 2170 8400 2170 8480 {lab=#net3}
N 2160 8470 2250 8470 {lab=word105}
N 2120 8440 2130 8440 {lab=GND}
N 2130 8410 2130 8440 {lab=GND}
N 2120 8410 2130 8410 {lab=GND}
N 2080 8400 2080 8440 {lab=A4}
N 2080 8440 2080 8480 {lab=A4}
N 2070 8470 2120 8470 {lab=word105}
N 2120 8470 2160 8470 {lab=word105}
N 2030 8440 2040 8440 {lab=GND}
N 2040 8410 2040 8440 {lab=GND}
N 2030 8410 2040 8410 {lab=GND}
N 1990 8400 1990 8440 {lab=#net4}
N 1990 8440 1990 8480 {lab=#net4}
N 1980 8470 2030 8470 {lab=word105}
N 2030 8470 2070 8470 {lab=word105}
N 1900 8400 1900 8480 {lab=A3}
N 1890 8470 1980 8470 {lab=word105}
N 1810 8400 1810 8480 {lab=#net5}
N 1800 8470 1890 8470 {lab=word105}
N 1760 8440 1770 8440 {lab=GND}
N 1770 8410 1770 8440 {lab=GND}
N 1760 8410 1770 8410 {lab=GND}
N 1720 8400 1720 8440 {lab=A2}
N 1720 8440 1720 8480 {lab=A2}
N 1710 8470 1760 8470 {lab=word105}
N 1760 8470 1800 8470 {lab=word105}
N 1630 8400 1630 8480 {lab=#net6}
N 1620 8470 1710 8470 {lab=word105}
N 1580 8440 1590 8440 {lab=GND}
N 1590 8410 1590 8440 {lab=GND}
N 1580 8410 1590 8410 {lab=GND}
N 1540 8400 1540 8440 {lab=A1}
N 1540 8440 1540 8480 {lab=A1}
N 1530 8470 1580 8470 {lab=word105}
N 1580 8470 1620 8470 {lab=word105}
N 1490 8440 1500 8440 {lab=GND}
N 1500 8410 1500 8440 {lab=GND}
N 1490 8410 1500 8410 {lab=GND}
N 1450 8400 1450 8440 {lab=#net7}
N 1450 8440 1450 8480 {lab=#net7}
N 1440 8470 1490 8470 {lab=word105}
N 1490 8470 1530 8470 {lab=word105}
N 1360 8400 1360 8480 {lab=A0}
N 1350 8470 1440 8470 {lab=word105}
N 1260 8470 1350 8470 { lab=word105}
N 1250 8400 1250 8480 {lab=A0}
N 1170 8470 1260 8470 {lab=word105}
N 1120 8430 1160 8430 {lab=#net9}
N 1120 8470 1120 8480 {lab=VDD}
N 1150 8470 1170 8470 {lab=word105}
N 1080 8470 1090 8470 {lab=#net645}
N 1160 8400 1160 8430 {lab=#net9}
N 1160 8430 1160 8480 {lab=#net9}
N 1030 8430 1070 8430 {lab=A1}
N 1030 8470 1030 8480 {lab=VDD}
N 1060 8470 1080 8470 {lab=#net645}
N 990 8470 1000 8470 {lab=#net646}
N 1070 8400 1070 8430 {lab=A1}
N 1070 8430 1070 8480 {lab=A1}
N 980 8400 980 8480 {lab=#net11}
N 900 8470 990 8470 {lab=#net646}
N 850 8430 890 8430 {lab=A2}
N 850 8470 850 8480 {lab=VDD}
N 880 8470 900 8470 {lab=#net646}
N 810 8470 820 8470 {lab=#net647}
N 890 8400 890 8430 {lab=A2}
N 890 8430 890 8480 {lab=A2}
N 800 8400 800 8480 {lab=#net13}
N 720 8470 810 8470 {lab=#net647}
N 710 8400 710 8480 {lab=A3}
N 630 8470 720 8470 {lab=#net647}
N 580 8430 620 8430 {lab=#net15}
N 580 8470 580 8480 {lab=VDD}
N 610 8470 630 8470 {lab=#net647}
N 540 8470 550 8470 {lab=#net648}
N 620 8400 620 8430 {lab=#net15}
N 620 8430 620 8480 {lab=#net15}
N 490 8430 530 8430 {lab=A4}
N 490 8470 490 8480 {lab=VDD}
N 520 8470 540 8470 {lab=#net648}
N 450 8470 460 8470 {lab=#net649}
N 530 8400 530 8430 {lab=A4}
N 530 8430 530 8480 {lab=A4}
N 440 8400 440 8480 {lab=#net17}
N 360 8470 450 8470 {lab=#net649}
N 350 8400 350 8480 {lab=A5}
N 270 8470 360 8470 {lab=#net649}
N 220 8430 260 8430 {lab=#net19}
N 220 8470 220 8480 {lab=VDD}
N 250 8470 270 8470 {lab=#net649}
N 180 8470 190 8470 {lab=#net650}
N 260 8400 260 8430 {lab=#net19}
N 260 8430 260 8480 {lab=#net19}
N 170 8400 170 8480 {lab=A6}
N 90 8470 180 8470 {lab=#net650}
N 40 8430 80 8430 {lab=#net20}
N 40 8470 40 8480 {lab=VDD}
N 70 8470 90 8470 {lab=#net650}
N 0 8470 10 8470 {lab=VDD}
N 80 8400 80 8430 {lab=#net20}
N 80 8430 80 8480 {lab=#net20}
N 0 8400 0 8480 { lab=VDD}
N 2570 8520 2580 8520 {lab=GND}
N 2580 8490 2580 8520 {lab=GND}
N 2570 8490 2580 8490 {lab=GND}
N 2530 8480 2530 8520 {lab=#net1}
N 2530 8520 2530 8560 {lab=#net1}
N 2520 8550 2570 8550 {lab=word106}
N 2570 8550 2610 8550 {lab=word106}
N 2440 8480 2440 8560 {lab=A6}
N 2430 8550 2520 8550 {lab=word106}
N 2390 8520 2400 8520 {lab=GND}
N 2400 8490 2400 8520 {lab=GND}
N 2390 8490 2400 8490 {lab=GND}
N 2350 8480 2350 8520 {lab=#net2}
N 2350 8520 2350 8560 {lab=#net2}
N 2340 8550 2390 8550 {lab=word106}
N 2390 8550 2430 8550 {lab=word106}
N 2260 8480 2260 8560 {lab=A5}
N 2250 8550 2340 8550 {lab=word106}
N 2170 8480 2170 8560 {lab=#net3}
N 2160 8550 2250 8550 {lab=word106}
N 2120 8520 2130 8520 {lab=GND}
N 2130 8490 2130 8520 {lab=GND}
N 2120 8490 2130 8490 {lab=GND}
N 2080 8480 2080 8520 {lab=A4}
N 2080 8520 2080 8560 {lab=A4}
N 2070 8550 2120 8550 {lab=word106}
N 2120 8550 2160 8550 {lab=word106}
N 2030 8520 2040 8520 {lab=GND}
N 2040 8490 2040 8520 {lab=GND}
N 2030 8490 2040 8490 {lab=GND}
N 1990 8480 1990 8520 {lab=#net4}
N 1990 8520 1990 8560 {lab=#net4}
N 1980 8550 2030 8550 {lab=word106}
N 2030 8550 2070 8550 {lab=word106}
N 1900 8480 1900 8560 {lab=A3}
N 1890 8550 1980 8550 {lab=word106}
N 1810 8480 1810 8560 {lab=#net5}
N 1800 8550 1890 8550 {lab=word106}
N 1760 8520 1770 8520 {lab=GND}
N 1770 8490 1770 8520 {lab=GND}
N 1760 8490 1770 8490 {lab=GND}
N 1720 8480 1720 8520 {lab=A2}
N 1720 8520 1720 8560 {lab=A2}
N 1710 8550 1760 8550 {lab=word106}
N 1760 8550 1800 8550 {lab=word106}
N 1670 8520 1680 8520 {lab=GND}
N 1680 8490 1680 8520 {lab=GND}
N 1670 8490 1680 8490 {lab=GND}
N 1630 8480 1630 8520 {lab=#net6}
N 1630 8520 1630 8560 {lab=#net6}
N 1620 8550 1670 8550 {lab=word106}
N 1670 8550 1710 8550 {lab=word106}
N 1540 8480 1540 8560 {lab=A1}
N 1530 8550 1620 8550 {lab=word106}
N 1450 8480 1450 8560 {lab=#net7}
N 1440 8550 1530 8550 {lab=word106}
N 1400 8520 1410 8520 {lab=GND}
N 1410 8490 1410 8520 {lab=GND}
N 1400 8490 1410 8490 {lab=GND}
N 1360 8480 1360 8520 {lab=A0}
N 1360 8520 1360 8560 {lab=A0}
N 1350 8550 1400 8550 {lab=word106}
N 1400 8550 1440 8550 {lab=word106}
N 1260 8550 1350 8550 { lab=word106}
N 1210 8510 1250 8510 {lab=A0}
N 1210 8550 1210 8560 {lab=VDD}
N 1240 8550 1260 8550 {lab=word106}
N 1170 8550 1180 8550 {lab=#net651}
N 1250 8480 1250 8510 {lab=A0}
N 1250 8510 1250 8560 {lab=A0}
N 1160 8480 1160 8560 {lab=#net9}
N 1080 8550 1170 8550 {lab=#net651}
N 1070 8480 1070 8560 {lab=A1}
N 990 8550 1080 8550 {lab=#net651}
N 940 8510 980 8510 {lab=#net11}
N 940 8550 940 8560 {lab=VDD}
N 970 8550 990 8550 {lab=#net651}
N 900 8550 910 8550 {lab=#net652}
N 980 8480 980 8510 {lab=#net11}
N 980 8510 980 8560 {lab=#net11}
N 850 8510 890 8510 {lab=A2}
N 850 8550 850 8560 {lab=VDD}
N 880 8550 900 8550 {lab=#net652}
N 810 8550 820 8550 {lab=#net653}
N 890 8480 890 8510 {lab=A2}
N 890 8510 890 8560 {lab=A2}
N 800 8480 800 8560 {lab=#net13}
N 720 8550 810 8550 {lab=#net653}
N 710 8480 710 8560 {lab=A3}
N 630 8550 720 8550 {lab=#net653}
N 580 8510 620 8510 {lab=#net15}
N 580 8550 580 8560 {lab=VDD}
N 610 8550 630 8550 {lab=#net653}
N 540 8550 550 8550 {lab=#net654}
N 620 8480 620 8510 {lab=#net15}
N 620 8510 620 8560 {lab=#net15}
N 490 8510 530 8510 {lab=A4}
N 490 8550 490 8560 {lab=VDD}
N 520 8550 540 8550 {lab=#net654}
N 450 8550 460 8550 {lab=#net655}
N 530 8480 530 8510 {lab=A4}
N 530 8510 530 8560 {lab=A4}
N 440 8480 440 8560 {lab=#net17}
N 360 8550 450 8550 {lab=#net655}
N 350 8480 350 8560 {lab=A5}
N 270 8550 360 8550 {lab=#net655}
N 220 8510 260 8510 {lab=#net19}
N 220 8550 220 8560 {lab=VDD}
N 250 8550 270 8550 {lab=#net655}
N 180 8550 190 8550 {lab=#net656}
N 260 8480 260 8510 {lab=#net19}
N 260 8510 260 8560 {lab=#net19}
N 170 8480 170 8560 {lab=A6}
N 90 8550 180 8550 {lab=#net656}
N 40 8510 80 8510 {lab=#net20}
N 40 8550 40 8560 {lab=VDD}
N 70 8550 90 8550 {lab=#net656}
N 0 8550 10 8550 {lab=VDD}
N 80 8480 80 8510 {lab=#net20}
N 80 8510 80 8560 {lab=#net20}
N 0 8480 0 8560 { lab=VDD}
N 2570 8600 2580 8600 {lab=GND}
N 2580 8570 2580 8600 {lab=GND}
N 2570 8570 2580 8570 {lab=GND}
N 2530 8560 2530 8600 {lab=#net1}
N 2530 8600 2530 8640 {lab=#net1}
N 2520 8630 2570 8630 {lab=word107}
N 2570 8630 2610 8630 {lab=word107}
N 2440 8560 2440 8640 {lab=A6}
N 2430 8630 2520 8630 {lab=word107}
N 2390 8600 2400 8600 {lab=GND}
N 2400 8570 2400 8600 {lab=GND}
N 2390 8570 2400 8570 {lab=GND}
N 2350 8560 2350 8600 {lab=#net2}
N 2350 8600 2350 8640 {lab=#net2}
N 2340 8630 2390 8630 {lab=word107}
N 2390 8630 2430 8630 {lab=word107}
N 2260 8560 2260 8640 {lab=A5}
N 2250 8630 2340 8630 {lab=word107}
N 2170 8560 2170 8640 {lab=#net3}
N 2160 8630 2250 8630 {lab=word107}
N 2120 8600 2130 8600 {lab=GND}
N 2130 8570 2130 8600 {lab=GND}
N 2120 8570 2130 8570 {lab=GND}
N 2080 8560 2080 8600 {lab=A4}
N 2080 8600 2080 8640 {lab=A4}
N 2070 8630 2120 8630 {lab=word107}
N 2120 8630 2160 8630 {lab=word107}
N 2030 8600 2040 8600 {lab=GND}
N 2040 8570 2040 8600 {lab=GND}
N 2030 8570 2040 8570 {lab=GND}
N 1990 8560 1990 8600 {lab=#net4}
N 1990 8600 1990 8640 {lab=#net4}
N 1980 8630 2030 8630 {lab=word107}
N 2030 8630 2070 8630 {lab=word107}
N 1900 8560 1900 8640 {lab=A3}
N 1890 8630 1980 8630 {lab=word107}
N 1810 8560 1810 8640 {lab=#net5}
N 1800 8630 1890 8630 {lab=word107}
N 1760 8600 1770 8600 {lab=GND}
N 1770 8570 1770 8600 {lab=GND}
N 1760 8570 1770 8570 {lab=GND}
N 1720 8560 1720 8600 {lab=A2}
N 1720 8600 1720 8640 {lab=A2}
N 1710 8630 1760 8630 {lab=word107}
N 1760 8630 1800 8630 {lab=word107}
N 1670 8600 1680 8600 {lab=GND}
N 1680 8570 1680 8600 {lab=GND}
N 1670 8570 1680 8570 {lab=GND}
N 1630 8560 1630 8600 {lab=#net6}
N 1630 8600 1630 8640 {lab=#net6}
N 1620 8630 1670 8630 {lab=word107}
N 1670 8630 1710 8630 {lab=word107}
N 1540 8560 1540 8640 {lab=A1}
N 1530 8630 1620 8630 {lab=word107}
N 1490 8600 1500 8600 {lab=GND}
N 1500 8570 1500 8600 {lab=GND}
N 1490 8570 1500 8570 {lab=GND}
N 1450 8560 1450 8600 {lab=#net7}
N 1450 8600 1450 8640 {lab=#net7}
N 1440 8630 1490 8630 {lab=word107}
N 1490 8630 1530 8630 {lab=word107}
N 1360 8560 1360 8640 {lab=A0}
N 1350 8630 1440 8630 {lab=word107}
N 1260 8630 1350 8630 { lab=word107}
N 1250 8560 1250 8640 {lab=A0}
N 1170 8630 1260 8630 {lab=word107}
N 1120 8590 1160 8590 {lab=#net9}
N 1120 8630 1120 8640 {lab=VDD}
N 1150 8630 1170 8630 {lab=word107}
N 1080 8630 1090 8630 {lab=#net657}
N 1160 8560 1160 8590 {lab=#net9}
N 1160 8590 1160 8640 {lab=#net9}
N 1070 8560 1070 8640 {lab=A1}
N 990 8630 1080 8630 {lab=#net657}
N 940 8590 980 8590 {lab=#net11}
N 940 8630 940 8640 {lab=VDD}
N 970 8630 990 8630 {lab=#net657}
N 900 8630 910 8630 {lab=#net658}
N 980 8560 980 8590 {lab=#net11}
N 980 8590 980 8640 {lab=#net11}
N 850 8590 890 8590 {lab=A2}
N 850 8630 850 8640 {lab=VDD}
N 880 8630 900 8630 {lab=#net658}
N 810 8630 820 8630 {lab=#net659}
N 890 8560 890 8590 {lab=A2}
N 890 8590 890 8640 {lab=A2}
N 800 8560 800 8640 {lab=#net13}
N 720 8630 810 8630 {lab=#net659}
N 710 8560 710 8640 {lab=A3}
N 630 8630 720 8630 {lab=#net659}
N 580 8590 620 8590 {lab=#net15}
N 580 8630 580 8640 {lab=VDD}
N 610 8630 630 8630 {lab=#net659}
N 540 8630 550 8630 {lab=#net660}
N 620 8560 620 8590 {lab=#net15}
N 620 8590 620 8640 {lab=#net15}
N 490 8590 530 8590 {lab=A4}
N 490 8630 490 8640 {lab=VDD}
N 520 8630 540 8630 {lab=#net660}
N 450 8630 460 8630 {lab=#net661}
N 530 8560 530 8590 {lab=A4}
N 530 8590 530 8640 {lab=A4}
N 440 8560 440 8640 {lab=#net17}
N 360 8630 450 8630 {lab=#net661}
N 350 8560 350 8640 {lab=A5}
N 270 8630 360 8630 {lab=#net661}
N 220 8590 260 8590 {lab=#net19}
N 220 8630 220 8640 {lab=VDD}
N 250 8630 270 8630 {lab=#net661}
N 180 8630 190 8630 {lab=#net662}
N 260 8560 260 8590 {lab=#net19}
N 260 8590 260 8640 {lab=#net19}
N 170 8560 170 8640 {lab=A6}
N 90 8630 180 8630 {lab=#net662}
N 40 8590 80 8590 {lab=#net20}
N 40 8630 40 8640 {lab=VDD}
N 70 8630 90 8630 {lab=#net662}
N 0 8630 10 8630 {lab=VDD}
N 80 8560 80 8590 {lab=#net20}
N 80 8590 80 8640 {lab=#net20}
N 0 8560 0 8640 { lab=VDD}
N 2570 8680 2580 8680 {lab=GND}
N 2580 8650 2580 8680 {lab=GND}
N 2570 8650 2580 8650 {lab=GND}
N 2530 8640 2530 8680 {lab=#net1}
N 2530 8680 2530 8720 {lab=#net1}
N 2520 8710 2570 8710 {lab=word108}
N 2570 8710 2610 8710 {lab=word108}
N 2440 8640 2440 8720 {lab=A6}
N 2430 8710 2520 8710 {lab=word108}
N 2390 8680 2400 8680 {lab=GND}
N 2400 8650 2400 8680 {lab=GND}
N 2390 8650 2400 8650 {lab=GND}
N 2350 8640 2350 8680 {lab=#net2}
N 2350 8680 2350 8720 {lab=#net2}
N 2340 8710 2390 8710 {lab=word108}
N 2390 8710 2430 8710 {lab=word108}
N 2260 8640 2260 8720 {lab=A5}
N 2250 8710 2340 8710 {lab=word108}
N 2170 8640 2170 8720 {lab=#net3}
N 2160 8710 2250 8710 {lab=word108}
N 2120 8680 2130 8680 {lab=GND}
N 2130 8650 2130 8680 {lab=GND}
N 2120 8650 2130 8650 {lab=GND}
N 2080 8640 2080 8680 {lab=A4}
N 2080 8680 2080 8720 {lab=A4}
N 2070 8710 2120 8710 {lab=word108}
N 2120 8710 2160 8710 {lab=word108}
N 2030 8680 2040 8680 {lab=GND}
N 2040 8650 2040 8680 {lab=GND}
N 2030 8650 2040 8650 {lab=GND}
N 1990 8640 1990 8680 {lab=#net4}
N 1990 8680 1990 8720 {lab=#net4}
N 1980 8710 2030 8710 {lab=word108}
N 2030 8710 2070 8710 {lab=word108}
N 1900 8640 1900 8720 {lab=A3}
N 1890 8710 1980 8710 {lab=word108}
N 1850 8680 1860 8680 {lab=GND}
N 1860 8650 1860 8680 {lab=GND}
N 1850 8650 1860 8650 {lab=GND}
N 1810 8640 1810 8680 {lab=#net5}
N 1810 8680 1810 8720 {lab=#net5}
N 1800 8710 1850 8710 {lab=word108}
N 1850 8710 1890 8710 {lab=word108}
N 1720 8640 1720 8720 {lab=A2}
N 1710 8710 1800 8710 {lab=word108}
N 1630 8640 1630 8720 {lab=#net6}
N 1620 8710 1710 8710 {lab=word108}
N 1580 8680 1590 8680 {lab=GND}
N 1590 8650 1590 8680 {lab=GND}
N 1580 8650 1590 8650 {lab=GND}
N 1540 8640 1540 8680 {lab=A1}
N 1540 8680 1540 8720 {lab=A1}
N 1530 8710 1580 8710 {lab=word108}
N 1580 8710 1620 8710 {lab=word108}
N 1450 8640 1450 8720 {lab=#net7}
N 1440 8710 1530 8710 {lab=word108}
N 1400 8680 1410 8680 {lab=GND}
N 1410 8650 1410 8680 {lab=GND}
N 1400 8650 1410 8650 {lab=GND}
N 1360 8640 1360 8680 {lab=A0}
N 1360 8680 1360 8720 {lab=A0}
N 1350 8710 1400 8710 {lab=word108}
N 1400 8710 1440 8710 {lab=word108}
N 1260 8710 1350 8710 { lab=word108}
N 1210 8670 1250 8670 {lab=A0}
N 1210 8710 1210 8720 {lab=VDD}
N 1240 8710 1260 8710 {lab=word108}
N 1170 8710 1180 8710 {lab=#net663}
N 1250 8640 1250 8670 {lab=A0}
N 1250 8670 1250 8720 {lab=A0}
N 1160 8640 1160 8720 {lab=#net9}
N 1080 8710 1170 8710 {lab=#net663}
N 1030 8670 1070 8670 {lab=A1}
N 1030 8710 1030 8720 {lab=VDD}
N 1060 8710 1080 8710 {lab=#net663}
N 990 8710 1000 8710 {lab=#net664}
N 1070 8640 1070 8670 {lab=A1}
N 1070 8670 1070 8720 {lab=A1}
N 980 8640 980 8720 {lab=#net11}
N 900 8710 990 8710 {lab=#net664}
N 890 8640 890 8720 {lab=A2}
N 810 8710 900 8710 {lab=#net664}
N 760 8670 800 8670 {lab=#net13}
N 760 8710 760 8720 {lab=VDD}
N 790 8710 810 8710 {lab=#net664}
N 720 8710 730 8710 {lab=#net665}
N 800 8640 800 8670 {lab=#net13}
N 800 8670 800 8720 {lab=#net13}
N 710 8640 710 8720 {lab=A3}
N 630 8710 720 8710 {lab=#net665}
N 580 8670 620 8670 {lab=#net15}
N 580 8710 580 8720 {lab=VDD}
N 610 8710 630 8710 {lab=#net665}
N 540 8710 550 8710 {lab=#net666}
N 620 8640 620 8670 {lab=#net15}
N 620 8670 620 8720 {lab=#net15}
N 490 8670 530 8670 {lab=A4}
N 490 8710 490 8720 {lab=VDD}
N 520 8710 540 8710 {lab=#net666}
N 450 8710 460 8710 {lab=#net667}
N 530 8640 530 8670 {lab=A4}
N 530 8670 530 8720 {lab=A4}
N 440 8640 440 8720 {lab=#net17}
N 360 8710 450 8710 {lab=#net667}
N 350 8640 350 8720 {lab=A5}
N 270 8710 360 8710 {lab=#net667}
N 220 8670 260 8670 {lab=#net19}
N 220 8710 220 8720 {lab=VDD}
N 250 8710 270 8710 {lab=#net667}
N 180 8710 190 8710 {lab=#net668}
N 260 8640 260 8670 {lab=#net19}
N 260 8670 260 8720 {lab=#net19}
N 170 8640 170 8720 {lab=A6}
N 90 8710 180 8710 {lab=#net668}
N 40 8670 80 8670 {lab=#net20}
N 40 8710 40 8720 {lab=VDD}
N 70 8710 90 8710 {lab=#net668}
N 0 8710 10 8710 {lab=VDD}
N 80 8640 80 8670 {lab=#net20}
N 80 8670 80 8720 {lab=#net20}
N 0 8640 0 8720 { lab=VDD}
N 2570 8760 2580 8760 {lab=GND}
N 2580 8730 2580 8760 {lab=GND}
N 2570 8730 2580 8730 {lab=GND}
N 2530 8720 2530 8760 {lab=#net1}
N 2530 8760 2530 8800 {lab=#net1}
N 2520 8790 2570 8790 {lab=word109}
N 2570 8790 2610 8790 {lab=word109}
N 2440 8720 2440 8800 {lab=A6}
N 2430 8790 2520 8790 {lab=word109}
N 2390 8760 2400 8760 {lab=GND}
N 2400 8730 2400 8760 {lab=GND}
N 2390 8730 2400 8730 {lab=GND}
N 2350 8720 2350 8760 {lab=#net2}
N 2350 8760 2350 8800 {lab=#net2}
N 2340 8790 2390 8790 {lab=word109}
N 2390 8790 2430 8790 {lab=word109}
N 2260 8720 2260 8800 {lab=A5}
N 2250 8790 2340 8790 {lab=word109}
N 2170 8720 2170 8800 {lab=#net3}
N 2160 8790 2250 8790 {lab=word109}
N 2120 8760 2130 8760 {lab=GND}
N 2130 8730 2130 8760 {lab=GND}
N 2120 8730 2130 8730 {lab=GND}
N 2080 8720 2080 8760 {lab=A4}
N 2080 8760 2080 8800 {lab=A4}
N 2070 8790 2120 8790 {lab=word109}
N 2120 8790 2160 8790 {lab=word109}
N 2030 8760 2040 8760 {lab=GND}
N 2040 8730 2040 8760 {lab=GND}
N 2030 8730 2040 8730 {lab=GND}
N 1990 8720 1990 8760 {lab=#net4}
N 1990 8760 1990 8800 {lab=#net4}
N 1980 8790 2030 8790 {lab=word109}
N 2030 8790 2070 8790 {lab=word109}
N 1900 8720 1900 8800 {lab=A3}
N 1890 8790 1980 8790 {lab=word109}
N 1850 8760 1860 8760 {lab=GND}
N 1860 8730 1860 8760 {lab=GND}
N 1850 8730 1860 8730 {lab=GND}
N 1810 8720 1810 8760 {lab=#net5}
N 1810 8760 1810 8800 {lab=#net5}
N 1800 8790 1850 8790 {lab=word109}
N 1850 8790 1890 8790 {lab=word109}
N 1720 8720 1720 8800 {lab=A2}
N 1710 8790 1800 8790 {lab=word109}
N 1630 8720 1630 8800 {lab=#net6}
N 1620 8790 1710 8790 {lab=word109}
N 1580 8760 1590 8760 {lab=GND}
N 1590 8730 1590 8760 {lab=GND}
N 1580 8730 1590 8730 {lab=GND}
N 1540 8720 1540 8760 {lab=A1}
N 1540 8760 1540 8800 {lab=A1}
N 1530 8790 1580 8790 {lab=word109}
N 1580 8790 1620 8790 {lab=word109}
N 1490 8760 1500 8760 {lab=GND}
N 1500 8730 1500 8760 {lab=GND}
N 1490 8730 1500 8730 {lab=GND}
N 1450 8720 1450 8760 {lab=#net7}
N 1450 8760 1450 8800 {lab=#net7}
N 1440 8790 1490 8790 {lab=word109}
N 1490 8790 1530 8790 {lab=word109}
N 1360 8720 1360 8800 {lab=A0}
N 1350 8790 1440 8790 {lab=word109}
N 1260 8790 1350 8790 { lab=word109}
N 1250 8720 1250 8800 {lab=A0}
N 1170 8790 1260 8790 {lab=word109}
N 1120 8750 1160 8750 {lab=#net9}
N 1120 8790 1120 8800 {lab=VDD}
N 1150 8790 1170 8790 {lab=word109}
N 1080 8790 1090 8790 {lab=#net669}
N 1160 8720 1160 8750 {lab=#net9}
N 1160 8750 1160 8800 {lab=#net9}
N 1030 8750 1070 8750 {lab=A1}
N 1030 8790 1030 8800 {lab=VDD}
N 1060 8790 1080 8790 {lab=#net669}
N 990 8790 1000 8790 {lab=#net670}
N 1070 8720 1070 8750 {lab=A1}
N 1070 8750 1070 8800 {lab=A1}
N 980 8720 980 8800 {lab=#net11}
N 900 8790 990 8790 {lab=#net670}
N 890 8720 890 8800 {lab=A2}
N 810 8790 900 8790 {lab=#net670}
N 760 8750 800 8750 {lab=#net13}
N 760 8790 760 8800 {lab=VDD}
N 790 8790 810 8790 {lab=#net670}
N 720 8790 730 8790 {lab=#net671}
N 800 8720 800 8750 {lab=#net13}
N 800 8750 800 8800 {lab=#net13}
N 710 8720 710 8800 {lab=A3}
N 630 8790 720 8790 {lab=#net671}
N 580 8750 620 8750 {lab=#net15}
N 580 8790 580 8800 {lab=VDD}
N 610 8790 630 8790 {lab=#net671}
N 540 8790 550 8790 {lab=#net672}
N 620 8720 620 8750 {lab=#net15}
N 620 8750 620 8800 {lab=#net15}
N 490 8750 530 8750 {lab=A4}
N 490 8790 490 8800 {lab=VDD}
N 520 8790 540 8790 {lab=#net672}
N 450 8790 460 8790 {lab=#net673}
N 530 8720 530 8750 {lab=A4}
N 530 8750 530 8800 {lab=A4}
N 440 8720 440 8800 {lab=#net17}
N 360 8790 450 8790 {lab=#net673}
N 350 8720 350 8800 {lab=A5}
N 270 8790 360 8790 {lab=#net673}
N 220 8750 260 8750 {lab=#net19}
N 220 8790 220 8800 {lab=VDD}
N 250 8790 270 8790 {lab=#net673}
N 180 8790 190 8790 {lab=#net674}
N 260 8720 260 8750 {lab=#net19}
N 260 8750 260 8800 {lab=#net19}
N 170 8720 170 8800 {lab=A6}
N 90 8790 180 8790 {lab=#net674}
N 40 8750 80 8750 {lab=#net20}
N 40 8790 40 8800 {lab=VDD}
N 70 8790 90 8790 {lab=#net674}
N 0 8790 10 8790 {lab=VDD}
N 80 8720 80 8750 {lab=#net20}
N 80 8750 80 8800 {lab=#net20}
N 0 8720 0 8800 { lab=VDD}
N 2570 8840 2580 8840 {lab=GND}
N 2580 8810 2580 8840 {lab=GND}
N 2570 8810 2580 8810 {lab=GND}
N 2530 8800 2530 8840 {lab=#net1}
N 2530 8840 2530 8880 {lab=#net1}
N 2520 8870 2570 8870 {lab=word110}
N 2570 8870 2610 8870 {lab=word110}
N 2440 8800 2440 8880 {lab=A6}
N 2430 8870 2520 8870 {lab=word110}
N 2390 8840 2400 8840 {lab=GND}
N 2400 8810 2400 8840 {lab=GND}
N 2390 8810 2400 8810 {lab=GND}
N 2350 8800 2350 8840 {lab=#net2}
N 2350 8840 2350 8880 {lab=#net2}
N 2340 8870 2390 8870 {lab=word110}
N 2390 8870 2430 8870 {lab=word110}
N 2260 8800 2260 8880 {lab=A5}
N 2250 8870 2340 8870 {lab=word110}
N 2170 8800 2170 8880 {lab=#net3}
N 2160 8870 2250 8870 {lab=word110}
N 2120 8840 2130 8840 {lab=GND}
N 2130 8810 2130 8840 {lab=GND}
N 2120 8810 2130 8810 {lab=GND}
N 2080 8800 2080 8840 {lab=A4}
N 2080 8840 2080 8880 {lab=A4}
N 2070 8870 2120 8870 {lab=word110}
N 2120 8870 2160 8870 {lab=word110}
N 2030 8840 2040 8840 {lab=GND}
N 2040 8810 2040 8840 {lab=GND}
N 2030 8810 2040 8810 {lab=GND}
N 1990 8800 1990 8840 {lab=#net4}
N 1990 8840 1990 8880 {lab=#net4}
N 1980 8870 2030 8870 {lab=word110}
N 2030 8870 2070 8870 {lab=word110}
N 1900 8800 1900 8880 {lab=A3}
N 1890 8870 1980 8870 {lab=word110}
N 1850 8840 1860 8840 {lab=GND}
N 1860 8810 1860 8840 {lab=GND}
N 1850 8810 1860 8810 {lab=GND}
N 1810 8800 1810 8840 {lab=#net5}
N 1810 8840 1810 8880 {lab=#net5}
N 1800 8870 1850 8870 {lab=word110}
N 1850 8870 1890 8870 {lab=word110}
N 1720 8800 1720 8880 {lab=A2}
N 1710 8870 1800 8870 {lab=word110}
N 1670 8840 1680 8840 {lab=GND}
N 1680 8810 1680 8840 {lab=GND}
N 1670 8810 1680 8810 {lab=GND}
N 1630 8800 1630 8840 {lab=#net6}
N 1630 8840 1630 8880 {lab=#net6}
N 1620 8870 1670 8870 {lab=word110}
N 1670 8870 1710 8870 {lab=word110}
N 1540 8800 1540 8880 {lab=A1}
N 1530 8870 1620 8870 {lab=word110}
N 1450 8800 1450 8880 {lab=#net7}
N 1440 8870 1530 8870 {lab=word110}
N 1400 8840 1410 8840 {lab=GND}
N 1410 8810 1410 8840 {lab=GND}
N 1400 8810 1410 8810 {lab=GND}
N 1360 8800 1360 8840 {lab=A0}
N 1360 8840 1360 8880 {lab=A0}
N 1350 8870 1400 8870 {lab=word110}
N 1400 8870 1440 8870 {lab=word110}
N 1260 8870 1350 8870 { lab=word110}
N 1210 8830 1250 8830 {lab=A0}
N 1210 8870 1210 8880 {lab=VDD}
N 1240 8870 1260 8870 {lab=word110}
N 1170 8870 1180 8870 {lab=#net675}
N 1250 8800 1250 8830 {lab=A0}
N 1250 8830 1250 8880 {lab=A0}
N 1160 8800 1160 8880 {lab=#net9}
N 1080 8870 1170 8870 {lab=#net675}
N 1070 8800 1070 8880 {lab=A1}
N 990 8870 1080 8870 {lab=#net675}
N 940 8830 980 8830 {lab=#net11}
N 940 8870 940 8880 {lab=VDD}
N 970 8870 990 8870 {lab=#net675}
N 900 8870 910 8870 {lab=#net676}
N 980 8800 980 8830 {lab=#net11}
N 980 8830 980 8880 {lab=#net11}
N 890 8800 890 8880 {lab=A2}
N 810 8870 900 8870 {lab=#net676}
N 760 8830 800 8830 {lab=#net13}
N 760 8870 760 8880 {lab=VDD}
N 790 8870 810 8870 {lab=#net676}
N 720 8870 730 8870 {lab=#net677}
N 800 8800 800 8830 {lab=#net13}
N 800 8830 800 8880 {lab=#net13}
N 710 8800 710 8880 {lab=A3}
N 630 8870 720 8870 {lab=#net677}
N 580 8830 620 8830 {lab=#net15}
N 580 8870 580 8880 {lab=VDD}
N 610 8870 630 8870 {lab=#net677}
N 540 8870 550 8870 {lab=#net678}
N 620 8800 620 8830 {lab=#net15}
N 620 8830 620 8880 {lab=#net15}
N 490 8830 530 8830 {lab=A4}
N 490 8870 490 8880 {lab=VDD}
N 520 8870 540 8870 {lab=#net678}
N 450 8870 460 8870 {lab=#net679}
N 530 8800 530 8830 {lab=A4}
N 530 8830 530 8880 {lab=A4}
N 440 8800 440 8880 {lab=#net17}
N 360 8870 450 8870 {lab=#net679}
N 350 8800 350 8880 {lab=A5}
N 270 8870 360 8870 {lab=#net679}
N 220 8830 260 8830 {lab=#net19}
N 220 8870 220 8880 {lab=VDD}
N 250 8870 270 8870 {lab=#net679}
N 180 8870 190 8870 {lab=#net680}
N 260 8800 260 8830 {lab=#net19}
N 260 8830 260 8880 {lab=#net19}
N 170 8800 170 8880 {lab=A6}
N 90 8870 180 8870 {lab=#net680}
N 40 8830 80 8830 {lab=#net20}
N 40 8870 40 8880 {lab=VDD}
N 70 8870 90 8870 {lab=#net680}
N 0 8870 10 8870 {lab=VDD}
N 80 8800 80 8830 {lab=#net20}
N 80 8830 80 8880 {lab=#net20}
N 0 8800 0 8880 { lab=VDD}
N 2570 8920 2580 8920 {lab=GND}
N 2580 8890 2580 8920 {lab=GND}
N 2570 8890 2580 8890 {lab=GND}
N 2530 8880 2530 8920 {lab=#net1}
N 2530 8920 2530 8960 {lab=#net1}
N 2520 8950 2570 8950 {lab=word111}
N 2570 8950 2610 8950 {lab=word111}
N 2440 8880 2440 8960 {lab=A6}
N 2430 8950 2520 8950 {lab=word111}
N 2390 8920 2400 8920 {lab=GND}
N 2400 8890 2400 8920 {lab=GND}
N 2390 8890 2400 8890 {lab=GND}
N 2350 8880 2350 8920 {lab=#net2}
N 2350 8920 2350 8960 {lab=#net2}
N 2340 8950 2390 8950 {lab=word111}
N 2390 8950 2430 8950 {lab=word111}
N 2260 8880 2260 8960 {lab=A5}
N 2250 8950 2340 8950 {lab=word111}
N 2170 8880 2170 8960 {lab=#net3}
N 2160 8950 2250 8950 {lab=word111}
N 2120 8920 2130 8920 {lab=GND}
N 2130 8890 2130 8920 {lab=GND}
N 2120 8890 2130 8890 {lab=GND}
N 2080 8880 2080 8920 {lab=A4}
N 2080 8920 2080 8960 {lab=A4}
N 2070 8950 2120 8950 {lab=word111}
N 2120 8950 2160 8950 {lab=word111}
N 2030 8920 2040 8920 {lab=GND}
N 2040 8890 2040 8920 {lab=GND}
N 2030 8890 2040 8890 {lab=GND}
N 1990 8880 1990 8920 {lab=#net4}
N 1990 8920 1990 8960 {lab=#net4}
N 1980 8950 2030 8950 {lab=word111}
N 2030 8950 2070 8950 {lab=word111}
N 1900 8880 1900 8960 {lab=A3}
N 1890 8950 1980 8950 {lab=word111}
N 1850 8920 1860 8920 {lab=GND}
N 1860 8890 1860 8920 {lab=GND}
N 1850 8890 1860 8890 {lab=GND}
N 1810 8880 1810 8920 {lab=#net5}
N 1810 8920 1810 8960 {lab=#net5}
N 1800 8950 1850 8950 {lab=word111}
N 1850 8950 1890 8950 {lab=word111}
N 1720 8880 1720 8960 {lab=A2}
N 1710 8950 1800 8950 {lab=word111}
N 1670 8920 1680 8920 {lab=GND}
N 1680 8890 1680 8920 {lab=GND}
N 1670 8890 1680 8890 {lab=GND}
N 1630 8880 1630 8920 {lab=#net6}
N 1630 8920 1630 8960 {lab=#net6}
N 1620 8950 1670 8950 {lab=word111}
N 1670 8950 1710 8950 {lab=word111}
N 1540 8880 1540 8960 {lab=A1}
N 1530 8950 1620 8950 {lab=word111}
N 1490 8920 1500 8920 {lab=GND}
N 1500 8890 1500 8920 {lab=GND}
N 1490 8890 1500 8890 {lab=GND}
N 1450 8880 1450 8920 {lab=#net7}
N 1450 8920 1450 8960 {lab=#net7}
N 1440 8950 1490 8950 {lab=word111}
N 1490 8950 1530 8950 {lab=word111}
N 1360 8880 1360 8960 {lab=A0}
N 1350 8950 1440 8950 {lab=word111}
N 1260 8950 1350 8950 { lab=word111}
N 1250 8880 1250 8960 {lab=A0}
N 1170 8950 1260 8950 {lab=word111}
N 1120 8910 1160 8910 {lab=#net9}
N 1120 8950 1120 8960 {lab=VDD}
N 1150 8950 1170 8950 {lab=word111}
N 1080 8950 1090 8950 {lab=#net681}
N 1160 8880 1160 8910 {lab=#net9}
N 1160 8910 1160 8960 {lab=#net9}
N 1070 8880 1070 8960 {lab=A1}
N 990 8950 1080 8950 {lab=#net681}
N 940 8910 980 8910 {lab=#net11}
N 940 8950 940 8960 {lab=VDD}
N 970 8950 990 8950 {lab=#net681}
N 900 8950 910 8950 {lab=#net682}
N 980 8880 980 8910 {lab=#net11}
N 980 8910 980 8960 {lab=#net11}
N 890 8880 890 8960 {lab=A2}
N 810 8950 900 8950 {lab=#net682}
N 760 8910 800 8910 {lab=#net13}
N 760 8950 760 8960 {lab=VDD}
N 790 8950 810 8950 {lab=#net682}
N 720 8950 730 8950 {lab=#net683}
N 800 8880 800 8910 {lab=#net13}
N 800 8910 800 8960 {lab=#net13}
N 710 8880 710 8960 {lab=A3}
N 630 8950 720 8950 {lab=#net683}
N 580 8910 620 8910 {lab=#net15}
N 580 8950 580 8960 {lab=VDD}
N 610 8950 630 8950 {lab=#net683}
N 540 8950 550 8950 {lab=#net684}
N 620 8880 620 8910 {lab=#net15}
N 620 8910 620 8960 {lab=#net15}
N 490 8910 530 8910 {lab=A4}
N 490 8950 490 8960 {lab=VDD}
N 520 8950 540 8950 {lab=#net684}
N 450 8950 460 8950 {lab=#net685}
N 530 8880 530 8910 {lab=A4}
N 530 8910 530 8960 {lab=A4}
N 440 8880 440 8960 {lab=#net17}
N 360 8950 450 8950 {lab=#net685}
N 350 8880 350 8960 {lab=A5}
N 270 8950 360 8950 {lab=#net685}
N 220 8910 260 8910 {lab=#net19}
N 220 8950 220 8960 {lab=VDD}
N 250 8950 270 8950 {lab=#net685}
N 180 8950 190 8950 {lab=#net686}
N 260 8880 260 8910 {lab=#net19}
N 260 8910 260 8960 {lab=#net19}
N 170 8880 170 8960 {lab=A6}
N 90 8950 180 8950 {lab=#net686}
N 40 8910 80 8910 {lab=#net20}
N 40 8950 40 8960 {lab=VDD}
N 70 8950 90 8950 {lab=#net686}
N 0 8950 10 8950 {lab=VDD}
N 80 8880 80 8910 {lab=#net20}
N 80 8910 80 8960 {lab=#net20}
N 0 8880 0 8960 { lab=VDD}
N 2570 9000 2580 9000 {lab=GND}
N 2580 8970 2580 9000 {lab=GND}
N 2570 8970 2580 8970 {lab=GND}
N 2530 8960 2530 9000 {lab=#net1}
N 2530 9000 2530 9040 {lab=#net1}
N 2520 9030 2570 9030 {lab=word112}
N 2570 9030 2610 9030 {lab=word112}
N 2440 8960 2440 9040 {lab=A6}
N 2430 9030 2520 9030 {lab=word112}
N 2390 9000 2400 9000 {lab=GND}
N 2400 8970 2400 9000 {lab=GND}
N 2390 8970 2400 8970 {lab=GND}
N 2350 8960 2350 9000 {lab=#net2}
N 2350 9000 2350 9040 {lab=#net2}
N 2340 9030 2390 9030 {lab=word112}
N 2390 9030 2430 9030 {lab=word112}
N 2260 8960 2260 9040 {lab=A5}
N 2250 9030 2340 9030 {lab=word112}
N 2210 9000 2220 9000 {lab=GND}
N 2220 8970 2220 9000 {lab=GND}
N 2210 8970 2220 8970 {lab=GND}
N 2170 8960 2170 9000 {lab=#net3}
N 2170 9000 2170 9040 {lab=#net3}
N 2160 9030 2210 9030 {lab=word112}
N 2210 9030 2250 9030 {lab=word112}
N 2080 8960 2080 9040 {lab=A4}
N 2070 9030 2160 9030 {lab=word112}
N 1990 8960 1990 9040 {lab=#net4}
N 1980 9030 2070 9030 {lab=word112}
N 1940 9000 1950 9000 {lab=GND}
N 1950 8970 1950 9000 {lab=GND}
N 1940 8970 1950 8970 {lab=GND}
N 1900 8960 1900 9000 {lab=A3}
N 1900 9000 1900 9040 {lab=A3}
N 1890 9030 1940 9030 {lab=word112}
N 1940 9030 1980 9030 {lab=word112}
N 1810 8960 1810 9040 {lab=#net5}
N 1800 9030 1890 9030 {lab=word112}
N 1760 9000 1770 9000 {lab=GND}
N 1770 8970 1770 9000 {lab=GND}
N 1760 8970 1770 8970 {lab=GND}
N 1720 8960 1720 9000 {lab=A2}
N 1720 9000 1720 9040 {lab=A2}
N 1710 9030 1760 9030 {lab=word112}
N 1760 9030 1800 9030 {lab=word112}
N 1630 8960 1630 9040 {lab=#net6}
N 1620 9030 1710 9030 {lab=word112}
N 1580 9000 1590 9000 {lab=GND}
N 1590 8970 1590 9000 {lab=GND}
N 1580 8970 1590 8970 {lab=GND}
N 1540 8960 1540 9000 {lab=A1}
N 1540 9000 1540 9040 {lab=A1}
N 1530 9030 1580 9030 {lab=word112}
N 1580 9030 1620 9030 {lab=word112}
N 1450 8960 1450 9040 {lab=#net7}
N 1440 9030 1530 9030 {lab=word112}
N 1400 9000 1410 9000 {lab=GND}
N 1410 8970 1410 9000 {lab=GND}
N 1400 8970 1410 8970 {lab=GND}
N 1360 8960 1360 9000 {lab=A0}
N 1360 9000 1360 9040 {lab=A0}
N 1350 9030 1400 9030 {lab=word112}
N 1400 9030 1440 9030 {lab=word112}
N 1260 9030 1350 9030 { lab=word112}
N 1210 8990 1250 8990 {lab=A0}
N 1210 9030 1210 9040 {lab=VDD}
N 1240 9030 1260 9030 {lab=word112}
N 1170 9030 1180 9030 {lab=#net687}
N 1250 8960 1250 8990 {lab=A0}
N 1250 8990 1250 9040 {lab=A0}
N 1160 8960 1160 9040 {lab=#net9}
N 1080 9030 1170 9030 {lab=#net687}
N 1030 8990 1070 8990 {lab=A1}
N 1030 9030 1030 9040 {lab=VDD}
N 1060 9030 1080 9030 {lab=#net687}
N 990 9030 1000 9030 {lab=#net688}
N 1070 8960 1070 8990 {lab=A1}
N 1070 8990 1070 9040 {lab=A1}
N 980 8960 980 9040 {lab=#net11}
N 900 9030 990 9030 {lab=#net688}
N 850 8990 890 8990 {lab=A2}
N 850 9030 850 9040 {lab=VDD}
N 880 9030 900 9030 {lab=#net688}
N 810 9030 820 9030 {lab=#net689}
N 890 8960 890 8990 {lab=A2}
N 890 8990 890 9040 {lab=A2}
N 800 8960 800 9040 {lab=#net13}
N 720 9030 810 9030 {lab=#net689}
N 670 8990 710 8990 {lab=A3}
N 670 9030 670 9040 {lab=VDD}
N 700 9030 720 9030 {lab=#net689}
N 630 9030 640 9030 {lab=#net690}
N 710 8960 710 8990 {lab=A3}
N 710 8990 710 9040 {lab=A3}
N 620 8960 620 9040 {lab=#net15}
N 540 9030 630 9030 {lab=#net690}
N 530 8960 530 9040 {lab=A4}
N 450 9030 540 9030 {lab=#net690}
N 400 8990 440 8990 {lab=#net17}
N 400 9030 400 9040 {lab=VDD}
N 430 9030 450 9030 {lab=#net690}
N 360 9030 370 9030 {lab=#net691}
N 440 8960 440 8990 {lab=#net17}
N 440 8990 440 9040 {lab=#net17}
N 350 8960 350 9040 {lab=A5}
N 270 9030 360 9030 {lab=#net691}
N 220 8990 260 8990 {lab=#net19}
N 220 9030 220 9040 {lab=VDD}
N 250 9030 270 9030 {lab=#net691}
N 180 9030 190 9030 {lab=#net692}
N 260 8960 260 8990 {lab=#net19}
N 260 8990 260 9040 {lab=#net19}
N 170 8960 170 9040 {lab=A6}
N 90 9030 180 9030 {lab=#net692}
N 40 8990 80 8990 {lab=#net20}
N 40 9030 40 9040 {lab=VDD}
N 70 9030 90 9030 {lab=#net692}
N 0 9030 10 9030 {lab=VDD}
N 80 8960 80 8990 {lab=#net20}
N 80 8990 80 9040 {lab=#net20}
N 0 8960 0 9040 { lab=VDD}
N 2570 9080 2580 9080 {lab=GND}
N 2580 9050 2580 9080 {lab=GND}
N 2570 9050 2580 9050 {lab=GND}
N 2530 9040 2530 9080 {lab=#net1}
N 2530 9080 2530 9120 {lab=#net1}
N 2520 9110 2570 9110 {lab=word113}
N 2570 9110 2610 9110 {lab=word113}
N 2440 9040 2440 9120 {lab=A6}
N 2430 9110 2520 9110 {lab=word113}
N 2390 9080 2400 9080 {lab=GND}
N 2400 9050 2400 9080 {lab=GND}
N 2390 9050 2400 9050 {lab=GND}
N 2350 9040 2350 9080 {lab=#net2}
N 2350 9080 2350 9120 {lab=#net2}
N 2340 9110 2390 9110 {lab=word113}
N 2390 9110 2430 9110 {lab=word113}
N 2260 9040 2260 9120 {lab=A5}
N 2250 9110 2340 9110 {lab=word113}
N 2210 9080 2220 9080 {lab=GND}
N 2220 9050 2220 9080 {lab=GND}
N 2210 9050 2220 9050 {lab=GND}
N 2170 9040 2170 9080 {lab=#net3}
N 2170 9080 2170 9120 {lab=#net3}
N 2160 9110 2210 9110 {lab=word113}
N 2210 9110 2250 9110 {lab=word113}
N 2080 9040 2080 9120 {lab=A4}
N 2070 9110 2160 9110 {lab=word113}
N 1990 9040 1990 9120 {lab=#net4}
N 1980 9110 2070 9110 {lab=word113}
N 1940 9080 1950 9080 {lab=GND}
N 1950 9050 1950 9080 {lab=GND}
N 1940 9050 1950 9050 {lab=GND}
N 1900 9040 1900 9080 {lab=A3}
N 1900 9080 1900 9120 {lab=A3}
N 1890 9110 1940 9110 {lab=word113}
N 1940 9110 1980 9110 {lab=word113}
N 1810 9040 1810 9120 {lab=#net5}
N 1800 9110 1890 9110 {lab=word113}
N 1760 9080 1770 9080 {lab=GND}
N 1770 9050 1770 9080 {lab=GND}
N 1760 9050 1770 9050 {lab=GND}
N 1720 9040 1720 9080 {lab=A2}
N 1720 9080 1720 9120 {lab=A2}
N 1710 9110 1760 9110 {lab=word113}
N 1760 9110 1800 9110 {lab=word113}
N 1630 9040 1630 9120 {lab=#net6}
N 1620 9110 1710 9110 {lab=word113}
N 1580 9080 1590 9080 {lab=GND}
N 1590 9050 1590 9080 {lab=GND}
N 1580 9050 1590 9050 {lab=GND}
N 1540 9040 1540 9080 {lab=A1}
N 1540 9080 1540 9120 {lab=A1}
N 1530 9110 1580 9110 {lab=word113}
N 1580 9110 1620 9110 {lab=word113}
N 1490 9080 1500 9080 {lab=GND}
N 1500 9050 1500 9080 {lab=GND}
N 1490 9050 1500 9050 {lab=GND}
N 1450 9040 1450 9080 {lab=#net7}
N 1450 9080 1450 9120 {lab=#net7}
N 1440 9110 1490 9110 {lab=word113}
N 1490 9110 1530 9110 {lab=word113}
N 1360 9040 1360 9120 {lab=A0}
N 1350 9110 1440 9110 {lab=word113}
N 1260 9110 1350 9110 { lab=word113}
N 1250 9040 1250 9120 {lab=A0}
N 1170 9110 1260 9110 {lab=word113}
N 1120 9070 1160 9070 {lab=#net9}
N 1120 9110 1120 9120 {lab=VDD}
N 1150 9110 1170 9110 {lab=word113}
N 1080 9110 1090 9110 {lab=#net693}
N 1160 9040 1160 9070 {lab=#net9}
N 1160 9070 1160 9120 {lab=#net9}
N 1030 9070 1070 9070 {lab=A1}
N 1030 9110 1030 9120 {lab=VDD}
N 1060 9110 1080 9110 {lab=#net693}
N 990 9110 1000 9110 {lab=#net694}
N 1070 9040 1070 9070 {lab=A1}
N 1070 9070 1070 9120 {lab=A1}
N 980 9040 980 9120 {lab=#net11}
N 900 9110 990 9110 {lab=#net694}
N 850 9070 890 9070 {lab=A2}
N 850 9110 850 9120 {lab=VDD}
N 880 9110 900 9110 {lab=#net694}
N 810 9110 820 9110 {lab=#net695}
N 890 9040 890 9070 {lab=A2}
N 890 9070 890 9120 {lab=A2}
N 800 9040 800 9120 {lab=#net13}
N 720 9110 810 9110 {lab=#net695}
N 670 9070 710 9070 {lab=A3}
N 670 9110 670 9120 {lab=VDD}
N 700 9110 720 9110 {lab=#net695}
N 630 9110 640 9110 {lab=#net696}
N 710 9040 710 9070 {lab=A3}
N 710 9070 710 9120 {lab=A3}
N 620 9040 620 9120 {lab=#net15}
N 540 9110 630 9110 {lab=#net696}
N 530 9040 530 9120 {lab=A4}
N 450 9110 540 9110 {lab=#net696}
N 400 9070 440 9070 {lab=#net17}
N 400 9110 400 9120 {lab=VDD}
N 430 9110 450 9110 {lab=#net696}
N 360 9110 370 9110 {lab=#net697}
N 440 9040 440 9070 {lab=#net17}
N 440 9070 440 9120 {lab=#net17}
N 350 9040 350 9120 {lab=A5}
N 270 9110 360 9110 {lab=#net697}
N 220 9070 260 9070 {lab=#net19}
N 220 9110 220 9120 {lab=VDD}
N 250 9110 270 9110 {lab=#net697}
N 180 9110 190 9110 {lab=#net698}
N 260 9040 260 9070 {lab=#net19}
N 260 9070 260 9120 {lab=#net19}
N 170 9040 170 9120 {lab=A6}
N 90 9110 180 9110 {lab=#net698}
N 40 9070 80 9070 {lab=#net20}
N 40 9110 40 9120 {lab=VDD}
N 70 9110 90 9110 {lab=#net698}
N 0 9110 10 9110 {lab=VDD}
N 80 9040 80 9070 {lab=#net20}
N 80 9070 80 9120 {lab=#net20}
N 0 9040 0 9120 { lab=VDD}
N 2570 9160 2580 9160 {lab=GND}
N 2580 9130 2580 9160 {lab=GND}
N 2570 9130 2580 9130 {lab=GND}
N 2530 9120 2530 9160 {lab=#net1}
N 2530 9160 2530 9200 {lab=#net1}
N 2520 9190 2570 9190 {lab=word114}
N 2570 9190 2610 9190 {lab=word114}
N 2440 9120 2440 9200 {lab=A6}
N 2430 9190 2520 9190 {lab=word114}
N 2390 9160 2400 9160 {lab=GND}
N 2400 9130 2400 9160 {lab=GND}
N 2390 9130 2400 9130 {lab=GND}
N 2350 9120 2350 9160 {lab=#net2}
N 2350 9160 2350 9200 {lab=#net2}
N 2340 9190 2390 9190 {lab=word114}
N 2390 9190 2430 9190 {lab=word114}
N 2260 9120 2260 9200 {lab=A5}
N 2250 9190 2340 9190 {lab=word114}
N 2210 9160 2220 9160 {lab=GND}
N 2220 9130 2220 9160 {lab=GND}
N 2210 9130 2220 9130 {lab=GND}
N 2170 9120 2170 9160 {lab=#net3}
N 2170 9160 2170 9200 {lab=#net3}
N 2160 9190 2210 9190 {lab=word114}
N 2210 9190 2250 9190 {lab=word114}
N 2080 9120 2080 9200 {lab=A4}
N 2070 9190 2160 9190 {lab=word114}
N 1990 9120 1990 9200 {lab=#net4}
N 1980 9190 2070 9190 {lab=word114}
N 1940 9160 1950 9160 {lab=GND}
N 1950 9130 1950 9160 {lab=GND}
N 1940 9130 1950 9130 {lab=GND}
N 1900 9120 1900 9160 {lab=A3}
N 1900 9160 1900 9200 {lab=A3}
N 1890 9190 1940 9190 {lab=word114}
N 1940 9190 1980 9190 {lab=word114}
N 1810 9120 1810 9200 {lab=#net5}
N 1800 9190 1890 9190 {lab=word114}
N 1760 9160 1770 9160 {lab=GND}
N 1770 9130 1770 9160 {lab=GND}
N 1760 9130 1770 9130 {lab=GND}
N 1720 9120 1720 9160 {lab=A2}
N 1720 9160 1720 9200 {lab=A2}
N 1710 9190 1760 9190 {lab=word114}
N 1760 9190 1800 9190 {lab=word114}
N 1670 9160 1680 9160 {lab=GND}
N 1680 9130 1680 9160 {lab=GND}
N 1670 9130 1680 9130 {lab=GND}
N 1630 9120 1630 9160 {lab=#net6}
N 1630 9160 1630 9200 {lab=#net6}
N 1620 9190 1670 9190 {lab=word114}
N 1670 9190 1710 9190 {lab=word114}
N 1540 9120 1540 9200 {lab=A1}
N 1530 9190 1620 9190 {lab=word114}
N 1450 9120 1450 9200 {lab=#net7}
N 1440 9190 1530 9190 {lab=word114}
N 1400 9160 1410 9160 {lab=GND}
N 1410 9130 1410 9160 {lab=GND}
N 1400 9130 1410 9130 {lab=GND}
N 1360 9120 1360 9160 {lab=A0}
N 1360 9160 1360 9200 {lab=A0}
N 1350 9190 1400 9190 {lab=word114}
N 1400 9190 1440 9190 {lab=word114}
N 1260 9190 1350 9190 { lab=word114}
N 1210 9150 1250 9150 {lab=A0}
N 1210 9190 1210 9200 {lab=VDD}
N 1240 9190 1260 9190 {lab=word114}
N 1170 9190 1180 9190 {lab=#net699}
N 1250 9120 1250 9150 {lab=A0}
N 1250 9150 1250 9200 {lab=A0}
N 1160 9120 1160 9200 {lab=#net9}
N 1080 9190 1170 9190 {lab=#net699}
N 1070 9120 1070 9200 {lab=A1}
N 990 9190 1080 9190 {lab=#net699}
N 940 9150 980 9150 {lab=#net11}
N 940 9190 940 9200 {lab=VDD}
N 970 9190 990 9190 {lab=#net699}
N 900 9190 910 9190 {lab=#net700}
N 980 9120 980 9150 {lab=#net11}
N 980 9150 980 9200 {lab=#net11}
N 850 9150 890 9150 {lab=A2}
N 850 9190 850 9200 {lab=VDD}
N 880 9190 900 9190 {lab=#net700}
N 810 9190 820 9190 {lab=#net701}
N 890 9120 890 9150 {lab=A2}
N 890 9150 890 9200 {lab=A2}
N 800 9120 800 9200 {lab=#net13}
N 720 9190 810 9190 {lab=#net701}
N 670 9150 710 9150 {lab=A3}
N 670 9190 670 9200 {lab=VDD}
N 700 9190 720 9190 {lab=#net701}
N 630 9190 640 9190 {lab=#net702}
N 710 9120 710 9150 {lab=A3}
N 710 9150 710 9200 {lab=A3}
N 620 9120 620 9200 {lab=#net15}
N 540 9190 630 9190 {lab=#net702}
N 530 9120 530 9200 {lab=A4}
N 450 9190 540 9190 {lab=#net702}
N 400 9150 440 9150 {lab=#net17}
N 400 9190 400 9200 {lab=VDD}
N 430 9190 450 9190 {lab=#net702}
N 360 9190 370 9190 {lab=#net703}
N 440 9120 440 9150 {lab=#net17}
N 440 9150 440 9200 {lab=#net17}
N 350 9120 350 9200 {lab=A5}
N 270 9190 360 9190 {lab=#net703}
N 220 9150 260 9150 {lab=#net19}
N 220 9190 220 9200 {lab=VDD}
N 250 9190 270 9190 {lab=#net703}
N 180 9190 190 9190 {lab=#net704}
N 260 9120 260 9150 {lab=#net19}
N 260 9150 260 9200 {lab=#net19}
N 170 9120 170 9200 {lab=A6}
N 90 9190 180 9190 {lab=#net704}
N 40 9150 80 9150 {lab=#net20}
N 40 9190 40 9200 {lab=VDD}
N 70 9190 90 9190 {lab=#net704}
N 0 9190 10 9190 {lab=VDD}
N 80 9120 80 9150 {lab=#net20}
N 80 9150 80 9200 {lab=#net20}
N 0 9120 0 9200 { lab=VDD}
N 2570 9240 2580 9240 {lab=GND}
N 2580 9210 2580 9240 {lab=GND}
N 2570 9210 2580 9210 {lab=GND}
N 2530 9200 2530 9240 {lab=#net1}
N 2530 9240 2530 9280 {lab=#net1}
N 2520 9270 2570 9270 {lab=word115}
N 2570 9270 2610 9270 {lab=word115}
N 2440 9200 2440 9280 {lab=A6}
N 2430 9270 2520 9270 {lab=word115}
N 2390 9240 2400 9240 {lab=GND}
N 2400 9210 2400 9240 {lab=GND}
N 2390 9210 2400 9210 {lab=GND}
N 2350 9200 2350 9240 {lab=#net2}
N 2350 9240 2350 9280 {lab=#net2}
N 2340 9270 2390 9270 {lab=word115}
N 2390 9270 2430 9270 {lab=word115}
N 2260 9200 2260 9280 {lab=A5}
N 2250 9270 2340 9270 {lab=word115}
N 2210 9240 2220 9240 {lab=GND}
N 2220 9210 2220 9240 {lab=GND}
N 2210 9210 2220 9210 {lab=GND}
N 2170 9200 2170 9240 {lab=#net3}
N 2170 9240 2170 9280 {lab=#net3}
N 2160 9270 2210 9270 {lab=word115}
N 2210 9270 2250 9270 {lab=word115}
N 2080 9200 2080 9280 {lab=A4}
N 2070 9270 2160 9270 {lab=word115}
N 1990 9200 1990 9280 {lab=#net4}
N 1980 9270 2070 9270 {lab=word115}
N 1940 9240 1950 9240 {lab=GND}
N 1950 9210 1950 9240 {lab=GND}
N 1940 9210 1950 9210 {lab=GND}
N 1900 9200 1900 9240 {lab=A3}
N 1900 9240 1900 9280 {lab=A3}
N 1890 9270 1940 9270 {lab=word115}
N 1940 9270 1980 9270 {lab=word115}
N 1810 9200 1810 9280 {lab=#net5}
N 1800 9270 1890 9270 {lab=word115}
N 1760 9240 1770 9240 {lab=GND}
N 1770 9210 1770 9240 {lab=GND}
N 1760 9210 1770 9210 {lab=GND}
N 1720 9200 1720 9240 {lab=A2}
N 1720 9240 1720 9280 {lab=A2}
N 1710 9270 1760 9270 {lab=word115}
N 1760 9270 1800 9270 {lab=word115}
N 1670 9240 1680 9240 {lab=GND}
N 1680 9210 1680 9240 {lab=GND}
N 1670 9210 1680 9210 {lab=GND}
N 1630 9200 1630 9240 {lab=#net6}
N 1630 9240 1630 9280 {lab=#net6}
N 1620 9270 1670 9270 {lab=word115}
N 1670 9270 1710 9270 {lab=word115}
N 1540 9200 1540 9280 {lab=A1}
N 1530 9270 1620 9270 {lab=word115}
N 1490 9240 1500 9240 {lab=GND}
N 1500 9210 1500 9240 {lab=GND}
N 1490 9210 1500 9210 {lab=GND}
N 1450 9200 1450 9240 {lab=#net7}
N 1450 9240 1450 9280 {lab=#net7}
N 1440 9270 1490 9270 {lab=word115}
N 1490 9270 1530 9270 {lab=word115}
N 1360 9200 1360 9280 {lab=A0}
N 1350 9270 1440 9270 {lab=word115}
N 1260 9270 1350 9270 { lab=word115}
N 1250 9200 1250 9280 {lab=A0}
N 1170 9270 1260 9270 {lab=word115}
N 1120 9230 1160 9230 {lab=#net9}
N 1120 9270 1120 9280 {lab=VDD}
N 1150 9270 1170 9270 {lab=word115}
N 1080 9270 1090 9270 {lab=#net705}
N 1160 9200 1160 9230 {lab=#net9}
N 1160 9230 1160 9280 {lab=#net9}
N 1070 9200 1070 9280 {lab=A1}
N 990 9270 1080 9270 {lab=#net705}
N 940 9230 980 9230 {lab=#net11}
N 940 9270 940 9280 {lab=VDD}
N 970 9270 990 9270 {lab=#net705}
N 900 9270 910 9270 {lab=#net706}
N 980 9200 980 9230 {lab=#net11}
N 980 9230 980 9280 {lab=#net11}
N 850 9230 890 9230 {lab=A2}
N 850 9270 850 9280 {lab=VDD}
N 880 9270 900 9270 {lab=#net706}
N 810 9270 820 9270 {lab=#net707}
N 890 9200 890 9230 {lab=A2}
N 890 9230 890 9280 {lab=A2}
N 800 9200 800 9280 {lab=#net13}
N 720 9270 810 9270 {lab=#net707}
N 670 9230 710 9230 {lab=A3}
N 670 9270 670 9280 {lab=VDD}
N 700 9270 720 9270 {lab=#net707}
N 630 9270 640 9270 {lab=#net708}
N 710 9200 710 9230 {lab=A3}
N 710 9230 710 9280 {lab=A3}
N 620 9200 620 9280 {lab=#net15}
N 540 9270 630 9270 {lab=#net708}
N 530 9200 530 9280 {lab=A4}
N 450 9270 540 9270 {lab=#net708}
N 400 9230 440 9230 {lab=#net17}
N 400 9270 400 9280 {lab=VDD}
N 430 9270 450 9270 {lab=#net708}
N 360 9270 370 9270 {lab=#net709}
N 440 9200 440 9230 {lab=#net17}
N 440 9230 440 9280 {lab=#net17}
N 350 9200 350 9280 {lab=A5}
N 270 9270 360 9270 {lab=#net709}
N 220 9230 260 9230 {lab=#net19}
N 220 9270 220 9280 {lab=VDD}
N 250 9270 270 9270 {lab=#net709}
N 180 9270 190 9270 {lab=#net710}
N 260 9200 260 9230 {lab=#net19}
N 260 9230 260 9280 {lab=#net19}
N 170 9200 170 9280 {lab=A6}
N 90 9270 180 9270 {lab=#net710}
N 40 9230 80 9230 {lab=#net20}
N 40 9270 40 9280 {lab=VDD}
N 70 9270 90 9270 {lab=#net710}
N 0 9270 10 9270 {lab=VDD}
N 80 9200 80 9230 {lab=#net20}
N 80 9230 80 9280 {lab=#net20}
N 0 9200 0 9280 { lab=VDD}
N 2570 9320 2580 9320 {lab=GND}
N 2580 9290 2580 9320 {lab=GND}
N 2570 9290 2580 9290 {lab=GND}
N 2530 9280 2530 9320 {lab=#net1}
N 2530 9320 2530 9360 {lab=#net1}
N 2520 9350 2570 9350 {lab=word116}
N 2570 9350 2610 9350 {lab=word116}
N 2440 9280 2440 9360 {lab=A6}
N 2430 9350 2520 9350 {lab=word116}
N 2390 9320 2400 9320 {lab=GND}
N 2400 9290 2400 9320 {lab=GND}
N 2390 9290 2400 9290 {lab=GND}
N 2350 9280 2350 9320 {lab=#net2}
N 2350 9320 2350 9360 {lab=#net2}
N 2340 9350 2390 9350 {lab=word116}
N 2390 9350 2430 9350 {lab=word116}
N 2260 9280 2260 9360 {lab=A5}
N 2250 9350 2340 9350 {lab=word116}
N 2210 9320 2220 9320 {lab=GND}
N 2220 9290 2220 9320 {lab=GND}
N 2210 9290 2220 9290 {lab=GND}
N 2170 9280 2170 9320 {lab=#net3}
N 2170 9320 2170 9360 {lab=#net3}
N 2160 9350 2210 9350 {lab=word116}
N 2210 9350 2250 9350 {lab=word116}
N 2080 9280 2080 9360 {lab=A4}
N 2070 9350 2160 9350 {lab=word116}
N 1990 9280 1990 9360 {lab=#net4}
N 1980 9350 2070 9350 {lab=word116}
N 1940 9320 1950 9320 {lab=GND}
N 1950 9290 1950 9320 {lab=GND}
N 1940 9290 1950 9290 {lab=GND}
N 1900 9280 1900 9320 {lab=A3}
N 1900 9320 1900 9360 {lab=A3}
N 1890 9350 1940 9350 {lab=word116}
N 1940 9350 1980 9350 {lab=word116}
N 1850 9320 1860 9320 {lab=GND}
N 1860 9290 1860 9320 {lab=GND}
N 1850 9290 1860 9290 {lab=GND}
N 1810 9280 1810 9320 {lab=#net5}
N 1810 9320 1810 9360 {lab=#net5}
N 1800 9350 1850 9350 {lab=word116}
N 1850 9350 1890 9350 {lab=word116}
N 1720 9280 1720 9360 {lab=A2}
N 1710 9350 1800 9350 {lab=word116}
N 1630 9280 1630 9360 {lab=#net6}
N 1620 9350 1710 9350 {lab=word116}
N 1580 9320 1590 9320 {lab=GND}
N 1590 9290 1590 9320 {lab=GND}
N 1580 9290 1590 9290 {lab=GND}
N 1540 9280 1540 9320 {lab=A1}
N 1540 9320 1540 9360 {lab=A1}
N 1530 9350 1580 9350 {lab=word116}
N 1580 9350 1620 9350 {lab=word116}
N 1450 9280 1450 9360 {lab=#net7}
N 1440 9350 1530 9350 {lab=word116}
N 1400 9320 1410 9320 {lab=GND}
N 1410 9290 1410 9320 {lab=GND}
N 1400 9290 1410 9290 {lab=GND}
N 1360 9280 1360 9320 {lab=A0}
N 1360 9320 1360 9360 {lab=A0}
N 1350 9350 1400 9350 {lab=word116}
N 1400 9350 1440 9350 {lab=word116}
N 1260 9350 1350 9350 { lab=word116}
N 1210 9310 1250 9310 {lab=A0}
N 1210 9350 1210 9360 {lab=VDD}
N 1240 9350 1260 9350 {lab=word116}
N 1170 9350 1180 9350 {lab=#net711}
N 1250 9280 1250 9310 {lab=A0}
N 1250 9310 1250 9360 {lab=A0}
N 1160 9280 1160 9360 {lab=#net9}
N 1080 9350 1170 9350 {lab=#net711}
N 1030 9310 1070 9310 {lab=A1}
N 1030 9350 1030 9360 {lab=VDD}
N 1060 9350 1080 9350 {lab=#net711}
N 990 9350 1000 9350 {lab=#net712}
N 1070 9280 1070 9310 {lab=A1}
N 1070 9310 1070 9360 {lab=A1}
N 980 9280 980 9360 {lab=#net11}
N 900 9350 990 9350 {lab=#net712}
N 890 9280 890 9360 {lab=A2}
N 810 9350 900 9350 {lab=#net712}
N 760 9310 800 9310 {lab=#net13}
N 760 9350 760 9360 {lab=VDD}
N 790 9350 810 9350 {lab=#net712}
N 720 9350 730 9350 {lab=#net713}
N 800 9280 800 9310 {lab=#net13}
N 800 9310 800 9360 {lab=#net13}
N 670 9310 710 9310 {lab=A3}
N 670 9350 670 9360 {lab=VDD}
N 700 9350 720 9350 {lab=#net713}
N 630 9350 640 9350 {lab=#net714}
N 710 9280 710 9310 {lab=A3}
N 710 9310 710 9360 {lab=A3}
N 620 9280 620 9360 {lab=#net15}
N 540 9350 630 9350 {lab=#net714}
N 530 9280 530 9360 {lab=A4}
N 450 9350 540 9350 {lab=#net714}
N 400 9310 440 9310 {lab=#net17}
N 400 9350 400 9360 {lab=VDD}
N 430 9350 450 9350 {lab=#net714}
N 360 9350 370 9350 {lab=#net715}
N 440 9280 440 9310 {lab=#net17}
N 440 9310 440 9360 {lab=#net17}
N 350 9280 350 9360 {lab=A5}
N 270 9350 360 9350 {lab=#net715}
N 220 9310 260 9310 {lab=#net19}
N 220 9350 220 9360 {lab=VDD}
N 250 9350 270 9350 {lab=#net715}
N 180 9350 190 9350 {lab=#net716}
N 260 9280 260 9310 {lab=#net19}
N 260 9310 260 9360 {lab=#net19}
N 170 9280 170 9360 {lab=A6}
N 90 9350 180 9350 {lab=#net716}
N 40 9310 80 9310 {lab=#net20}
N 40 9350 40 9360 {lab=VDD}
N 70 9350 90 9350 {lab=#net716}
N 0 9350 10 9350 {lab=VDD}
N 80 9280 80 9310 {lab=#net20}
N 80 9310 80 9360 {lab=#net20}
N 0 9280 0 9360 { lab=VDD}
N 2570 9400 2580 9400 {lab=GND}
N 2580 9370 2580 9400 {lab=GND}
N 2570 9370 2580 9370 {lab=GND}
N 2530 9360 2530 9400 {lab=#net1}
N 2530 9400 2530 9440 {lab=#net1}
N 2520 9430 2570 9430 {lab=word117}
N 2570 9430 2610 9430 {lab=word117}
N 2440 9360 2440 9440 {lab=A6}
N 2430 9430 2520 9430 {lab=word117}
N 2390 9400 2400 9400 {lab=GND}
N 2400 9370 2400 9400 {lab=GND}
N 2390 9370 2400 9370 {lab=GND}
N 2350 9360 2350 9400 {lab=#net2}
N 2350 9400 2350 9440 {lab=#net2}
N 2340 9430 2390 9430 {lab=word117}
N 2390 9430 2430 9430 {lab=word117}
N 2260 9360 2260 9440 {lab=A5}
N 2250 9430 2340 9430 {lab=word117}
N 2210 9400 2220 9400 {lab=GND}
N 2220 9370 2220 9400 {lab=GND}
N 2210 9370 2220 9370 {lab=GND}
N 2170 9360 2170 9400 {lab=#net3}
N 2170 9400 2170 9440 {lab=#net3}
N 2160 9430 2210 9430 {lab=word117}
N 2210 9430 2250 9430 {lab=word117}
N 2080 9360 2080 9440 {lab=A4}
N 2070 9430 2160 9430 {lab=word117}
N 1990 9360 1990 9440 {lab=#net4}
N 1980 9430 2070 9430 {lab=word117}
N 1940 9400 1950 9400 {lab=GND}
N 1950 9370 1950 9400 {lab=GND}
N 1940 9370 1950 9370 {lab=GND}
N 1900 9360 1900 9400 {lab=A3}
N 1900 9400 1900 9440 {lab=A3}
N 1890 9430 1940 9430 {lab=word117}
N 1940 9430 1980 9430 {lab=word117}
N 1850 9400 1860 9400 {lab=GND}
N 1860 9370 1860 9400 {lab=GND}
N 1850 9370 1860 9370 {lab=GND}
N 1810 9360 1810 9400 {lab=#net5}
N 1810 9400 1810 9440 {lab=#net5}
N 1800 9430 1850 9430 {lab=word117}
N 1850 9430 1890 9430 {lab=word117}
N 1720 9360 1720 9440 {lab=A2}
N 1710 9430 1800 9430 {lab=word117}
N 1630 9360 1630 9440 {lab=#net6}
N 1620 9430 1710 9430 {lab=word117}
N 1580 9400 1590 9400 {lab=GND}
N 1590 9370 1590 9400 {lab=GND}
N 1580 9370 1590 9370 {lab=GND}
N 1540 9360 1540 9400 {lab=A1}
N 1540 9400 1540 9440 {lab=A1}
N 1530 9430 1580 9430 {lab=word117}
N 1580 9430 1620 9430 {lab=word117}
N 1490 9400 1500 9400 {lab=GND}
N 1500 9370 1500 9400 {lab=GND}
N 1490 9370 1500 9370 {lab=GND}
N 1450 9360 1450 9400 {lab=#net7}
N 1450 9400 1450 9440 {lab=#net7}
N 1440 9430 1490 9430 {lab=word117}
N 1490 9430 1530 9430 {lab=word117}
N 1360 9360 1360 9440 {lab=A0}
N 1350 9430 1440 9430 {lab=word117}
N 1260 9430 1350 9430 { lab=word117}
N 1250 9360 1250 9440 {lab=A0}
N 1170 9430 1260 9430 {lab=word117}
N 1120 9390 1160 9390 {lab=#net9}
N 1120 9430 1120 9440 {lab=VDD}
N 1150 9430 1170 9430 {lab=word117}
N 1080 9430 1090 9430 {lab=#net717}
N 1160 9360 1160 9390 {lab=#net9}
N 1160 9390 1160 9440 {lab=#net9}
N 1030 9390 1070 9390 {lab=A1}
N 1030 9430 1030 9440 {lab=VDD}
N 1060 9430 1080 9430 {lab=#net717}
N 990 9430 1000 9430 {lab=#net718}
N 1070 9360 1070 9390 {lab=A1}
N 1070 9390 1070 9440 {lab=A1}
N 980 9360 980 9440 {lab=#net11}
N 900 9430 990 9430 {lab=#net718}
N 890 9360 890 9440 {lab=A2}
N 810 9430 900 9430 {lab=#net718}
N 760 9390 800 9390 {lab=#net13}
N 760 9430 760 9440 {lab=VDD}
N 790 9430 810 9430 {lab=#net718}
N 720 9430 730 9430 {lab=#net719}
N 800 9360 800 9390 {lab=#net13}
N 800 9390 800 9440 {lab=#net13}
N 670 9390 710 9390 {lab=A3}
N 670 9430 670 9440 {lab=VDD}
N 700 9430 720 9430 {lab=#net719}
N 630 9430 640 9430 {lab=#net720}
N 710 9360 710 9390 {lab=A3}
N 710 9390 710 9440 {lab=A3}
N 620 9360 620 9440 {lab=#net15}
N 540 9430 630 9430 {lab=#net720}
N 530 9360 530 9440 {lab=A4}
N 450 9430 540 9430 {lab=#net720}
N 400 9390 440 9390 {lab=#net17}
N 400 9430 400 9440 {lab=VDD}
N 430 9430 450 9430 {lab=#net720}
N 360 9430 370 9430 {lab=#net721}
N 440 9360 440 9390 {lab=#net17}
N 440 9390 440 9440 {lab=#net17}
N 350 9360 350 9440 {lab=A5}
N 270 9430 360 9430 {lab=#net721}
N 220 9390 260 9390 {lab=#net19}
N 220 9430 220 9440 {lab=VDD}
N 250 9430 270 9430 {lab=#net721}
N 180 9430 190 9430 {lab=#net722}
N 260 9360 260 9390 {lab=#net19}
N 260 9390 260 9440 {lab=#net19}
N 170 9360 170 9440 {lab=A6}
N 90 9430 180 9430 {lab=#net722}
N 40 9390 80 9390 {lab=#net20}
N 40 9430 40 9440 {lab=VDD}
N 70 9430 90 9430 {lab=#net722}
N 0 9430 10 9430 {lab=VDD}
N 80 9360 80 9390 {lab=#net20}
N 80 9390 80 9440 {lab=#net20}
N 0 9360 0 9440 { lab=VDD}
N 2570 9480 2580 9480 {lab=GND}
N 2580 9450 2580 9480 {lab=GND}
N 2570 9450 2580 9450 {lab=GND}
N 2530 9440 2530 9480 {lab=#net1}
N 2530 9480 2530 9520 {lab=#net1}
N 2520 9510 2570 9510 {lab=word118}
N 2570 9510 2610 9510 {lab=word118}
N 2440 9440 2440 9520 {lab=A6}
N 2430 9510 2520 9510 {lab=word118}
N 2390 9480 2400 9480 {lab=GND}
N 2400 9450 2400 9480 {lab=GND}
N 2390 9450 2400 9450 {lab=GND}
N 2350 9440 2350 9480 {lab=#net2}
N 2350 9480 2350 9520 {lab=#net2}
N 2340 9510 2390 9510 {lab=word118}
N 2390 9510 2430 9510 {lab=word118}
N 2260 9440 2260 9520 {lab=A5}
N 2250 9510 2340 9510 {lab=word118}
N 2210 9480 2220 9480 {lab=GND}
N 2220 9450 2220 9480 {lab=GND}
N 2210 9450 2220 9450 {lab=GND}
N 2170 9440 2170 9480 {lab=#net3}
N 2170 9480 2170 9520 {lab=#net3}
N 2160 9510 2210 9510 {lab=word118}
N 2210 9510 2250 9510 {lab=word118}
N 2080 9440 2080 9520 {lab=A4}
N 2070 9510 2160 9510 {lab=word118}
N 1990 9440 1990 9520 {lab=#net4}
N 1980 9510 2070 9510 {lab=word118}
N 1940 9480 1950 9480 {lab=GND}
N 1950 9450 1950 9480 {lab=GND}
N 1940 9450 1950 9450 {lab=GND}
N 1900 9440 1900 9480 {lab=A3}
N 1900 9480 1900 9520 {lab=A3}
N 1890 9510 1940 9510 {lab=word118}
N 1940 9510 1980 9510 {lab=word118}
N 1850 9480 1860 9480 {lab=GND}
N 1860 9450 1860 9480 {lab=GND}
N 1850 9450 1860 9450 {lab=GND}
N 1810 9440 1810 9480 {lab=#net5}
N 1810 9480 1810 9520 {lab=#net5}
N 1800 9510 1850 9510 {lab=word118}
N 1850 9510 1890 9510 {lab=word118}
N 1720 9440 1720 9520 {lab=A2}
N 1710 9510 1800 9510 {lab=word118}
N 1670 9480 1680 9480 {lab=GND}
N 1680 9450 1680 9480 {lab=GND}
N 1670 9450 1680 9450 {lab=GND}
N 1630 9440 1630 9480 {lab=#net6}
N 1630 9480 1630 9520 {lab=#net6}
N 1620 9510 1670 9510 {lab=word118}
N 1670 9510 1710 9510 {lab=word118}
N 1540 9440 1540 9520 {lab=A1}
N 1530 9510 1620 9510 {lab=word118}
N 1450 9440 1450 9520 {lab=#net7}
N 1440 9510 1530 9510 {lab=word118}
N 1400 9480 1410 9480 {lab=GND}
N 1410 9450 1410 9480 {lab=GND}
N 1400 9450 1410 9450 {lab=GND}
N 1360 9440 1360 9480 {lab=A0}
N 1360 9480 1360 9520 {lab=A0}
N 1350 9510 1400 9510 {lab=word118}
N 1400 9510 1440 9510 {lab=word118}
N 1260 9510 1350 9510 { lab=word118}
N 1210 9470 1250 9470 {lab=A0}
N 1210 9510 1210 9520 {lab=VDD}
N 1240 9510 1260 9510 {lab=word118}
N 1170 9510 1180 9510 {lab=#net723}
N 1250 9440 1250 9470 {lab=A0}
N 1250 9470 1250 9520 {lab=A0}
N 1160 9440 1160 9520 {lab=#net9}
N 1080 9510 1170 9510 {lab=#net723}
N 1070 9440 1070 9520 {lab=A1}
N 990 9510 1080 9510 {lab=#net723}
N 940 9470 980 9470 {lab=#net11}
N 940 9510 940 9520 {lab=VDD}
N 970 9510 990 9510 {lab=#net723}
N 900 9510 910 9510 {lab=#net724}
N 980 9440 980 9470 {lab=#net11}
N 980 9470 980 9520 {lab=#net11}
N 890 9440 890 9520 {lab=A2}
N 810 9510 900 9510 {lab=#net724}
N 760 9470 800 9470 {lab=#net13}
N 760 9510 760 9520 {lab=VDD}
N 790 9510 810 9510 {lab=#net724}
N 720 9510 730 9510 {lab=#net725}
N 800 9440 800 9470 {lab=#net13}
N 800 9470 800 9520 {lab=#net13}
N 670 9470 710 9470 {lab=A3}
N 670 9510 670 9520 {lab=VDD}
N 700 9510 720 9510 {lab=#net725}
N 630 9510 640 9510 {lab=#net726}
N 710 9440 710 9470 {lab=A3}
N 710 9470 710 9520 {lab=A3}
N 620 9440 620 9520 {lab=#net15}
N 540 9510 630 9510 {lab=#net726}
N 530 9440 530 9520 {lab=A4}
N 450 9510 540 9510 {lab=#net726}
N 400 9470 440 9470 {lab=#net17}
N 400 9510 400 9520 {lab=VDD}
N 430 9510 450 9510 {lab=#net726}
N 360 9510 370 9510 {lab=#net727}
N 440 9440 440 9470 {lab=#net17}
N 440 9470 440 9520 {lab=#net17}
N 350 9440 350 9520 {lab=A5}
N 270 9510 360 9510 {lab=#net727}
N 220 9470 260 9470 {lab=#net19}
N 220 9510 220 9520 {lab=VDD}
N 250 9510 270 9510 {lab=#net727}
N 180 9510 190 9510 {lab=#net728}
N 260 9440 260 9470 {lab=#net19}
N 260 9470 260 9520 {lab=#net19}
N 170 9440 170 9520 {lab=A6}
N 90 9510 180 9510 {lab=#net728}
N 40 9470 80 9470 {lab=#net20}
N 40 9510 40 9520 {lab=VDD}
N 70 9510 90 9510 {lab=#net728}
N 0 9510 10 9510 {lab=VDD}
N 80 9440 80 9470 {lab=#net20}
N 80 9470 80 9520 {lab=#net20}
N 0 9440 0 9520 { lab=VDD}
N 2570 9560 2580 9560 {lab=GND}
N 2580 9530 2580 9560 {lab=GND}
N 2570 9530 2580 9530 {lab=GND}
N 2530 9520 2530 9560 {lab=#net1}
N 2530 9560 2530 9600 {lab=#net1}
N 2520 9590 2570 9590 {lab=word119}
N 2570 9590 2610 9590 {lab=word119}
N 2440 9520 2440 9600 {lab=A6}
N 2430 9590 2520 9590 {lab=word119}
N 2390 9560 2400 9560 {lab=GND}
N 2400 9530 2400 9560 {lab=GND}
N 2390 9530 2400 9530 {lab=GND}
N 2350 9520 2350 9560 {lab=#net2}
N 2350 9560 2350 9600 {lab=#net2}
N 2340 9590 2390 9590 {lab=word119}
N 2390 9590 2430 9590 {lab=word119}
N 2260 9520 2260 9600 {lab=A5}
N 2250 9590 2340 9590 {lab=word119}
N 2210 9560 2220 9560 {lab=GND}
N 2220 9530 2220 9560 {lab=GND}
N 2210 9530 2220 9530 {lab=GND}
N 2170 9520 2170 9560 {lab=#net3}
N 2170 9560 2170 9600 {lab=#net3}
N 2160 9590 2210 9590 {lab=word119}
N 2210 9590 2250 9590 {lab=word119}
N 2080 9520 2080 9600 {lab=A4}
N 2070 9590 2160 9590 {lab=word119}
N 1990 9520 1990 9600 {lab=#net4}
N 1980 9590 2070 9590 {lab=word119}
N 1940 9560 1950 9560 {lab=GND}
N 1950 9530 1950 9560 {lab=GND}
N 1940 9530 1950 9530 {lab=GND}
N 1900 9520 1900 9560 {lab=A3}
N 1900 9560 1900 9600 {lab=A3}
N 1890 9590 1940 9590 {lab=word119}
N 1940 9590 1980 9590 {lab=word119}
N 1850 9560 1860 9560 {lab=GND}
N 1860 9530 1860 9560 {lab=GND}
N 1850 9530 1860 9530 {lab=GND}
N 1810 9520 1810 9560 {lab=#net5}
N 1810 9560 1810 9600 {lab=#net5}
N 1800 9590 1850 9590 {lab=word119}
N 1850 9590 1890 9590 {lab=word119}
N 1720 9520 1720 9600 {lab=A2}
N 1710 9590 1800 9590 {lab=word119}
N 1670 9560 1680 9560 {lab=GND}
N 1680 9530 1680 9560 {lab=GND}
N 1670 9530 1680 9530 {lab=GND}
N 1630 9520 1630 9560 {lab=#net6}
N 1630 9560 1630 9600 {lab=#net6}
N 1620 9590 1670 9590 {lab=word119}
N 1670 9590 1710 9590 {lab=word119}
N 1540 9520 1540 9600 {lab=A1}
N 1530 9590 1620 9590 {lab=word119}
N 1490 9560 1500 9560 {lab=GND}
N 1500 9530 1500 9560 {lab=GND}
N 1490 9530 1500 9530 {lab=GND}
N 1450 9520 1450 9560 {lab=#net7}
N 1450 9560 1450 9600 {lab=#net7}
N 1440 9590 1490 9590 {lab=word119}
N 1490 9590 1530 9590 {lab=word119}
N 1360 9520 1360 9600 {lab=A0}
N 1350 9590 1440 9590 {lab=word119}
N 1260 9590 1350 9590 { lab=word119}
N 1250 9520 1250 9600 {lab=A0}
N 1170 9590 1260 9590 {lab=word119}
N 1120 9550 1160 9550 {lab=#net9}
N 1120 9590 1120 9600 {lab=VDD}
N 1150 9590 1170 9590 {lab=word119}
N 1080 9590 1090 9590 {lab=#net729}
N 1160 9520 1160 9550 {lab=#net9}
N 1160 9550 1160 9600 {lab=#net9}
N 1070 9520 1070 9600 {lab=A1}
N 990 9590 1080 9590 {lab=#net729}
N 940 9550 980 9550 {lab=#net11}
N 940 9590 940 9600 {lab=VDD}
N 970 9590 990 9590 {lab=#net729}
N 900 9590 910 9590 {lab=#net730}
N 980 9520 980 9550 {lab=#net11}
N 980 9550 980 9600 {lab=#net11}
N 890 9520 890 9600 {lab=A2}
N 810 9590 900 9590 {lab=#net730}
N 760 9550 800 9550 {lab=#net13}
N 760 9590 760 9600 {lab=VDD}
N 790 9590 810 9590 {lab=#net730}
N 720 9590 730 9590 {lab=#net731}
N 800 9520 800 9550 {lab=#net13}
N 800 9550 800 9600 {lab=#net13}
N 670 9550 710 9550 {lab=A3}
N 670 9590 670 9600 {lab=VDD}
N 700 9590 720 9590 {lab=#net731}
N 630 9590 640 9590 {lab=#net732}
N 710 9520 710 9550 {lab=A3}
N 710 9550 710 9600 {lab=A3}
N 620 9520 620 9600 {lab=#net15}
N 540 9590 630 9590 {lab=#net732}
N 530 9520 530 9600 {lab=A4}
N 450 9590 540 9590 {lab=#net732}
N 400 9550 440 9550 {lab=#net17}
N 400 9590 400 9600 {lab=VDD}
N 430 9590 450 9590 {lab=#net732}
N 360 9590 370 9590 {lab=#net733}
N 440 9520 440 9550 {lab=#net17}
N 440 9550 440 9600 {lab=#net17}
N 350 9520 350 9600 {lab=A5}
N 270 9590 360 9590 {lab=#net733}
N 220 9550 260 9550 {lab=#net19}
N 220 9590 220 9600 {lab=VDD}
N 250 9590 270 9590 {lab=#net733}
N 180 9590 190 9590 {lab=#net734}
N 260 9520 260 9550 {lab=#net19}
N 260 9550 260 9600 {lab=#net19}
N 170 9520 170 9600 {lab=A6}
N 90 9590 180 9590 {lab=#net734}
N 40 9550 80 9550 {lab=#net20}
N 40 9590 40 9600 {lab=VDD}
N 70 9590 90 9590 {lab=#net734}
N 0 9590 10 9590 {lab=VDD}
N 80 9520 80 9550 {lab=#net20}
N 80 9550 80 9600 {lab=#net20}
N 0 9520 0 9600 { lab=VDD}
N 2570 9640 2580 9640 {lab=GND}
N 2580 9610 2580 9640 {lab=GND}
N 2570 9610 2580 9610 {lab=GND}
N 2530 9600 2530 9640 {lab=#net1}
N 2530 9640 2530 9680 {lab=#net1}
N 2520 9670 2570 9670 {lab=word120}
N 2570 9670 2610 9670 {lab=word120}
N 2440 9600 2440 9680 {lab=A6}
N 2430 9670 2520 9670 {lab=word120}
N 2390 9640 2400 9640 {lab=GND}
N 2400 9610 2400 9640 {lab=GND}
N 2390 9610 2400 9610 {lab=GND}
N 2350 9600 2350 9640 {lab=#net2}
N 2350 9640 2350 9680 {lab=#net2}
N 2340 9670 2390 9670 {lab=word120}
N 2390 9670 2430 9670 {lab=word120}
N 2260 9600 2260 9680 {lab=A5}
N 2250 9670 2340 9670 {lab=word120}
N 2210 9640 2220 9640 {lab=GND}
N 2220 9610 2220 9640 {lab=GND}
N 2210 9610 2220 9610 {lab=GND}
N 2170 9600 2170 9640 {lab=#net3}
N 2170 9640 2170 9680 {lab=#net3}
N 2160 9670 2210 9670 {lab=word120}
N 2210 9670 2250 9670 {lab=word120}
N 2080 9600 2080 9680 {lab=A4}
N 2070 9670 2160 9670 {lab=word120}
N 2030 9640 2040 9640 {lab=GND}
N 2040 9610 2040 9640 {lab=GND}
N 2030 9610 2040 9610 {lab=GND}
N 1990 9600 1990 9640 {lab=#net4}
N 1990 9640 1990 9680 {lab=#net4}
N 1980 9670 2030 9670 {lab=word120}
N 2030 9670 2070 9670 {lab=word120}
N 1900 9600 1900 9680 {lab=A3}
N 1890 9670 1980 9670 {lab=word120}
N 1810 9600 1810 9680 {lab=#net5}
N 1800 9670 1890 9670 {lab=word120}
N 1760 9640 1770 9640 {lab=GND}
N 1770 9610 1770 9640 {lab=GND}
N 1760 9610 1770 9610 {lab=GND}
N 1720 9600 1720 9640 {lab=A2}
N 1720 9640 1720 9680 {lab=A2}
N 1710 9670 1760 9670 {lab=word120}
N 1760 9670 1800 9670 {lab=word120}
N 1630 9600 1630 9680 {lab=#net6}
N 1620 9670 1710 9670 {lab=word120}
N 1580 9640 1590 9640 {lab=GND}
N 1590 9610 1590 9640 {lab=GND}
N 1580 9610 1590 9610 {lab=GND}
N 1540 9600 1540 9640 {lab=A1}
N 1540 9640 1540 9680 {lab=A1}
N 1530 9670 1580 9670 {lab=word120}
N 1580 9670 1620 9670 {lab=word120}
N 1450 9600 1450 9680 {lab=#net7}
N 1440 9670 1530 9670 {lab=word120}
N 1400 9640 1410 9640 {lab=GND}
N 1410 9610 1410 9640 {lab=GND}
N 1400 9610 1410 9610 {lab=GND}
N 1360 9600 1360 9640 {lab=A0}
N 1360 9640 1360 9680 {lab=A0}
N 1350 9670 1400 9670 {lab=word120}
N 1400 9670 1440 9670 {lab=word120}
N 1260 9670 1350 9670 { lab=word120}
N 1210 9630 1250 9630 {lab=A0}
N 1210 9670 1210 9680 {lab=VDD}
N 1240 9670 1260 9670 {lab=word120}
N 1170 9670 1180 9670 {lab=#net735}
N 1250 9600 1250 9630 {lab=A0}
N 1250 9630 1250 9680 {lab=A0}
N 1160 9600 1160 9680 {lab=#net9}
N 1080 9670 1170 9670 {lab=#net735}
N 1030 9630 1070 9630 {lab=A1}
N 1030 9670 1030 9680 {lab=VDD}
N 1060 9670 1080 9670 {lab=#net735}
N 990 9670 1000 9670 {lab=#net736}
N 1070 9600 1070 9630 {lab=A1}
N 1070 9630 1070 9680 {lab=A1}
N 980 9600 980 9680 {lab=#net11}
N 900 9670 990 9670 {lab=#net736}
N 850 9630 890 9630 {lab=A2}
N 850 9670 850 9680 {lab=VDD}
N 880 9670 900 9670 {lab=#net736}
N 810 9670 820 9670 {lab=#net737}
N 890 9600 890 9630 {lab=A2}
N 890 9630 890 9680 {lab=A2}
N 800 9600 800 9680 {lab=#net13}
N 720 9670 810 9670 {lab=#net737}
N 710 9600 710 9680 {lab=A3}
N 630 9670 720 9670 {lab=#net737}
N 580 9630 620 9630 {lab=#net15}
N 580 9670 580 9680 {lab=VDD}
N 610 9670 630 9670 {lab=#net737}
N 540 9670 550 9670 {lab=#net738}
N 620 9600 620 9630 {lab=#net15}
N 620 9630 620 9680 {lab=#net15}
N 530 9600 530 9680 {lab=A4}
N 450 9670 540 9670 {lab=#net738}
N 400 9630 440 9630 {lab=#net17}
N 400 9670 400 9680 {lab=VDD}
N 430 9670 450 9670 {lab=#net738}
N 360 9670 370 9670 {lab=#net739}
N 440 9600 440 9630 {lab=#net17}
N 440 9630 440 9680 {lab=#net17}
N 350 9600 350 9680 {lab=A5}
N 270 9670 360 9670 {lab=#net739}
N 220 9630 260 9630 {lab=#net19}
N 220 9670 220 9680 {lab=VDD}
N 250 9670 270 9670 {lab=#net739}
N 180 9670 190 9670 {lab=#net740}
N 260 9600 260 9630 {lab=#net19}
N 260 9630 260 9680 {lab=#net19}
N 170 9600 170 9680 {lab=A6}
N 90 9670 180 9670 {lab=#net740}
N 40 9630 80 9630 {lab=#net20}
N 40 9670 40 9680 {lab=VDD}
N 70 9670 90 9670 {lab=#net740}
N 0 9670 10 9670 {lab=VDD}
N 80 9600 80 9630 {lab=#net20}
N 80 9630 80 9680 {lab=#net20}
N 0 9600 0 9680 { lab=VDD}
N 2570 9720 2580 9720 {lab=GND}
N 2580 9690 2580 9720 {lab=GND}
N 2570 9690 2580 9690 {lab=GND}
N 2530 9680 2530 9720 {lab=#net1}
N 2530 9720 2530 9760 {lab=#net1}
N 2520 9750 2570 9750 {lab=word121}
N 2570 9750 2610 9750 {lab=word121}
N 2440 9680 2440 9760 {lab=A6}
N 2430 9750 2520 9750 {lab=word121}
N 2390 9720 2400 9720 {lab=GND}
N 2400 9690 2400 9720 {lab=GND}
N 2390 9690 2400 9690 {lab=GND}
N 2350 9680 2350 9720 {lab=#net2}
N 2350 9720 2350 9760 {lab=#net2}
N 2340 9750 2390 9750 {lab=word121}
N 2390 9750 2430 9750 {lab=word121}
N 2260 9680 2260 9760 {lab=A5}
N 2250 9750 2340 9750 {lab=word121}
N 2210 9720 2220 9720 {lab=GND}
N 2220 9690 2220 9720 {lab=GND}
N 2210 9690 2220 9690 {lab=GND}
N 2170 9680 2170 9720 {lab=#net3}
N 2170 9720 2170 9760 {lab=#net3}
N 2160 9750 2210 9750 {lab=word121}
N 2210 9750 2250 9750 {lab=word121}
N 2080 9680 2080 9760 {lab=A4}
N 2070 9750 2160 9750 {lab=word121}
N 2030 9720 2040 9720 {lab=GND}
N 2040 9690 2040 9720 {lab=GND}
N 2030 9690 2040 9690 {lab=GND}
N 1990 9680 1990 9720 {lab=#net4}
N 1990 9720 1990 9760 {lab=#net4}
N 1980 9750 2030 9750 {lab=word121}
N 2030 9750 2070 9750 {lab=word121}
N 1900 9680 1900 9760 {lab=A3}
N 1890 9750 1980 9750 {lab=word121}
N 1810 9680 1810 9760 {lab=#net5}
N 1800 9750 1890 9750 {lab=word121}
N 1760 9720 1770 9720 {lab=GND}
N 1770 9690 1770 9720 {lab=GND}
N 1760 9690 1770 9690 {lab=GND}
N 1720 9680 1720 9720 {lab=A2}
N 1720 9720 1720 9760 {lab=A2}
N 1710 9750 1760 9750 {lab=word121}
N 1760 9750 1800 9750 {lab=word121}
N 1630 9680 1630 9760 {lab=#net6}
N 1620 9750 1710 9750 {lab=word121}
N 1580 9720 1590 9720 {lab=GND}
N 1590 9690 1590 9720 {lab=GND}
N 1580 9690 1590 9690 {lab=GND}
N 1540 9680 1540 9720 {lab=A1}
N 1540 9720 1540 9760 {lab=A1}
N 1530 9750 1580 9750 {lab=word121}
N 1580 9750 1620 9750 {lab=word121}
N 1490 9720 1500 9720 {lab=GND}
N 1500 9690 1500 9720 {lab=GND}
N 1490 9690 1500 9690 {lab=GND}
N 1450 9680 1450 9720 {lab=#net7}
N 1450 9720 1450 9760 {lab=#net7}
N 1440 9750 1490 9750 {lab=word121}
N 1490 9750 1530 9750 {lab=word121}
N 1360 9680 1360 9760 {lab=A0}
N 1350 9750 1440 9750 {lab=word121}
N 1260 9750 1350 9750 { lab=word121}
N 1250 9680 1250 9760 {lab=A0}
N 1170 9750 1260 9750 {lab=word121}
N 1120 9710 1160 9710 {lab=#net9}
N 1120 9750 1120 9760 {lab=VDD}
N 1150 9750 1170 9750 {lab=word121}
N 1080 9750 1090 9750 {lab=#net741}
N 1160 9680 1160 9710 {lab=#net9}
N 1160 9710 1160 9760 {lab=#net9}
N 1030 9710 1070 9710 {lab=A1}
N 1030 9750 1030 9760 {lab=VDD}
N 1060 9750 1080 9750 {lab=#net741}
N 990 9750 1000 9750 {lab=#net742}
N 1070 9680 1070 9710 {lab=A1}
N 1070 9710 1070 9760 {lab=A1}
N 980 9680 980 9760 {lab=#net11}
N 900 9750 990 9750 {lab=#net742}
N 850 9710 890 9710 {lab=A2}
N 850 9750 850 9760 {lab=VDD}
N 880 9750 900 9750 {lab=#net742}
N 810 9750 820 9750 {lab=#net743}
N 890 9680 890 9710 {lab=A2}
N 890 9710 890 9760 {lab=A2}
N 800 9680 800 9760 {lab=#net13}
N 720 9750 810 9750 {lab=#net743}
N 710 9680 710 9760 {lab=A3}
N 630 9750 720 9750 {lab=#net743}
N 580 9710 620 9710 {lab=#net15}
N 580 9750 580 9760 {lab=VDD}
N 610 9750 630 9750 {lab=#net743}
N 540 9750 550 9750 {lab=#net744}
N 620 9680 620 9710 {lab=#net15}
N 620 9710 620 9760 {lab=#net15}
N 530 9680 530 9760 {lab=A4}
N 450 9750 540 9750 {lab=#net744}
N 400 9710 440 9710 {lab=#net17}
N 400 9750 400 9760 {lab=VDD}
N 430 9750 450 9750 {lab=#net744}
N 360 9750 370 9750 {lab=#net745}
N 440 9680 440 9710 {lab=#net17}
N 440 9710 440 9760 {lab=#net17}
N 350 9680 350 9760 {lab=A5}
N 270 9750 360 9750 {lab=#net745}
N 220 9710 260 9710 {lab=#net19}
N 220 9750 220 9760 {lab=VDD}
N 250 9750 270 9750 {lab=#net745}
N 180 9750 190 9750 {lab=#net746}
N 260 9680 260 9710 {lab=#net19}
N 260 9710 260 9760 {lab=#net19}
N 170 9680 170 9760 {lab=A6}
N 90 9750 180 9750 {lab=#net746}
N 40 9710 80 9710 {lab=#net20}
N 40 9750 40 9760 {lab=VDD}
N 70 9750 90 9750 {lab=#net746}
N 0 9750 10 9750 {lab=VDD}
N 80 9680 80 9710 {lab=#net20}
N 80 9710 80 9760 {lab=#net20}
N 0 9680 0 9760 { lab=VDD}
N 2570 9800 2580 9800 {lab=GND}
N 2580 9770 2580 9800 {lab=GND}
N 2570 9770 2580 9770 {lab=GND}
N 2530 9760 2530 9800 {lab=#net1}
N 2530 9800 2530 9840 {lab=#net1}
N 2520 9830 2570 9830 {lab=word122}
N 2570 9830 2610 9830 {lab=word122}
N 2440 9760 2440 9840 {lab=A6}
N 2430 9830 2520 9830 {lab=word122}
N 2390 9800 2400 9800 {lab=GND}
N 2400 9770 2400 9800 {lab=GND}
N 2390 9770 2400 9770 {lab=GND}
N 2350 9760 2350 9800 {lab=#net2}
N 2350 9800 2350 9840 {lab=#net2}
N 2340 9830 2390 9830 {lab=word122}
N 2390 9830 2430 9830 {lab=word122}
N 2260 9760 2260 9840 {lab=A5}
N 2250 9830 2340 9830 {lab=word122}
N 2210 9800 2220 9800 {lab=GND}
N 2220 9770 2220 9800 {lab=GND}
N 2210 9770 2220 9770 {lab=GND}
N 2170 9760 2170 9800 {lab=#net3}
N 2170 9800 2170 9840 {lab=#net3}
N 2160 9830 2210 9830 {lab=word122}
N 2210 9830 2250 9830 {lab=word122}
N 2080 9760 2080 9840 {lab=A4}
N 2070 9830 2160 9830 {lab=word122}
N 2030 9800 2040 9800 {lab=GND}
N 2040 9770 2040 9800 {lab=GND}
N 2030 9770 2040 9770 {lab=GND}
N 1990 9760 1990 9800 {lab=#net4}
N 1990 9800 1990 9840 {lab=#net4}
N 1980 9830 2030 9830 {lab=word122}
N 2030 9830 2070 9830 {lab=word122}
N 1900 9760 1900 9840 {lab=A3}
N 1890 9830 1980 9830 {lab=word122}
N 1810 9760 1810 9840 {lab=#net5}
N 1800 9830 1890 9830 {lab=word122}
N 1760 9800 1770 9800 {lab=GND}
N 1770 9770 1770 9800 {lab=GND}
N 1760 9770 1770 9770 {lab=GND}
N 1720 9760 1720 9800 {lab=A2}
N 1720 9800 1720 9840 {lab=A2}
N 1710 9830 1760 9830 {lab=word122}
N 1760 9830 1800 9830 {lab=word122}
N 1670 9800 1680 9800 {lab=GND}
N 1680 9770 1680 9800 {lab=GND}
N 1670 9770 1680 9770 {lab=GND}
N 1630 9760 1630 9800 {lab=#net6}
N 1630 9800 1630 9840 {lab=#net6}
N 1620 9830 1670 9830 {lab=word122}
N 1670 9830 1710 9830 {lab=word122}
N 1540 9760 1540 9840 {lab=A1}
N 1530 9830 1620 9830 {lab=word122}
N 1450 9760 1450 9840 {lab=#net7}
N 1440 9830 1530 9830 {lab=word122}
N 1400 9800 1410 9800 {lab=GND}
N 1410 9770 1410 9800 {lab=GND}
N 1400 9770 1410 9770 {lab=GND}
N 1360 9760 1360 9800 {lab=A0}
N 1360 9800 1360 9840 {lab=A0}
N 1350 9830 1400 9830 {lab=word122}
N 1400 9830 1440 9830 {lab=word122}
N 1260 9830 1350 9830 { lab=word122}
N 1210 9790 1250 9790 {lab=A0}
N 1210 9830 1210 9840 {lab=VDD}
N 1240 9830 1260 9830 {lab=word122}
N 1170 9830 1180 9830 {lab=#net747}
N 1250 9760 1250 9790 {lab=A0}
N 1250 9790 1250 9840 {lab=A0}
N 1160 9760 1160 9840 {lab=#net9}
N 1080 9830 1170 9830 {lab=#net747}
N 1070 9760 1070 9840 {lab=A1}
N 990 9830 1080 9830 {lab=#net747}
N 940 9790 980 9790 {lab=#net11}
N 940 9830 940 9840 {lab=VDD}
N 970 9830 990 9830 {lab=#net747}
N 900 9830 910 9830 {lab=#net748}
N 980 9760 980 9790 {lab=#net11}
N 980 9790 980 9840 {lab=#net11}
N 850 9790 890 9790 {lab=A2}
N 850 9830 850 9840 {lab=VDD}
N 880 9830 900 9830 {lab=#net748}
N 810 9830 820 9830 {lab=#net749}
N 890 9760 890 9790 {lab=A2}
N 890 9790 890 9840 {lab=A2}
N 800 9760 800 9840 {lab=#net13}
N 720 9830 810 9830 {lab=#net749}
N 710 9760 710 9840 {lab=A3}
N 630 9830 720 9830 {lab=#net749}
N 580 9790 620 9790 {lab=#net15}
N 580 9830 580 9840 {lab=VDD}
N 610 9830 630 9830 {lab=#net749}
N 540 9830 550 9830 {lab=#net750}
N 620 9760 620 9790 {lab=#net15}
N 620 9790 620 9840 {lab=#net15}
N 530 9760 530 9840 {lab=A4}
N 450 9830 540 9830 {lab=#net750}
N 400 9790 440 9790 {lab=#net17}
N 400 9830 400 9840 {lab=VDD}
N 430 9830 450 9830 {lab=#net750}
N 360 9830 370 9830 {lab=#net751}
N 440 9760 440 9790 {lab=#net17}
N 440 9790 440 9840 {lab=#net17}
N 350 9760 350 9840 {lab=A5}
N 270 9830 360 9830 {lab=#net751}
N 220 9790 260 9790 {lab=#net19}
N 220 9830 220 9840 {lab=VDD}
N 250 9830 270 9830 {lab=#net751}
N 180 9830 190 9830 {lab=#net752}
N 260 9760 260 9790 {lab=#net19}
N 260 9790 260 9840 {lab=#net19}
N 170 9760 170 9840 {lab=A6}
N 90 9830 180 9830 {lab=#net752}
N 40 9790 80 9790 {lab=#net20}
N 40 9830 40 9840 {lab=VDD}
N 70 9830 90 9830 {lab=#net752}
N 0 9830 10 9830 {lab=VDD}
N 80 9760 80 9790 {lab=#net20}
N 80 9790 80 9840 {lab=#net20}
N 0 9760 0 9840 { lab=VDD}
N 2570 9880 2580 9880 {lab=GND}
N 2580 9850 2580 9880 {lab=GND}
N 2570 9850 2580 9850 {lab=GND}
N 2530 9840 2530 9880 {lab=#net1}
N 2530 9880 2530 9920 {lab=#net1}
N 2520 9910 2570 9910 {lab=word123}
N 2570 9910 2610 9910 {lab=word123}
N 2440 9840 2440 9920 {lab=A6}
N 2430 9910 2520 9910 {lab=word123}
N 2390 9880 2400 9880 {lab=GND}
N 2400 9850 2400 9880 {lab=GND}
N 2390 9850 2400 9850 {lab=GND}
N 2350 9840 2350 9880 {lab=#net2}
N 2350 9880 2350 9920 {lab=#net2}
N 2340 9910 2390 9910 {lab=word123}
N 2390 9910 2430 9910 {lab=word123}
N 2260 9840 2260 9920 {lab=A5}
N 2250 9910 2340 9910 {lab=word123}
N 2210 9880 2220 9880 {lab=GND}
N 2220 9850 2220 9880 {lab=GND}
N 2210 9850 2220 9850 {lab=GND}
N 2170 9840 2170 9880 {lab=#net3}
N 2170 9880 2170 9920 {lab=#net3}
N 2160 9910 2210 9910 {lab=word123}
N 2210 9910 2250 9910 {lab=word123}
N 2080 9840 2080 9920 {lab=A4}
N 2070 9910 2160 9910 {lab=word123}
N 2030 9880 2040 9880 {lab=GND}
N 2040 9850 2040 9880 {lab=GND}
N 2030 9850 2040 9850 {lab=GND}
N 1990 9840 1990 9880 {lab=#net4}
N 1990 9880 1990 9920 {lab=#net4}
N 1980 9910 2030 9910 {lab=word123}
N 2030 9910 2070 9910 {lab=word123}
N 1900 9840 1900 9920 {lab=A3}
N 1890 9910 1980 9910 {lab=word123}
N 1810 9840 1810 9920 {lab=#net5}
N 1800 9910 1890 9910 {lab=word123}
N 1760 9880 1770 9880 {lab=GND}
N 1770 9850 1770 9880 {lab=GND}
N 1760 9850 1770 9850 {lab=GND}
N 1720 9840 1720 9880 {lab=A2}
N 1720 9880 1720 9920 {lab=A2}
N 1710 9910 1760 9910 {lab=word123}
N 1760 9910 1800 9910 {lab=word123}
N 1670 9880 1680 9880 {lab=GND}
N 1680 9850 1680 9880 {lab=GND}
N 1670 9850 1680 9850 {lab=GND}
N 1630 9840 1630 9880 {lab=#net6}
N 1630 9880 1630 9920 {lab=#net6}
N 1620 9910 1670 9910 {lab=word123}
N 1670 9910 1710 9910 {lab=word123}
N 1540 9840 1540 9920 {lab=A1}
N 1530 9910 1620 9910 {lab=word123}
N 1490 9880 1500 9880 {lab=GND}
N 1500 9850 1500 9880 {lab=GND}
N 1490 9850 1500 9850 {lab=GND}
N 1450 9840 1450 9880 {lab=#net7}
N 1450 9880 1450 9920 {lab=#net7}
N 1440 9910 1490 9910 {lab=word123}
N 1490 9910 1530 9910 {lab=word123}
N 1360 9840 1360 9920 {lab=A0}
N 1350 9910 1440 9910 {lab=word123}
N 1260 9910 1350 9910 { lab=word123}
N 1250 9840 1250 9920 {lab=A0}
N 1170 9910 1260 9910 {lab=word123}
N 1120 9870 1160 9870 {lab=#net9}
N 1120 9910 1120 9920 {lab=VDD}
N 1150 9910 1170 9910 {lab=word123}
N 1080 9910 1090 9910 {lab=#net753}
N 1160 9840 1160 9870 {lab=#net9}
N 1160 9870 1160 9920 {lab=#net9}
N 1070 9840 1070 9920 {lab=A1}
N 990 9910 1080 9910 {lab=#net753}
N 940 9870 980 9870 {lab=#net11}
N 940 9910 940 9920 {lab=VDD}
N 970 9910 990 9910 {lab=#net753}
N 900 9910 910 9910 {lab=#net754}
N 980 9840 980 9870 {lab=#net11}
N 980 9870 980 9920 {lab=#net11}
N 850 9870 890 9870 {lab=A2}
N 850 9910 850 9920 {lab=VDD}
N 880 9910 900 9910 {lab=#net754}
N 810 9910 820 9910 {lab=#net755}
N 890 9840 890 9870 {lab=A2}
N 890 9870 890 9920 {lab=A2}
N 800 9840 800 9920 {lab=#net13}
N 720 9910 810 9910 {lab=#net755}
N 710 9840 710 9920 {lab=A3}
N 630 9910 720 9910 {lab=#net755}
N 580 9870 620 9870 {lab=#net15}
N 580 9910 580 9920 {lab=VDD}
N 610 9910 630 9910 {lab=#net755}
N 540 9910 550 9910 {lab=#net756}
N 620 9840 620 9870 {lab=#net15}
N 620 9870 620 9920 {lab=#net15}
N 530 9840 530 9920 {lab=A4}
N 450 9910 540 9910 {lab=#net756}
N 400 9870 440 9870 {lab=#net17}
N 400 9910 400 9920 {lab=VDD}
N 430 9910 450 9910 {lab=#net756}
N 360 9910 370 9910 {lab=#net757}
N 440 9840 440 9870 {lab=#net17}
N 440 9870 440 9920 {lab=#net17}
N 350 9840 350 9920 {lab=A5}
N 270 9910 360 9910 {lab=#net757}
N 220 9870 260 9870 {lab=#net19}
N 220 9910 220 9920 {lab=VDD}
N 250 9910 270 9910 {lab=#net757}
N 180 9910 190 9910 {lab=#net758}
N 260 9840 260 9870 {lab=#net19}
N 260 9870 260 9920 {lab=#net19}
N 170 9840 170 9920 {lab=A6}
N 90 9910 180 9910 {lab=#net758}
N 40 9870 80 9870 {lab=#net20}
N 40 9910 40 9920 {lab=VDD}
N 70 9910 90 9910 {lab=#net758}
N 0 9910 10 9910 {lab=VDD}
N 80 9840 80 9870 {lab=#net20}
N 80 9870 80 9920 {lab=#net20}
N 0 9840 0 9920 { lab=VDD}
N 2570 9960 2580 9960 {lab=GND}
N 2580 9930 2580 9960 {lab=GND}
N 2570 9930 2580 9930 {lab=GND}
N 2530 9920 2530 9960 {lab=#net1}
N 2530 9960 2530 10000 {lab=#net1}
N 2520 9990 2570 9990 {lab=word124}
N 2570 9990 2610 9990 {lab=word124}
N 2440 9920 2440 10000 {lab=A6}
N 2430 9990 2520 9990 {lab=word124}
N 2390 9960 2400 9960 {lab=GND}
N 2400 9930 2400 9960 {lab=GND}
N 2390 9930 2400 9930 {lab=GND}
N 2350 9920 2350 9960 {lab=#net2}
N 2350 9960 2350 10000 {lab=#net2}
N 2340 9990 2390 9990 {lab=word124}
N 2390 9990 2430 9990 {lab=word124}
N 2260 9920 2260 10000 {lab=A5}
N 2250 9990 2340 9990 {lab=word124}
N 2210 9960 2220 9960 {lab=GND}
N 2220 9930 2220 9960 {lab=GND}
N 2210 9930 2220 9930 {lab=GND}
N 2170 9920 2170 9960 {lab=#net3}
N 2170 9960 2170 10000 {lab=#net3}
N 2160 9990 2210 9990 {lab=word124}
N 2210 9990 2250 9990 {lab=word124}
N 2080 9920 2080 10000 {lab=A4}
N 2070 9990 2160 9990 {lab=word124}
N 2030 9960 2040 9960 {lab=GND}
N 2040 9930 2040 9960 {lab=GND}
N 2030 9930 2040 9930 {lab=GND}
N 1990 9920 1990 9960 {lab=#net4}
N 1990 9960 1990 10000 {lab=#net4}
N 1980 9990 2030 9990 {lab=word124}
N 2030 9990 2070 9990 {lab=word124}
N 1900 9920 1900 10000 {lab=A3}
N 1890 9990 1980 9990 {lab=word124}
N 1850 9960 1860 9960 {lab=GND}
N 1860 9930 1860 9960 {lab=GND}
N 1850 9930 1860 9930 {lab=GND}
N 1810 9920 1810 9960 {lab=#net5}
N 1810 9960 1810 10000 {lab=#net5}
N 1800 9990 1850 9990 {lab=word124}
N 1850 9990 1890 9990 {lab=word124}
N 1720 9920 1720 10000 {lab=A2}
N 1710 9990 1800 9990 {lab=word124}
N 1630 9920 1630 10000 {lab=#net6}
N 1620 9990 1710 9990 {lab=word124}
N 1580 9960 1590 9960 {lab=GND}
N 1590 9930 1590 9960 {lab=GND}
N 1580 9930 1590 9930 {lab=GND}
N 1540 9920 1540 9960 {lab=A1}
N 1540 9960 1540 10000 {lab=A1}
N 1530 9990 1580 9990 {lab=word124}
N 1580 9990 1620 9990 {lab=word124}
N 1450 9920 1450 10000 {lab=#net7}
N 1440 9990 1530 9990 {lab=word124}
N 1400 9960 1410 9960 {lab=GND}
N 1410 9930 1410 9960 {lab=GND}
N 1400 9930 1410 9930 {lab=GND}
N 1360 9920 1360 9960 {lab=A0}
N 1360 9960 1360 10000 {lab=A0}
N 1350 9990 1400 9990 {lab=word124}
N 1400 9990 1440 9990 {lab=word124}
N 1260 9990 1350 9990 { lab=word124}
N 1210 9950 1250 9950 {lab=A0}
N 1210 9990 1210 10000 {lab=VDD}
N 1240 9990 1260 9990 {lab=word124}
N 1170 9990 1180 9990 {lab=#net759}
N 1250 9920 1250 9950 {lab=A0}
N 1250 9950 1250 10000 {lab=A0}
N 1160 9920 1160 10000 {lab=#net9}
N 1080 9990 1170 9990 {lab=#net759}
N 1030 9950 1070 9950 {lab=A1}
N 1030 9990 1030 10000 {lab=VDD}
N 1060 9990 1080 9990 {lab=#net759}
N 990 9990 1000 9990 {lab=#net760}
N 1070 9920 1070 9950 {lab=A1}
N 1070 9950 1070 10000 {lab=A1}
N 980 9920 980 10000 {lab=#net11}
N 900 9990 990 9990 {lab=#net760}
N 890 9920 890 10000 {lab=A2}
N 810 9990 900 9990 {lab=#net760}
N 760 9950 800 9950 {lab=#net13}
N 760 9990 760 10000 {lab=VDD}
N 790 9990 810 9990 {lab=#net760}
N 720 9990 730 9990 {lab=#net761}
N 800 9920 800 9950 {lab=#net13}
N 800 9950 800 10000 {lab=#net13}
N 710 9920 710 10000 {lab=A3}
N 630 9990 720 9990 {lab=#net761}
N 580 9950 620 9950 {lab=#net15}
N 580 9990 580 10000 {lab=VDD}
N 610 9990 630 9990 {lab=#net761}
N 540 9990 550 9990 {lab=#net762}
N 620 9920 620 9950 {lab=#net15}
N 620 9950 620 10000 {lab=#net15}
N 530 9920 530 10000 {lab=A4}
N 450 9990 540 9990 {lab=#net762}
N 400 9950 440 9950 {lab=#net17}
N 400 9990 400 10000 {lab=VDD}
N 430 9990 450 9990 {lab=#net762}
N 360 9990 370 9990 {lab=#net763}
N 440 9920 440 9950 {lab=#net17}
N 440 9950 440 10000 {lab=#net17}
N 350 9920 350 10000 {lab=A5}
N 270 9990 360 9990 {lab=#net763}
N 220 9950 260 9950 {lab=#net19}
N 220 9990 220 10000 {lab=VDD}
N 250 9990 270 9990 {lab=#net763}
N 180 9990 190 9990 {lab=#net764}
N 260 9920 260 9950 {lab=#net19}
N 260 9950 260 10000 {lab=#net19}
N 170 9920 170 10000 {lab=A6}
N 90 9990 180 9990 {lab=#net764}
N 40 9950 80 9950 {lab=#net20}
N 40 9990 40 10000 {lab=VDD}
N 70 9990 90 9990 {lab=#net764}
N 0 9990 10 9990 {lab=VDD}
N 80 9920 80 9950 {lab=#net20}
N 80 9950 80 10000 {lab=#net20}
N 0 9920 0 10000 { lab=VDD}
N 2570 10040 2580 10040 {lab=GND}
N 2580 10010 2580 10040 {lab=GND}
N 2570 10010 2580 10010 {lab=GND}
N 2530 10000 2530 10040 {lab=#net1}
N 2530 10040 2530 10080 {lab=#net1}
N 2520 10070 2570 10070 {lab=word125}
N 2570 10070 2610 10070 {lab=word125}
N 2440 10000 2440 10080 {lab=A6}
N 2430 10070 2520 10070 {lab=word125}
N 2390 10040 2400 10040 {lab=GND}
N 2400 10010 2400 10040 {lab=GND}
N 2390 10010 2400 10010 {lab=GND}
N 2350 10000 2350 10040 {lab=#net2}
N 2350 10040 2350 10080 {lab=#net2}
N 2340 10070 2390 10070 {lab=word125}
N 2390 10070 2430 10070 {lab=word125}
N 2260 10000 2260 10080 {lab=A5}
N 2250 10070 2340 10070 {lab=word125}
N 2210 10040 2220 10040 {lab=GND}
N 2220 10010 2220 10040 {lab=GND}
N 2210 10010 2220 10010 {lab=GND}
N 2170 10000 2170 10040 {lab=#net3}
N 2170 10040 2170 10080 {lab=#net3}
N 2160 10070 2210 10070 {lab=word125}
N 2210 10070 2250 10070 {lab=word125}
N 2080 10000 2080 10080 {lab=A4}
N 2070 10070 2160 10070 {lab=word125}
N 2030 10040 2040 10040 {lab=GND}
N 2040 10010 2040 10040 {lab=GND}
N 2030 10010 2040 10010 {lab=GND}
N 1990 10000 1990 10040 {lab=#net4}
N 1990 10040 1990 10080 {lab=#net4}
N 1980 10070 2030 10070 {lab=word125}
N 2030 10070 2070 10070 {lab=word125}
N 1900 10000 1900 10080 {lab=A3}
N 1890 10070 1980 10070 {lab=word125}
N 1850 10040 1860 10040 {lab=GND}
N 1860 10010 1860 10040 {lab=GND}
N 1850 10010 1860 10010 {lab=GND}
N 1810 10000 1810 10040 {lab=#net5}
N 1810 10040 1810 10080 {lab=#net5}
N 1800 10070 1850 10070 {lab=word125}
N 1850 10070 1890 10070 {lab=word125}
N 1720 10000 1720 10080 {lab=A2}
N 1710 10070 1800 10070 {lab=word125}
N 1630 10000 1630 10080 {lab=#net6}
N 1620 10070 1710 10070 {lab=word125}
N 1580 10040 1590 10040 {lab=GND}
N 1590 10010 1590 10040 {lab=GND}
N 1580 10010 1590 10010 {lab=GND}
N 1540 10000 1540 10040 {lab=A1}
N 1540 10040 1540 10080 {lab=A1}
N 1530 10070 1580 10070 {lab=word125}
N 1580 10070 1620 10070 {lab=word125}
N 1490 10040 1500 10040 {lab=GND}
N 1500 10010 1500 10040 {lab=GND}
N 1490 10010 1500 10010 {lab=GND}
N 1450 10000 1450 10040 {lab=#net7}
N 1450 10040 1450 10080 {lab=#net7}
N 1440 10070 1490 10070 {lab=word125}
N 1490 10070 1530 10070 {lab=word125}
N 1360 10000 1360 10080 {lab=A0}
N 1350 10070 1440 10070 {lab=word125}
N 1260 10070 1350 10070 { lab=word125}
N 1250 10000 1250 10080 {lab=A0}
N 1170 10070 1260 10070 {lab=word125}
N 1120 10030 1160 10030 {lab=#net9}
N 1120 10070 1120 10080 {lab=VDD}
N 1150 10070 1170 10070 {lab=word125}
N 1080 10070 1090 10070 {lab=#net765}
N 1160 10000 1160 10030 {lab=#net9}
N 1160 10030 1160 10080 {lab=#net9}
N 1030 10030 1070 10030 {lab=A1}
N 1030 10070 1030 10080 {lab=VDD}
N 1060 10070 1080 10070 {lab=#net765}
N 990 10070 1000 10070 {lab=#net766}
N 1070 10000 1070 10030 {lab=A1}
N 1070 10030 1070 10080 {lab=A1}
N 980 10000 980 10080 {lab=#net11}
N 900 10070 990 10070 {lab=#net766}
N 890 10000 890 10080 {lab=A2}
N 810 10070 900 10070 {lab=#net766}
N 760 10030 800 10030 {lab=#net13}
N 760 10070 760 10080 {lab=VDD}
N 790 10070 810 10070 {lab=#net766}
N 720 10070 730 10070 {lab=#net767}
N 800 10000 800 10030 {lab=#net13}
N 800 10030 800 10080 {lab=#net13}
N 710 10000 710 10080 {lab=A3}
N 630 10070 720 10070 {lab=#net767}
N 580 10030 620 10030 {lab=#net15}
N 580 10070 580 10080 {lab=VDD}
N 610 10070 630 10070 {lab=#net767}
N 540 10070 550 10070 {lab=#net768}
N 620 10000 620 10030 {lab=#net15}
N 620 10030 620 10080 {lab=#net15}
N 530 10000 530 10080 {lab=A4}
N 450 10070 540 10070 {lab=#net768}
N 400 10030 440 10030 {lab=#net17}
N 400 10070 400 10080 {lab=VDD}
N 430 10070 450 10070 {lab=#net768}
N 360 10070 370 10070 {lab=#net769}
N 440 10000 440 10030 {lab=#net17}
N 440 10030 440 10080 {lab=#net17}
N 350 10000 350 10080 {lab=A5}
N 270 10070 360 10070 {lab=#net769}
N 220 10030 260 10030 {lab=#net19}
N 220 10070 220 10080 {lab=VDD}
N 250 10070 270 10070 {lab=#net769}
N 180 10070 190 10070 {lab=#net770}
N 260 10000 260 10030 {lab=#net19}
N 260 10030 260 10080 {lab=#net19}
N 170 10000 170 10080 {lab=A6}
N 90 10070 180 10070 {lab=#net770}
N 40 10030 80 10030 {lab=#net20}
N 40 10070 40 10080 {lab=VDD}
N 70 10070 90 10070 {lab=#net770}
N 0 10070 10 10070 {lab=VDD}
N 80 10000 80 10030 {lab=#net20}
N 80 10030 80 10080 {lab=#net20}
N 0 10000 0 10080 { lab=VDD}
N 2570 10120 2580 10120 {lab=GND}
N 2580 10090 2580 10120 {lab=GND}
N 2570 10090 2580 10090 {lab=GND}
N 2530 10080 2530 10120 {lab=#net1}
N 2530 10120 2530 10160 {lab=#net1}
N 2520 10150 2570 10150 {lab=word126}
N 2570 10150 2610 10150 {lab=word126}
N 2440 10080 2440 10160 {lab=A6}
N 2430 10150 2520 10150 {lab=word126}
N 2390 10120 2400 10120 {lab=GND}
N 2400 10090 2400 10120 {lab=GND}
N 2390 10090 2400 10090 {lab=GND}
N 2350 10080 2350 10120 {lab=#net2}
N 2350 10120 2350 10160 {lab=#net2}
N 2340 10150 2390 10150 {lab=word126}
N 2390 10150 2430 10150 {lab=word126}
N 2260 10080 2260 10160 {lab=A5}
N 2250 10150 2340 10150 {lab=word126}
N 2210 10120 2220 10120 {lab=GND}
N 2220 10090 2220 10120 {lab=GND}
N 2210 10090 2220 10090 {lab=GND}
N 2170 10080 2170 10120 {lab=#net3}
N 2170 10120 2170 10160 {lab=#net3}
N 2160 10150 2210 10150 {lab=word126}
N 2210 10150 2250 10150 {lab=word126}
N 2080 10080 2080 10160 {lab=A4}
N 2070 10150 2160 10150 {lab=word126}
N 2030 10120 2040 10120 {lab=GND}
N 2040 10090 2040 10120 {lab=GND}
N 2030 10090 2040 10090 {lab=GND}
N 1990 10080 1990 10120 {lab=#net4}
N 1990 10120 1990 10160 {lab=#net4}
N 1980 10150 2030 10150 {lab=word126}
N 2030 10150 2070 10150 {lab=word126}
N 1900 10080 1900 10160 {lab=A3}
N 1890 10150 1980 10150 {lab=word126}
N 1850 10120 1860 10120 {lab=GND}
N 1860 10090 1860 10120 {lab=GND}
N 1850 10090 1860 10090 {lab=GND}
N 1810 10080 1810 10120 {lab=#net5}
N 1810 10120 1810 10160 {lab=#net5}
N 1800 10150 1850 10150 {lab=word126}
N 1850 10150 1890 10150 {lab=word126}
N 1720 10080 1720 10160 {lab=A2}
N 1710 10150 1800 10150 {lab=word126}
N 1670 10120 1680 10120 {lab=GND}
N 1680 10090 1680 10120 {lab=GND}
N 1670 10090 1680 10090 {lab=GND}
N 1630 10080 1630 10120 {lab=#net6}
N 1630 10120 1630 10160 {lab=#net6}
N 1620 10150 1670 10150 {lab=word126}
N 1670 10150 1710 10150 {lab=word126}
N 1540 10080 1540 10160 {lab=A1}
N 1530 10150 1620 10150 {lab=word126}
N 1450 10080 1450 10160 {lab=#net7}
N 1440 10150 1530 10150 {lab=word126}
N 1400 10120 1410 10120 {lab=GND}
N 1410 10090 1410 10120 {lab=GND}
N 1400 10090 1410 10090 {lab=GND}
N 1360 10080 1360 10120 {lab=A0}
N 1360 10120 1360 10160 {lab=A0}
N 1350 10150 1400 10150 {lab=word126}
N 1400 10150 1440 10150 {lab=word126}
N 1260 10150 1350 10150 { lab=word126}
N 1210 10110 1250 10110 {lab=A0}
N 1210 10150 1210 10160 {lab=VDD}
N 1240 10150 1260 10150 {lab=word126}
N 1170 10150 1180 10150 {lab=#net771}
N 1250 10080 1250 10110 {lab=A0}
N 1250 10110 1250 10160 {lab=A0}
N 1160 10080 1160 10160 {lab=#net9}
N 1080 10150 1170 10150 {lab=#net771}
N 1070 10080 1070 10160 {lab=A1}
N 990 10150 1080 10150 {lab=#net771}
N 940 10110 980 10110 {lab=#net11}
N 940 10150 940 10160 {lab=VDD}
N 970 10150 990 10150 {lab=#net771}
N 900 10150 910 10150 {lab=#net772}
N 980 10080 980 10110 {lab=#net11}
N 980 10110 980 10160 {lab=#net11}
N 890 10080 890 10160 {lab=A2}
N 810 10150 900 10150 {lab=#net772}
N 760 10110 800 10110 {lab=#net13}
N 760 10150 760 10160 {lab=VDD}
N 790 10150 810 10150 {lab=#net772}
N 720 10150 730 10150 {lab=#net773}
N 800 10080 800 10110 {lab=#net13}
N 800 10110 800 10160 {lab=#net13}
N 710 10080 710 10160 {lab=A3}
N 630 10150 720 10150 {lab=#net773}
N 580 10110 620 10110 {lab=#net15}
N 580 10150 580 10160 {lab=VDD}
N 610 10150 630 10150 {lab=#net773}
N 540 10150 550 10150 {lab=#net774}
N 620 10080 620 10110 {lab=#net15}
N 620 10110 620 10160 {lab=#net15}
N 530 10080 530 10160 {lab=A4}
N 450 10150 540 10150 {lab=#net774}
N 400 10110 440 10110 {lab=#net17}
N 400 10150 400 10160 {lab=VDD}
N 430 10150 450 10150 {lab=#net774}
N 360 10150 370 10150 {lab=#net775}
N 440 10080 440 10110 {lab=#net17}
N 440 10110 440 10160 {lab=#net17}
N 350 10080 350 10160 {lab=A5}
N 270 10150 360 10150 {lab=#net775}
N 220 10110 260 10110 {lab=#net19}
N 220 10150 220 10160 {lab=VDD}
N 250 10150 270 10150 {lab=#net775}
N 180 10150 190 10150 {lab=#net776}
N 260 10080 260 10110 {lab=#net19}
N 260 10110 260 10160 {lab=#net19}
N 170 10080 170 10160 {lab=A6}
N 90 10150 180 10150 {lab=#net776}
N 40 10110 80 10110 {lab=#net20}
N 40 10150 40 10160 {lab=VDD}
N 70 10150 90 10150 {lab=#net776}
N 0 10150 10 10150 {lab=VDD}
N 80 10080 80 10110 {lab=#net20}
N 80 10110 80 10160 {lab=#net20}
N 0 10080 0 10160 { lab=VDD}
N 2570 10200 2580 10200 {lab=GND}
N 2580 10170 2580 10200 {lab=GND}
N 2570 10170 2580 10170 {lab=GND}
N 2530 10160 2530 10200 {lab=#net1}
N 2530 10200 2530 10240 {lab=#net1}
N 2520 10230 2570 10230 {lab=word127}
N 2570 10230 2610 10230 {lab=word127}
N 2440 10160 2440 10240 {lab=A6}
N 2430 10230 2520 10230 {lab=word127}
N 2390 10200 2400 10200 {lab=GND}
N 2400 10170 2400 10200 {lab=GND}
N 2390 10170 2400 10170 {lab=GND}
N 2350 10160 2350 10200 {lab=#net2}
N 2350 10200 2350 10240 {lab=#net2}
N 2340 10230 2390 10230 {lab=word127}
N 2390 10230 2430 10230 {lab=word127}
N 2260 10160 2260 10240 {lab=A5}
N 2250 10230 2340 10230 {lab=word127}
N 2210 10200 2220 10200 {lab=GND}
N 2220 10170 2220 10200 {lab=GND}
N 2210 10170 2220 10170 {lab=GND}
N 2170 10160 2170 10200 {lab=#net3}
N 2170 10200 2170 10240 {lab=#net3}
N 2160 10230 2210 10230 {lab=word127}
N 2210 10230 2250 10230 {lab=word127}
N 2080 10160 2080 10240 {lab=A4}
N 2070 10230 2160 10230 {lab=word127}
N 2030 10200 2040 10200 {lab=GND}
N 2040 10170 2040 10200 {lab=GND}
N 2030 10170 2040 10170 {lab=GND}
N 1990 10160 1990 10200 {lab=#net4}
N 1990 10200 1990 10240 {lab=#net4}
N 1980 10230 2030 10230 {lab=word127}
N 2030 10230 2070 10230 {lab=word127}
N 1900 10160 1900 10240 {lab=A3}
N 1890 10230 1980 10230 {lab=word127}
N 1850 10200 1860 10200 {lab=GND}
N 1860 10170 1860 10200 {lab=GND}
N 1850 10170 1860 10170 {lab=GND}
N 1810 10160 1810 10200 {lab=#net5}
N 1810 10200 1810 10240 {lab=#net5}
N 1800 10230 1850 10230 {lab=word127}
N 1850 10230 1890 10230 {lab=word127}
N 1720 10160 1720 10240 {lab=A2}
N 1710 10230 1800 10230 {lab=word127}
N 1670 10200 1680 10200 {lab=GND}
N 1680 10170 1680 10200 {lab=GND}
N 1670 10170 1680 10170 {lab=GND}
N 1630 10160 1630 10200 {lab=#net6}
N 1630 10200 1630 10240 {lab=#net6}
N 1620 10230 1670 10230 {lab=word127}
N 1670 10230 1710 10230 {lab=word127}
N 1540 10160 1540 10240 {lab=A1}
N 1530 10230 1620 10230 {lab=word127}
N 1490 10200 1500 10200 {lab=GND}
N 1500 10170 1500 10200 {lab=GND}
N 1490 10170 1500 10170 {lab=GND}
N 1450 10160 1450 10200 {lab=#net7}
N 1450 10200 1450 10240 {lab=#net7}
N 1440 10230 1490 10230 {lab=word127}
N 1490 10230 1530 10230 {lab=word127}
N 1360 10160 1360 10240 {lab=A0}
N 1350 10230 1440 10230 {lab=word127}
N 1260 10230 1350 10230 { lab=word127}
N 1250 10160 1250 10240 {lab=A0}
N 1170 10230 1260 10230 {lab=word127}
N 1120 10190 1160 10190 {lab=#net9}
N 1120 10230 1120 10240 {lab=VDD}
N 1150 10230 1170 10230 {lab=word127}
N 1080 10230 1090 10230 {lab=#net777}
N 1160 10160 1160 10190 {lab=#net9}
N 1160 10190 1160 10240 {lab=#net9}
N 1070 10160 1070 10240 {lab=A1}
N 990 10230 1080 10230 {lab=#net777}
N 940 10190 980 10190 {lab=#net11}
N 940 10230 940 10240 {lab=VDD}
N 970 10230 990 10230 {lab=#net777}
N 900 10230 910 10230 {lab=#net778}
N 980 10160 980 10190 {lab=#net11}
N 980 10190 980 10240 {lab=#net11}
N 890 10160 890 10240 {lab=A2}
N 810 10230 900 10230 {lab=#net778}
N 760 10190 800 10190 {lab=#net13}
N 760 10230 760 10240 {lab=VDD}
N 790 10230 810 10230 {lab=#net778}
N 720 10230 730 10230 {lab=#net779}
N 800 10160 800 10190 {lab=#net13}
N 800 10190 800 10240 {lab=#net13}
N 710 10160 710 10240 {lab=A3}
N 630 10230 720 10230 {lab=#net779}
N 580 10190 620 10190 {lab=#net15}
N 580 10230 580 10240 {lab=VDD}
N 610 10230 630 10230 {lab=#net779}
N 540 10230 550 10230 {lab=#net780}
N 620 10160 620 10190 {lab=#net15}
N 620 10190 620 10240 {lab=#net15}
N 530 10160 530 10240 {lab=A4}
N 450 10230 540 10230 {lab=#net780}
N 400 10190 440 10190 {lab=#net17}
N 400 10230 400 10240 {lab=VDD}
N 430 10230 450 10230 {lab=#net780}
N 360 10230 370 10230 {lab=#net781}
N 440 10160 440 10190 {lab=#net17}
N 440 10190 440 10240 {lab=#net17}
N 350 10160 350 10240 {lab=A5}
N 270 10230 360 10230 {lab=#net781}
N 220 10190 260 10190 {lab=#net19}
N 220 10230 220 10240 {lab=VDD}
N 250 10230 270 10230 {lab=#net781}
N 180 10230 190 10230 {lab=#net782}
N 260 10160 260 10190 {lab=#net19}
N 260 10190 260 10240 {lab=#net19}
N 170 10160 170 10240 {lab=A6}
N 90 10230 180 10230 {lab=#net782}
N 40 10190 80 10190 {lab=#net20}
N 40 10230 40 10240 {lab=VDD}
N 70 10230 90 10230 {lab=#net782}
N 0 10230 10 10230 {lab=VDD}
N 80 10160 80 10190 {lab=#net20}
N 80 10190 80 10240 {lab=#net20}
N 0 10160 0 10240 { lab=VDD}
N 170 -60 170 0 {lab=A6}
N 80 -30 80 0 {lab=#net20}
N 170 -180 170 -60 {lab=A6}
N 120 -150 130 -150 {lab=VDD}
N 120 -190 120 -150 {lab=VDD}
N 120 -190 130 -190 {lab=VDD}
N 130 -190 130 -180 {lab=VDD}
N 130 -120 130 -90 {lab=#net20}
N 120 -60 130 -60 {lab=GND}
N 120 -60 120 -20 {lab=GND}
N 120 -20 130 -20 {lab=GND}
N 130 -30 130 -20 {lab=GND}
N 80 -110 130 -110 {lab=#net20}
N 80 -110 80 -30 {lab=#net20}
N 350 -60 350 0 {lab=A5}
N 260 -30 260 0 {lab=#net19}
N 350 -180 350 -60 {lab=A5}
N 300 -150 310 -150 {lab=VDD}
N 300 -190 300 -150 {lab=VDD}
N 300 -190 310 -190 {lab=VDD}
N 310 -190 310 -180 {lab=VDD}
N 310 -120 310 -90 {lab=#net19}
N 300 -60 310 -60 {lab=GND}
N 300 -60 300 -20 {lab=GND}
N 300 -20 310 -20 {lab=GND}
N 310 -30 310 -20 {lab=GND}
N 260 -110 310 -110 {lab=#net19}
N 260 -110 260 -30 {lab=#net19}
N 530 -60 530 0 {lab=A4}
N 440 -30 440 0 {lab=#net17}
N 530 -180 530 -60 {lab=A4}
N 480 -150 490 -150 {lab=VDD}
N 480 -190 480 -150 {lab=VDD}
N 480 -190 490 -190 {lab=VDD}
N 490 -190 490 -180 {lab=VDD}
N 490 -120 490 -90 {lab=#net17}
N 480 -60 490 -60 {lab=GND}
N 480 -60 480 -20 {lab=GND}
N 480 -20 490 -20 {lab=GND}
N 490 -30 490 -20 {lab=GND}
N 440 -110 490 -110 {lab=#net17}
N 440 -110 440 -30 {lab=#net17}
N 710 -60 710 0 {lab=A3}
N 620 -30 620 0 {lab=#net15}
N 710 -180 710 -60 {lab=A3}
N 660 -150 670 -150 {lab=VDD}
N 660 -190 660 -150 {lab=VDD}
N 660 -190 670 -190 {lab=VDD}
N 670 -190 670 -180 {lab=VDD}
N 670 -120 670 -90 {lab=#net15}
N 660 -60 670 -60 {lab=GND}
N 660 -60 660 -20 {lab=GND}
N 660 -20 670 -20 {lab=GND}
N 670 -30 670 -20 {lab=GND}
N 620 -110 670 -110 {lab=#net15}
N 620 -110 620 -30 {lab=#net15}
N 890 -60 890 0 {lab=A2}
N 800 -30 800 0 {lab=#net13}
N 890 -180 890 -60 {lab=A2}
N 840 -150 850 -150 {lab=VDD}
N 840 -190 840 -150 {lab=VDD}
N 840 -190 850 -190 {lab=VDD}
N 850 -190 850 -180 {lab=VDD}
N 850 -120 850 -90 {lab=#net13}
N 840 -60 850 -60 {lab=GND}
N 840 -60 840 -20 {lab=GND}
N 840 -20 850 -20 {lab=GND}
N 850 -30 850 -20 {lab=GND}
N 800 -110 850 -110 {lab=#net13}
N 800 -110 800 -30 {lab=#net13}
N 1070 -60 1070 0 {lab=A1}
N 980 -30 980 0 {lab=#net11}
N 1070 -180 1070 -60 {lab=A1}
N 1020 -150 1030 -150 {lab=VDD}
N 1020 -190 1020 -150 {lab=VDD}
N 1020 -190 1030 -190 {lab=VDD}
N 1030 -190 1030 -180 {lab=VDD}
N 1030 -120 1030 -90 {lab=#net11}
N 1020 -60 1030 -60 {lab=GND}
N 1020 -60 1020 -20 {lab=GND}
N 1020 -20 1030 -20 {lab=GND}
N 1030 -30 1030 -20 {lab=GND}
N 980 -110 1030 -110 {lab=#net11}
N 980 -110 980 -30 {lab=#net11}
N 1250 -60 1250 0 {lab=A0}
N 1160 -30 1160 0 {lab=#net9}
N 1250 -180 1250 -60 {lab=A0}
N 1200 -150 1210 -150 {lab=VDD}
N 1200 -190 1200 -150 {lab=VDD}
N 1200 -190 1210 -190 {lab=VDD}
N 1210 -190 1210 -180 {lab=VDD}
N 1210 -120 1210 -90 {lab=#net9}
N 1200 -60 1210 -60 {lab=GND}
N 1200 -60 1200 -20 {lab=GND}
N 1200 -20 1210 -20 {lab=GND}
N 1210 -30 1210 -20 {lab=GND}
N 1160 -110 1210 -110 {lab=#net9}
N 1160 -110 1160 -30 {lab=#net9}
N 1400 -250 1400 -240 {lab=VDD}
N 1400 -180 1400 -150 {lab=#net7}
N 1450 -60 1450 0 { lab=#net7}
N 1360 -60 1360 0 { lab=A0}
N 1360 -120 1360 -60 {lab=A0}
N 1450 -90 1450 -60 {lab=#net7}
N 1360 -240 1360 -120 {lab=A0}
N 1400 -250 1400 -240 {lab=VDD}
N 1400 -180 1400 -150 {lab=#net7}
N 1400 -170 1450 -170 {lab=#net7}
N 1450 -170 1450 -90 {lab=#net7}
N 1400 -250 1410 -250 {lab=VDD}
N 1400 -90 1400 -80 {lab=GND}
N 1400 -80 1410 -80 {lab=GND}
N 1400 -120 1410 -120 {lab=GND}
N 1410 -120 1410 -80 {lab=GND}
N 1400 -210 1410 -210 {lab=VDD}
N 1410 -250 1410 -210 {lab=VDD}
N 1580 -250 1580 -240 {lab=VDD}
N 1580 -180 1580 -150 {lab=#net6}
N 1630 -60 1630 0 { lab=#net6}
N 1540 -60 1540 0 { lab=A1}
N 1540 -120 1540 -60 {lab=A1}
N 1630 -90 1630 -60 {lab=#net6}
N 1540 -240 1540 -120 {lab=A1}
N 1580 -250 1580 -240 {lab=VDD}
N 1580 -180 1580 -150 {lab=#net6}
N 1580 -170 1630 -170 {lab=#net6}
N 1630 -170 1630 -90 {lab=#net6}
N 1580 -250 1590 -250 {lab=VDD}
N 1580 -90 1580 -80 {lab=GND}
N 1580 -80 1590 -80 {lab=GND}
N 1580 -120 1590 -120 {lab=GND}
N 1590 -120 1590 -80 {lab=GND}
N 1580 -210 1590 -210 {lab=VDD}
N 1590 -250 1590 -210 {lab=VDD}
N 1760 -250 1760 -240 {lab=VDD}
N 1760 -180 1760 -150 {lab=#net5}
N 1810 -60 1810 0 { lab=#net5}
N 1720 -60 1720 0 { lab=A2}
N 1720 -120 1720 -60 {lab=A2}
N 1810 -90 1810 -60 {lab=#net5}
N 1720 -240 1720 -120 {lab=A2}
N 1760 -250 1760 -240 {lab=VDD}
N 1760 -180 1760 -150 {lab=#net5}
N 1760 -170 1810 -170 {lab=#net5}
N 1810 -170 1810 -90 {lab=#net5}
N 1760 -250 1770 -250 {lab=VDD}
N 1760 -90 1760 -80 {lab=GND}
N 1760 -80 1770 -80 {lab=GND}
N 1760 -120 1770 -120 {lab=GND}
N 1770 -120 1770 -80 {lab=GND}
N 1760 -210 1770 -210 {lab=VDD}
N 1770 -250 1770 -210 {lab=VDD}
N 1940 -250 1940 -240 {lab=VDD}
N 1940 -180 1940 -150 {lab=#net4}
N 1990 -60 1990 0 { lab=#net4}
N 1900 -60 1900 0 { lab=A3}
N 1900 -120 1900 -60 {lab=A3}
N 1990 -90 1990 -60 {lab=#net4}
N 1900 -240 1900 -120 {lab=A3}
N 1940 -250 1940 -240 {lab=VDD}
N 1940 -180 1940 -150 {lab=#net4}
N 1940 -170 1990 -170 {lab=#net4}
N 1990 -170 1990 -90 {lab=#net4}
N 1940 -250 1950 -250 {lab=VDD}
N 1940 -90 1940 -80 {lab=GND}
N 1940 -80 1950 -80 {lab=GND}
N 1940 -120 1950 -120 {lab=GND}
N 1950 -120 1950 -80 {lab=GND}
N 1940 -210 1950 -210 {lab=VDD}
N 1950 -250 1950 -210 {lab=VDD}
N 2120 -250 2120 -240 {lab=VDD}
N 2120 -180 2120 -150 {lab=#net3}
N 2170 -60 2170 0 { lab=#net3}
N 2080 -60 2080 0 { lab=A4}
N 2080 -120 2080 -60 {lab=A4}
N 2170 -90 2170 -60 {lab=#net3}
N 2080 -240 2080 -120 {lab=A4}
N 2120 -250 2120 -240 {lab=VDD}
N 2120 -180 2120 -150 {lab=#net3}
N 2120 -170 2170 -170 {lab=#net3}
N 2170 -170 2170 -90 {lab=#net3}
N 2120 -250 2130 -250 {lab=VDD}
N 2120 -90 2120 -80 {lab=GND}
N 2120 -80 2130 -80 {lab=GND}
N 2120 -120 2130 -120 {lab=GND}
N 2130 -120 2130 -80 {lab=GND}
N 2120 -210 2130 -210 {lab=VDD}
N 2130 -250 2130 -210 {lab=VDD}
N 2300 -250 2300 -240 {lab=VDD}
N 2300 -180 2300 -150 {lab=#net2}
N 2350 -60 2350 0 { lab=#net2}
N 2260 -60 2260 0 { lab=A5}
N 2260 -120 2260 -60 {lab=A5}
N 2350 -90 2350 -60 {lab=#net2}
N 2260 -240 2260 -120 {lab=A5}
N 2300 -250 2300 -240 {lab=VDD}
N 2300 -180 2300 -150 {lab=#net2}
N 2300 -170 2350 -170 {lab=#net2}
N 2350 -170 2350 -90 {lab=#net2}
N 2300 -250 2310 -250 {lab=VDD}
N 2300 -90 2300 -80 {lab=GND}
N 2300 -80 2310 -80 {lab=GND}
N 2300 -120 2310 -120 {lab=GND}
N 2310 -120 2310 -80 {lab=GND}
N 2300 -210 2310 -210 {lab=VDD}
N 2310 -250 2310 -210 {lab=VDD}
N 2480 -250 2480 -240 {lab=VDD}
N 2480 -180 2480 -150 {lab=#net1}
N 2530 -60 2530 0 { lab=#net1}
N 2440 -60 2440 0 { lab=A6}
N 2440 -120 2440 -60 {lab=A6}
N 2530 -90 2530 -60 {lab=#net1}
N 2440 -240 2440 -120 {lab=A6}
N 2480 -250 2480 -240 {lab=VDD}
N 2480 -180 2480 -150 {lab=#net1}
N 2480 -170 2530 -170 {lab=#net1}
N 2530 -170 2530 -90 {lab=#net1}
N 2480 -250 2490 -250 {lab=VDD}
N 2480 -90 2480 -80 {lab=GND}
N 2480 -80 2490 -80 {lab=GND}
N 2480 -120 2490 -120 {lab=GND}
N 2490 -120 2490 -80 {lab=GND}
N 2480 -210 2490 -210 {lab=VDD}
N 2490 -250 2490 -210 {lab=VDD}
C {devices/vdd.sym} 0 0 0 0 {lab=VDD}
C {devices/ipin.sym} 1250 -180 3 1 {name=p14 lab=A0}
C {devices/ipin.sym} 1070 -180 3 1 {name=p16 lab=A1}
C {devices/ipin.sym} 890 -180 3 1 {name=p18 lab=A2}
C {devices/ipin.sym} 710 -180 3 1 {name=p20 lab=A3}
C {devices/ipin.sym} 530 -180 3 1 {name=p22 lab=A4}
C {devices/ipin.sym} 350 -180 3 1 {name=p24 lab=A5}
C {devices/ipin.sym} 170 -180 3 1 {name=p26 lab=A6}
C {devices/opin.sym} 2610 70 0 0 {name=p28 lab=word0}
C {sky130_fd_pr/nfet_01v8.sym} 2460 40 2 1 {name=M0
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 40 3 0 {name=l0 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 40 2 1 {name=M1
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 40 3 0 {name=l1 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 40 2 1 {name=M2
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 40 3 0 {name=l2 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 40 2 1 {name=M3
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 40 3 0 {name=l3 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 40 2 1 {name=M4
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 40 3 0 {name=l4 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 40 2 1 {name=M5
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 40 3 0 {name=l5 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 40 2 1 {name=M6
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 40 3 0 {name=l6 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 50 3 1 {name=M7
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 80 3 0 {name=l7 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 50 3 1 {name=M8
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 80 3 0 {name=l8 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 50 3 1 {name=M9
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 80 3 0 {name=l9 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 50 3 1 {name=M10
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 80 3 0 {name=l10 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 50 3 1 {name=M11
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 80 3 0 {name=l11 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 50 3 1 {name=M12
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 80 3 0 {name=l12 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 50 3 1 {name=M13
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 80 3 0 {name=l13 lab=VDD}
C {devices/opin.sym} 2610 150 0 0 {name=p29 lab=word1}
C {sky130_fd_pr/nfet_01v8.sym} 2460 120 2 1 {name=M14
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 120 3 0 {name=l14 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 120 2 1 {name=M15
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 120 3 0 {name=l15 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 120 2 1 {name=M16
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 120 3 0 {name=l16 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 120 2 1 {name=M17
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 120 3 0 {name=l17 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 120 2 1 {name=M18
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 120 3 0 {name=l18 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 120 2 1 {name=M19
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 120 3 0 {name=l19 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 120 2 1 {name=M20
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 120 3 0 {name=l20 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 130 3 1 {name=M21
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 160 3 0 {name=l21 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 130 3 1 {name=M22
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 160 3 0 {name=l22 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 130 3 1 {name=M23
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 160 3 0 {name=l23 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 130 3 1 {name=M24
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 160 3 0 {name=l24 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 130 3 1 {name=M25
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 160 3 0 {name=l25 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 130 3 1 {name=M26
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 160 3 0 {name=l26 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 130 3 1 {name=M27
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 160 3 0 {name=l27 lab=VDD}
C {devices/opin.sym} 2610 230 0 0 {name=p30 lab=word2}
C {sky130_fd_pr/nfet_01v8.sym} 2460 200 2 1 {name=M28
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 200 3 0 {name=l28 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 200 2 1 {name=M29
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 200 3 0 {name=l29 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 200 2 1 {name=M30
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 200 3 0 {name=l30 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 200 2 1 {name=M31
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 200 3 0 {name=l31 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 200 2 1 {name=M32
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 200 3 0 {name=l32 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 200 2 1 {name=M33
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 200 3 0 {name=l33 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 200 2 1 {name=M34
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 200 3 0 {name=l34 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 210 3 1 {name=M35
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 240 3 0 {name=l35 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 210 3 1 {name=M36
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 240 3 0 {name=l36 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 210 3 1 {name=M37
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 240 3 0 {name=l37 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 210 3 1 {name=M38
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 240 3 0 {name=l38 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 210 3 1 {name=M39
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 240 3 0 {name=l39 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 210 3 1 {name=M40
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 240 3 0 {name=l40 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 210 3 1 {name=M41
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 240 3 0 {name=l41 lab=VDD}
C {devices/opin.sym} 2610 310 0 0 {name=p31 lab=word3}
C {sky130_fd_pr/nfet_01v8.sym} 2460 280 2 1 {name=M42
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 280 3 0 {name=l42 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 280 2 1 {name=M43
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 280 3 0 {name=l43 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 280 2 1 {name=M44
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 280 3 0 {name=l44 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 280 2 1 {name=M45
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 280 3 0 {name=l45 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 280 2 1 {name=M46
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 280 3 0 {name=l46 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 280 2 1 {name=M47
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 280 3 0 {name=l47 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 280 2 1 {name=M48
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 280 3 0 {name=l48 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 290 3 1 {name=M49
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 320 3 0 {name=l49 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 290 3 1 {name=M50
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 320 3 0 {name=l50 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 290 3 1 {name=M51
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 320 3 0 {name=l51 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 290 3 1 {name=M52
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 320 3 0 {name=l52 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 290 3 1 {name=M53
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 320 3 0 {name=l53 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 290 3 1 {name=M54
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 320 3 0 {name=l54 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 290 3 1 {name=M55
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 320 3 0 {name=l55 lab=VDD}
C {devices/opin.sym} 2610 390 0 0 {name=p32 lab=word4}
C {sky130_fd_pr/nfet_01v8.sym} 2460 360 2 1 {name=M56
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 360 3 0 {name=l56 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 360 2 1 {name=M57
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 360 3 0 {name=l57 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 360 2 1 {name=M58
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 360 3 0 {name=l58 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 360 2 1 {name=M59
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 360 3 0 {name=l59 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 360 2 1 {name=M60
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 360 3 0 {name=l60 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 360 2 1 {name=M61
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 360 3 0 {name=l61 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 360 2 1 {name=M62
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 360 3 0 {name=l62 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 370 3 1 {name=M63
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 400 3 0 {name=l63 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 370 3 1 {name=M64
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 400 3 0 {name=l64 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 370 3 1 {name=M65
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 400 3 0 {name=l65 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 370 3 1 {name=M66
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 400 3 0 {name=l66 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 370 3 1 {name=M67
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 400 3 0 {name=l67 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 370 3 1 {name=M68
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 400 3 0 {name=l68 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 370 3 1 {name=M69
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 400 3 0 {name=l69 lab=VDD}
C {devices/opin.sym} 2610 470 0 0 {name=p33 lab=word5}
C {sky130_fd_pr/nfet_01v8.sym} 2460 440 2 1 {name=M70
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 440 3 0 {name=l70 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 440 2 1 {name=M71
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 440 3 0 {name=l71 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 440 2 1 {name=M72
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 440 3 0 {name=l72 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 440 2 1 {name=M73
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 440 3 0 {name=l73 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 440 2 1 {name=M74
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 440 3 0 {name=l74 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 440 2 1 {name=M75
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 440 3 0 {name=l75 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 440 2 1 {name=M76
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 440 3 0 {name=l76 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 450 3 1 {name=M77
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 480 3 0 {name=l77 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 450 3 1 {name=M78
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 480 3 0 {name=l78 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 450 3 1 {name=M79
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 480 3 0 {name=l79 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 450 3 1 {name=M80
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 480 3 0 {name=l80 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 450 3 1 {name=M81
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 480 3 0 {name=l81 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 450 3 1 {name=M82
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 480 3 0 {name=l82 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 450 3 1 {name=M83
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 480 3 0 {name=l83 lab=VDD}
C {devices/opin.sym} 2610 550 0 0 {name=p34 lab=word6}
C {sky130_fd_pr/nfet_01v8.sym} 2460 520 2 1 {name=M84
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 520 3 0 {name=l84 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 520 2 1 {name=M85
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 520 3 0 {name=l85 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 520 2 1 {name=M86
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 520 3 0 {name=l86 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 520 2 1 {name=M87
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 520 3 0 {name=l87 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 520 2 1 {name=M88
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 520 3 0 {name=l88 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 520 2 1 {name=M89
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 520 3 0 {name=l89 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 520 2 1 {name=M90
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 520 3 0 {name=l90 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 530 3 1 {name=M91
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 560 3 0 {name=l91 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 530 3 1 {name=M92
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 560 3 0 {name=l92 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 530 3 1 {name=M93
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 560 3 0 {name=l93 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 530 3 1 {name=M94
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 560 3 0 {name=l94 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 530 3 1 {name=M95
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 560 3 0 {name=l95 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 530 3 1 {name=M96
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 560 3 0 {name=l96 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 530 3 1 {name=M97
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 560 3 0 {name=l97 lab=VDD}
C {devices/opin.sym} 2610 630 0 0 {name=p35 lab=word7}
C {sky130_fd_pr/nfet_01v8.sym} 2460 600 2 1 {name=M98
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 600 3 0 {name=l98 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 600 2 1 {name=M99
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 600 3 0 {name=l99 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 600 2 1 {name=M100
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 600 3 0 {name=l100 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 600 2 1 {name=M101
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 600 3 0 {name=l101 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 600 2 1 {name=M102
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 600 3 0 {name=l102 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 600 2 1 {name=M103
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 600 3 0 {name=l103 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 600 2 1 {name=M104
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 600 3 0 {name=l104 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 610 3 1 {name=M105
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 640 3 0 {name=l105 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 610 3 1 {name=M106
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 640 3 0 {name=l106 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 610 3 1 {name=M107
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 640 3 0 {name=l107 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 610 3 1 {name=M108
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 640 3 0 {name=l108 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 610 3 1 {name=M109
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 640 3 0 {name=l109 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 610 3 1 {name=M110
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 640 3 0 {name=l110 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 610 3 1 {name=M111
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 640 3 0 {name=l111 lab=VDD}
C {devices/opin.sym} 2610 710 0 0 {name=p36 lab=word8}
C {sky130_fd_pr/nfet_01v8.sym} 2460 680 2 1 {name=M112
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 680 3 0 {name=l112 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 680 2 1 {name=M113
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 680 3 0 {name=l113 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 680 2 1 {name=M114
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 680 3 0 {name=l114 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 680 2 1 {name=M115
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 680 3 0 {name=l115 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 680 2 1 {name=M116
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 680 3 0 {name=l116 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 680 2 1 {name=M117
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 680 3 0 {name=l117 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 680 2 1 {name=M118
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 680 3 0 {name=l118 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 690 3 1 {name=M119
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 720 3 0 {name=l119 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 690 3 1 {name=M120
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 720 3 0 {name=l120 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 690 3 1 {name=M121
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 720 3 0 {name=l121 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 690 3 1 {name=M122
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 720 3 0 {name=l122 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 690 3 1 {name=M123
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 720 3 0 {name=l123 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 690 3 1 {name=M124
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 720 3 0 {name=l124 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 690 3 1 {name=M125
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 720 3 0 {name=l125 lab=VDD}
C {devices/opin.sym} 2610 790 0 0 {name=p37 lab=word9}
C {sky130_fd_pr/nfet_01v8.sym} 2460 760 2 1 {name=M126
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 760 3 0 {name=l126 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 760 2 1 {name=M127
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 760 3 0 {name=l127 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 760 2 1 {name=M128
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 760 3 0 {name=l128 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 760 2 1 {name=M129
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 760 3 0 {name=l129 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 760 2 1 {name=M130
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 760 3 0 {name=l130 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 760 2 1 {name=M131
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 760 3 0 {name=l131 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 760 2 1 {name=M132
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 760 3 0 {name=l132 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 770 3 1 {name=M133
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 800 3 0 {name=l133 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 770 3 1 {name=M134
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 800 3 0 {name=l134 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 770 3 1 {name=M135
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 800 3 0 {name=l135 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 770 3 1 {name=M136
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 800 3 0 {name=l136 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 770 3 1 {name=M137
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 800 3 0 {name=l137 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 770 3 1 {name=M138
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 800 3 0 {name=l138 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 770 3 1 {name=M139
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 800 3 0 {name=l139 lab=VDD}
C {devices/opin.sym} 2610 870 0 0 {name=p38 lab=word10}
C {sky130_fd_pr/nfet_01v8.sym} 2460 840 2 1 {name=M140
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 840 3 0 {name=l140 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 840 2 1 {name=M141
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 840 3 0 {name=l141 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 840 2 1 {name=M142
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 840 3 0 {name=l142 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 840 2 1 {name=M143
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 840 3 0 {name=l143 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 840 2 1 {name=M144
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 840 3 0 {name=l144 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 840 2 1 {name=M145
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 840 3 0 {name=l145 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 840 2 1 {name=M146
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 840 3 0 {name=l146 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 850 3 1 {name=M147
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 880 3 0 {name=l147 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 850 3 1 {name=M148
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 880 3 0 {name=l148 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 850 3 1 {name=M149
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 880 3 0 {name=l149 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 850 3 1 {name=M150
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 880 3 0 {name=l150 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 850 3 1 {name=M151
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 880 3 0 {name=l151 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 850 3 1 {name=M152
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 880 3 0 {name=l152 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 850 3 1 {name=M153
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 880 3 0 {name=l153 lab=VDD}
C {devices/opin.sym} 2610 950 0 0 {name=p39 lab=word11}
C {sky130_fd_pr/nfet_01v8.sym} 2460 920 2 1 {name=M154
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 920 3 0 {name=l154 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 920 2 1 {name=M155
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 920 3 0 {name=l155 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 920 2 1 {name=M156
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 920 3 0 {name=l156 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 920 2 1 {name=M157
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 920 3 0 {name=l157 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 920 2 1 {name=M158
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 920 3 0 {name=l158 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 920 2 1 {name=M159
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 920 3 0 {name=l159 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 920 2 1 {name=M160
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 920 3 0 {name=l160 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 930 3 1 {name=M161
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 960 3 0 {name=l161 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 930 3 1 {name=M162
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 960 3 0 {name=l162 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 930 3 1 {name=M163
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 960 3 0 {name=l163 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 930 3 1 {name=M164
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 960 3 0 {name=l164 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 930 3 1 {name=M165
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 960 3 0 {name=l165 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 930 3 1 {name=M166
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 960 3 0 {name=l166 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 930 3 1 {name=M167
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 960 3 0 {name=l167 lab=VDD}
C {devices/opin.sym} 2610 1030 0 0 {name=p40 lab=word12}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1000 2 1 {name=M168
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1000 3 0 {name=l168 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1000 2 1 {name=M169
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1000 3 0 {name=l169 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1000 2 1 {name=M170
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1000 3 0 {name=l170 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1000 2 1 {name=M171
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1000 3 0 {name=l171 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1000 2 1 {name=M172
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1000 3 0 {name=l172 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 1000 2 1 {name=M173
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 1000 3 0 {name=l173 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1000 2 1 {name=M174
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1000 3 0 {name=l174 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 1010 3 1 {name=M175
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 1040 3 0 {name=l175 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1010 3 1 {name=M176
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 1040 3 0 {name=l176 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1010 3 1 {name=M177
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1040 3 0 {name=l177 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1010 3 1 {name=M178
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 1040 3 0 {name=l178 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 1010 3 1 {name=M179
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 1040 3 0 {name=l179 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1010 3 1 {name=M180
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1040 3 0 {name=l180 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1010 3 1 {name=M181
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1040 3 0 {name=l181 lab=VDD}
C {devices/opin.sym} 2610 1110 0 0 {name=p41 lab=word13}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1080 2 1 {name=M182
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1080 3 0 {name=l182 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1080 2 1 {name=M183
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1080 3 0 {name=l183 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1080 2 1 {name=M184
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1080 3 0 {name=l184 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1080 2 1 {name=M185
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1080 3 0 {name=l185 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1080 2 1 {name=M186
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1080 3 0 {name=l186 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 1080 2 1 {name=M187
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 1080 3 0 {name=l187 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1080 2 1 {name=M188
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 1080 3 0 {name=l188 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 1090 3 1 {name=M189
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 1120 3 0 {name=l189 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1090 3 1 {name=M190
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 1120 3 0 {name=l190 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1090 3 1 {name=M191
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1120 3 0 {name=l191 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1090 3 1 {name=M192
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 1120 3 0 {name=l192 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 1090 3 1 {name=M193
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 1120 3 0 {name=l193 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1090 3 1 {name=M194
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1120 3 0 {name=l194 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1090 3 1 {name=M195
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1120 3 0 {name=l195 lab=VDD}
C {devices/opin.sym} 2610 1190 0 0 {name=p42 lab=word14}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1160 2 1 {name=M196
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1160 3 0 {name=l196 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1160 2 1 {name=M197
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1160 3 0 {name=l197 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1160 2 1 {name=M198
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1160 3 0 {name=l198 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1160 2 1 {name=M199
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1160 3 0 {name=l199 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1160 2 1 {name=M200
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1160 3 0 {name=l200 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1160 2 1 {name=M201
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1160 3 0 {name=l201 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1160 2 1 {name=M202
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1160 3 0 {name=l202 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 1170 3 1 {name=M203
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 1200 3 0 {name=l203 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 1170 3 1 {name=M204
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 1200 3 0 {name=l204 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1170 3 1 {name=M205
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1200 3 0 {name=l205 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1170 3 1 {name=M206
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 1200 3 0 {name=l206 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 1170 3 1 {name=M207
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 1200 3 0 {name=l207 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1170 3 1 {name=M208
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1200 3 0 {name=l208 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1170 3 1 {name=M209
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1200 3 0 {name=l209 lab=VDD}
C {devices/opin.sym} 2610 1270 0 0 {name=p43 lab=word15}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1240 2 1 {name=M210
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1240 3 0 {name=l210 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1240 2 1 {name=M211
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1240 3 0 {name=l211 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 1240 2 1 {name=M212
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 1240 3 0 {name=l212 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1240 2 1 {name=M213
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1240 3 0 {name=l213 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1240 2 1 {name=M214
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1240 3 0 {name=l214 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1240 2 1 {name=M215
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1240 3 0 {name=l215 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1240 2 1 {name=M216
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 1240 3 0 {name=l216 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 1250 3 1 {name=M217
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 1280 3 0 {name=l217 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 1250 3 1 {name=M218
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 1280 3 0 {name=l218 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1250 3 1 {name=M219
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1280 3 0 {name=l219 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1250 3 1 {name=M220
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 1280 3 0 {name=l220 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 1250 3 1 {name=M221
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 1280 3 0 {name=l221 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1250 3 1 {name=M222
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1280 3 0 {name=l222 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1250 3 1 {name=M223
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1280 3 0 {name=l223 lab=VDD}
C {devices/opin.sym} 2610 1350 0 0 {name=p44 lab=word16}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1320 2 1 {name=M224
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1320 3 0 {name=l224 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1320 2 1 {name=M225
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1320 3 0 {name=l225 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 1320 2 1 {name=M226
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 1320 3 0 {name=l226 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 1320 2 1 {name=M227
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 1320 3 0 {name=l227 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1320 2 1 {name=M228
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1320 3 0 {name=l228 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 1320 2 1 {name=M229
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 1320 3 0 {name=l229 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1320 2 1 {name=M230
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1320 3 0 {name=l230 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 1330 3 1 {name=M231
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 1360 3 0 {name=l231 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1330 3 1 {name=M232
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 1360 3 0 {name=l232 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 1330 3 1 {name=M233
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 1360 3 0 {name=l233 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1330 3 1 {name=M234
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 1360 3 0 {name=l234 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1330 3 1 {name=M235
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 1360 3 0 {name=l235 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1330 3 1 {name=M236
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1360 3 0 {name=l236 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1330 3 1 {name=M237
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1360 3 0 {name=l237 lab=VDD}
C {devices/opin.sym} 2610 1430 0 0 {name=p45 lab=word17}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1400 2 1 {name=M238
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1400 3 0 {name=l238 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1400 2 1 {name=M239
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1400 3 0 {name=l239 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 1400 2 1 {name=M240
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 1400 3 0 {name=l240 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 1400 2 1 {name=M241
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 1400 3 0 {name=l241 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1400 2 1 {name=M242
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1400 3 0 {name=l242 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 1400 2 1 {name=M243
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 1400 3 0 {name=l243 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1400 2 1 {name=M244
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 1400 3 0 {name=l244 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 1410 3 1 {name=M245
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 1440 3 0 {name=l245 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1410 3 1 {name=M246
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 1440 3 0 {name=l246 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 1410 3 1 {name=M247
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 1440 3 0 {name=l247 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1410 3 1 {name=M248
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 1440 3 0 {name=l248 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1410 3 1 {name=M249
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 1440 3 0 {name=l249 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1410 3 1 {name=M250
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1440 3 0 {name=l250 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1410 3 1 {name=M251
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1440 3 0 {name=l251 lab=VDD}
C {devices/opin.sym} 2610 1510 0 0 {name=p46 lab=word18}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1480 2 1 {name=M252
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1480 3 0 {name=l252 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1480 2 1 {name=M253
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1480 3 0 {name=l253 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 1480 2 1 {name=M254
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 1480 3 0 {name=l254 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 1480 2 1 {name=M255
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 1480 3 0 {name=l255 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1480 2 1 {name=M256
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1480 3 0 {name=l256 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1480 2 1 {name=M257
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1480 3 0 {name=l257 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1480 2 1 {name=M258
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1480 3 0 {name=l258 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 1490 3 1 {name=M259
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 1520 3 0 {name=l259 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 1490 3 1 {name=M260
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 1520 3 0 {name=l260 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 1490 3 1 {name=M261
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 1520 3 0 {name=l261 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1490 3 1 {name=M262
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 1520 3 0 {name=l262 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1490 3 1 {name=M263
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 1520 3 0 {name=l263 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1490 3 1 {name=M264
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1520 3 0 {name=l264 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1490 3 1 {name=M265
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1520 3 0 {name=l265 lab=VDD}
C {devices/opin.sym} 2610 1590 0 0 {name=p47 lab=word19}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1560 2 1 {name=M266
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1560 3 0 {name=l266 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1560 2 1 {name=M267
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1560 3 0 {name=l267 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 1560 2 1 {name=M268
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 1560 3 0 {name=l268 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 1560 2 1 {name=M269
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 1560 3 0 {name=l269 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1560 2 1 {name=M270
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1560 3 0 {name=l270 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1560 2 1 {name=M271
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1560 3 0 {name=l271 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1560 2 1 {name=M272
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 1560 3 0 {name=l272 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 1570 3 1 {name=M273
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 1600 3 0 {name=l273 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 1570 3 1 {name=M274
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 1600 3 0 {name=l274 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 1570 3 1 {name=M275
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 1600 3 0 {name=l275 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1570 3 1 {name=M276
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 1600 3 0 {name=l276 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1570 3 1 {name=M277
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 1600 3 0 {name=l277 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1570 3 1 {name=M278
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1600 3 0 {name=l278 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1570 3 1 {name=M279
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1600 3 0 {name=l279 lab=VDD}
C {devices/opin.sym} 2610 1670 0 0 {name=p48 lab=word20}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1640 2 1 {name=M280
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1640 3 0 {name=l280 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1640 2 1 {name=M281
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1640 3 0 {name=l281 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 1640 2 1 {name=M282
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 1640 3 0 {name=l282 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 1640 2 1 {name=M283
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 1640 3 0 {name=l283 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1640 2 1 {name=M284
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1640 3 0 {name=l284 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 1640 2 1 {name=M285
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 1640 3 0 {name=l285 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1640 2 1 {name=M286
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1640 3 0 {name=l286 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 1650 3 1 {name=M287
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 1680 3 0 {name=l287 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1650 3 1 {name=M288
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 1680 3 0 {name=l288 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1650 3 1 {name=M289
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1680 3 0 {name=l289 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1650 3 1 {name=M290
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 1680 3 0 {name=l290 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1650 3 1 {name=M291
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 1680 3 0 {name=l291 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1650 3 1 {name=M292
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1680 3 0 {name=l292 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1650 3 1 {name=M293
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1680 3 0 {name=l293 lab=VDD}
C {devices/opin.sym} 2610 1750 0 0 {name=p49 lab=word21}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1720 2 1 {name=M294
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1720 3 0 {name=l294 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1720 2 1 {name=M295
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1720 3 0 {name=l295 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 1720 2 1 {name=M296
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 1720 3 0 {name=l296 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 1720 2 1 {name=M297
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 1720 3 0 {name=l297 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1720 2 1 {name=M298
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1720 3 0 {name=l298 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 1720 2 1 {name=M299
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 1720 3 0 {name=l299 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1720 2 1 {name=M300
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 1720 3 0 {name=l300 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 1730 3 1 {name=M301
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 1760 3 0 {name=l301 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1730 3 1 {name=M302
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 1760 3 0 {name=l302 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1730 3 1 {name=M303
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1760 3 0 {name=l303 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1730 3 1 {name=M304
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 1760 3 0 {name=l304 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1730 3 1 {name=M305
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 1760 3 0 {name=l305 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1730 3 1 {name=M306
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1760 3 0 {name=l306 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1730 3 1 {name=M307
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1760 3 0 {name=l307 lab=VDD}
C {devices/opin.sym} 2610 1830 0 0 {name=p50 lab=word22}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1800 2 1 {name=M308
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1800 3 0 {name=l308 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1800 2 1 {name=M309
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1800 3 0 {name=l309 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 1800 2 1 {name=M310
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 1800 3 0 {name=l310 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 1800 2 1 {name=M311
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 1800 3 0 {name=l311 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1800 2 1 {name=M312
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1800 3 0 {name=l312 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1800 2 1 {name=M313
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1800 3 0 {name=l313 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1800 2 1 {name=M314
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1800 3 0 {name=l314 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 1810 3 1 {name=M315
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 1840 3 0 {name=l315 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 1810 3 1 {name=M316
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 1840 3 0 {name=l316 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1810 3 1 {name=M317
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1840 3 0 {name=l317 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1810 3 1 {name=M318
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 1840 3 0 {name=l318 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1810 3 1 {name=M319
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 1840 3 0 {name=l319 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1810 3 1 {name=M320
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1840 3 0 {name=l320 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1810 3 1 {name=M321
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1840 3 0 {name=l321 lab=VDD}
C {devices/opin.sym} 2610 1910 0 0 {name=p51 lab=word23}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1880 2 1 {name=M322
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1880 3 0 {name=l322 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1880 2 1 {name=M323
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1880 3 0 {name=l323 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 1880 2 1 {name=M324
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 1880 3 0 {name=l324 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 1880 2 1 {name=M325
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 1880 3 0 {name=l325 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 1880 2 1 {name=M326
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 1880 3 0 {name=l326 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 1880 2 1 {name=M327
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 1880 3 0 {name=l327 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1880 2 1 {name=M328
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 1880 3 0 {name=l328 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 1890 3 1 {name=M329
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 1920 3 0 {name=l329 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 1890 3 1 {name=M330
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 1920 3 0 {name=l330 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 1890 3 1 {name=M331
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 1920 3 0 {name=l331 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 1890 3 1 {name=M332
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 1920 3 0 {name=l332 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1890 3 1 {name=M333
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 1920 3 0 {name=l333 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1890 3 1 {name=M334
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 1920 3 0 {name=l334 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1890 3 1 {name=M335
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 1920 3 0 {name=l335 lab=VDD}
C {devices/opin.sym} 2610 1990 0 0 {name=p52 lab=word24}
C {sky130_fd_pr/nfet_01v8.sym} 2460 1960 2 1 {name=M336
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 1960 3 0 {name=l336 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1960 2 1 {name=M337
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 1960 3 0 {name=l337 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 1960 2 1 {name=M338
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 1960 3 0 {name=l338 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 1960 2 1 {name=M339
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 1960 3 0 {name=l339 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 1960 2 1 {name=M340
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 1960 3 0 {name=l340 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 1960 2 1 {name=M341
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 1960 3 0 {name=l341 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 1960 2 1 {name=M342
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 1960 3 0 {name=l342 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 1970 3 1 {name=M343
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 2000 3 0 {name=l343 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 1970 3 1 {name=M344
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2000 3 0 {name=l344 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 1970 3 1 {name=M345
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2000 3 0 {name=l345 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 1970 3 1 {name=M346
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2000 3 0 {name=l346 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 1970 3 1 {name=M347
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2000 3 0 {name=l347 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 1970 3 1 {name=M348
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2000 3 0 {name=l348 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 1970 3 1 {name=M349
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2000 3 0 {name=l349 lab=VDD}
C {devices/opin.sym} 2610 2070 0 0 {name=p53 lab=word25}
C {sky130_fd_pr/nfet_01v8.sym} 2460 2040 2 1 {name=M350
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 2040 3 0 {name=l350 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 2040 2 1 {name=M351
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 2040 3 0 {name=l351 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 2040 2 1 {name=M352
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 2040 3 0 {name=l352 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2040 2 1 {name=M353
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2040 3 0 {name=l353 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 2040 2 1 {name=M354
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 2040 3 0 {name=l354 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2040 2 1 {name=M355
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2040 3 0 {name=l355 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 2040 2 1 {name=M356
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 2040 3 0 {name=l356 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 2050 3 1 {name=M357
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 2080 3 0 {name=l357 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 2050 3 1 {name=M358
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2080 3 0 {name=l358 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2050 3 1 {name=M359
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2080 3 0 {name=l359 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 2050 3 1 {name=M360
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2080 3 0 {name=l360 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2050 3 1 {name=M361
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2080 3 0 {name=l361 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 2050 3 1 {name=M362
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2080 3 0 {name=l362 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2050 3 1 {name=M363
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2080 3 0 {name=l363 lab=VDD}
C {devices/opin.sym} 2610 2150 0 0 {name=p54 lab=word26}
C {sky130_fd_pr/nfet_01v8.sym} 2460 2120 2 1 {name=M364
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 2120 3 0 {name=l364 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 2120 2 1 {name=M365
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 2120 3 0 {name=l365 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 2120 2 1 {name=M366
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 2120 3 0 {name=l366 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2120 2 1 {name=M367
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2120 3 0 {name=l367 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 2120 2 1 {name=M368
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 2120 3 0 {name=l368 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 2120 2 1 {name=M369
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 2120 3 0 {name=l369 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 2120 2 1 {name=M370
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 2120 3 0 {name=l370 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 2130 3 1 {name=M371
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 2160 3 0 {name=l371 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 2130 3 1 {name=M372
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 2160 3 0 {name=l372 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2130 3 1 {name=M373
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2160 3 0 {name=l373 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 2130 3 1 {name=M374
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2160 3 0 {name=l374 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2130 3 1 {name=M375
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2160 3 0 {name=l375 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 2130 3 1 {name=M376
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2160 3 0 {name=l376 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2130 3 1 {name=M377
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2160 3 0 {name=l377 lab=VDD}
C {devices/opin.sym} 2610 2230 0 0 {name=p55 lab=word27}
C {sky130_fd_pr/nfet_01v8.sym} 2460 2200 2 1 {name=M378
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 2200 3 0 {name=l378 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 2200 2 1 {name=M379
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 2200 3 0 {name=l379 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 2200 2 1 {name=M380
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 2200 3 0 {name=l380 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2200 2 1 {name=M381
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2200 3 0 {name=l381 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 2200 2 1 {name=M382
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 2200 3 0 {name=l382 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 2200 2 1 {name=M383
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 2200 3 0 {name=l383 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 2200 2 1 {name=M384
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 2200 3 0 {name=l384 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 2210 3 1 {name=M385
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 2240 3 0 {name=l385 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 2210 3 1 {name=M386
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 2240 3 0 {name=l386 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2210 3 1 {name=M387
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2240 3 0 {name=l387 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 2210 3 1 {name=M388
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2240 3 0 {name=l388 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2210 3 1 {name=M389
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2240 3 0 {name=l389 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 2210 3 1 {name=M390
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2240 3 0 {name=l390 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2210 3 1 {name=M391
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2240 3 0 {name=l391 lab=VDD}
C {devices/opin.sym} 2610 2310 0 0 {name=p56 lab=word28}
C {sky130_fd_pr/nfet_01v8.sym} 2460 2280 2 1 {name=M392
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 2280 3 0 {name=l392 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 2280 2 1 {name=M393
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 2280 3 0 {name=l393 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 2280 2 1 {name=M394
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 2280 3 0 {name=l394 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2280 2 1 {name=M395
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2280 3 0 {name=l395 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 2280 2 1 {name=M396
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 2280 3 0 {name=l396 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2280 2 1 {name=M397
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2280 3 0 {name=l397 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 2280 2 1 {name=M398
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 2280 3 0 {name=l398 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 2290 3 1 {name=M399
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 2320 3 0 {name=l399 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 2290 3 1 {name=M400
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2320 3 0 {name=l400 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 2290 3 1 {name=M401
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 2320 3 0 {name=l401 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 2290 3 1 {name=M402
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2320 3 0 {name=l402 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2290 3 1 {name=M403
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2320 3 0 {name=l403 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 2290 3 1 {name=M404
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2320 3 0 {name=l404 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2290 3 1 {name=M405
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2320 3 0 {name=l405 lab=VDD}
C {devices/opin.sym} 2610 2390 0 0 {name=p57 lab=word29}
C {sky130_fd_pr/nfet_01v8.sym} 2460 2360 2 1 {name=M406
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 2360 3 0 {name=l406 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 2360 2 1 {name=M407
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 2360 3 0 {name=l407 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 2360 2 1 {name=M408
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 2360 3 0 {name=l408 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2360 2 1 {name=M409
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2360 3 0 {name=l409 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 2360 2 1 {name=M410
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 2360 3 0 {name=l410 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2360 2 1 {name=M411
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2360 3 0 {name=l411 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 2360 2 1 {name=M412
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 2360 3 0 {name=l412 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 2370 3 1 {name=M413
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 2400 3 0 {name=l413 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 2370 3 1 {name=M414
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2400 3 0 {name=l414 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 2370 3 1 {name=M415
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 2400 3 0 {name=l415 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 2370 3 1 {name=M416
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2400 3 0 {name=l416 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2370 3 1 {name=M417
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2400 3 0 {name=l417 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 2370 3 1 {name=M418
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2400 3 0 {name=l418 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2370 3 1 {name=M419
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2400 3 0 {name=l419 lab=VDD}
C {devices/opin.sym} 2610 2470 0 0 {name=p58 lab=word30}
C {sky130_fd_pr/nfet_01v8.sym} 2460 2440 2 1 {name=M420
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 2440 3 0 {name=l420 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 2440 2 1 {name=M421
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 2440 3 0 {name=l421 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 2440 2 1 {name=M422
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 2440 3 0 {name=l422 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2440 2 1 {name=M423
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2440 3 0 {name=l423 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 2440 2 1 {name=M424
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 2440 3 0 {name=l424 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 2440 2 1 {name=M425
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 2440 3 0 {name=l425 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 2440 2 1 {name=M426
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 2440 3 0 {name=l426 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 2450 3 1 {name=M427
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 2480 3 0 {name=l427 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 2450 3 1 {name=M428
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 2480 3 0 {name=l428 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 2450 3 1 {name=M429
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 2480 3 0 {name=l429 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 2450 3 1 {name=M430
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2480 3 0 {name=l430 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2450 3 1 {name=M431
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2480 3 0 {name=l431 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 2450 3 1 {name=M432
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2480 3 0 {name=l432 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2450 3 1 {name=M433
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2480 3 0 {name=l433 lab=VDD}
C {devices/opin.sym} 2610 2550 0 0 {name=p59 lab=word31}
C {sky130_fd_pr/nfet_01v8.sym} 2460 2520 2 1 {name=M434
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 2520 3 0 {name=l434 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2280 2520 2 1 {name=M435
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2310 2520 3 0 {name=l435 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 2520 2 1 {name=M436
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 2520 3 0 {name=l436 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 2520 2 1 {name=M437
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 2520 3 0 {name=l437 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 2520 2 1 {name=M438
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 2520 3 0 {name=l438 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 2520 2 1 {name=M439
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 2520 3 0 {name=l439 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 2520 2 1 {name=M440
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 2520 3 0 {name=l440 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 2530 3 1 {name=M441
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 2560 3 0 {name=l441 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 2530 3 1 {name=M442
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 2560 3 0 {name=l442 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 2530 3 1 {name=M443
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 2560 3 0 {name=l443 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 2530 3 1 {name=M444
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 2560 3 0 {name=l444 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 2530 3 1 {name=M445
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 2560 3 0 {name=l445 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 310 2530 3 1 {name=M446
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 310 2560 3 0 {name=l446 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2530 3 1 {name=M447
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2560 3 0 {name=l447 lab=VDD}
C {devices/opin.sym} 2610 2630 0 0 {name=p60 lab=word32}
C {sky130_fd_pr/nfet_01v8.sym} 2460 2600 2 1 {name=M448
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 2600 3 0 {name=l448 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 2600 2 1 {name=M449
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 2600 3 0 {name=l449 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 2600 2 1 {name=M450
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 2600 3 0 {name=l450 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 2600 2 1 {name=M451
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 2600 3 0 {name=l451 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 2600 2 1 {name=M452
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 2600 3 0 {name=l452 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2600 2 1 {name=M453
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2600 3 0 {name=l453 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 2600 2 1 {name=M454
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 2600 3 0 {name=l454 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 2610 3 1 {name=M455
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 2640 3 0 {name=l455 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 2610 3 1 {name=M456
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2640 3 0 {name=l456 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2610 3 1 {name=M457
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2640 3 0 {name=l457 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 2610 3 1 {name=M458
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2640 3 0 {name=l458 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 2610 3 1 {name=M459
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 2640 3 0 {name=l459 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 2610 3 1 {name=M460
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2640 3 0 {name=l460 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2610 3 1 {name=M461
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2640 3 0 {name=l461 lab=VDD}
C {devices/opin.sym} 2610 2710 0 0 {name=p61 lab=word33}
C {sky130_fd_pr/nfet_01v8.sym} 2460 2680 2 1 {name=M462
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 2680 3 0 {name=l462 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 2680 2 1 {name=M463
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 2680 3 0 {name=l463 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 2680 2 1 {name=M464
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 2680 3 0 {name=l464 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 2680 2 1 {name=M465
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 2680 3 0 {name=l465 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 2680 2 1 {name=M466
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 2680 3 0 {name=l466 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2680 2 1 {name=M467
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2680 3 0 {name=l467 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 2680 2 1 {name=M468
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 2680 3 0 {name=l468 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 2690 3 1 {name=M469
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 2720 3 0 {name=l469 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 2690 3 1 {name=M470
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2720 3 0 {name=l470 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2690 3 1 {name=M471
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2720 3 0 {name=l471 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 2690 3 1 {name=M472
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2720 3 0 {name=l472 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 2690 3 1 {name=M473
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 2720 3 0 {name=l473 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 2690 3 1 {name=M474
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2720 3 0 {name=l474 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2690 3 1 {name=M475
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2720 3 0 {name=l475 lab=VDD}
C {devices/opin.sym} 2610 2790 0 0 {name=p62 lab=word34}
C {sky130_fd_pr/nfet_01v8.sym} 2460 2760 2 1 {name=M476
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 2760 3 0 {name=l476 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 2760 2 1 {name=M477
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 2760 3 0 {name=l477 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 2760 2 1 {name=M478
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 2760 3 0 {name=l478 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 2760 2 1 {name=M479
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 2760 3 0 {name=l479 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 2760 2 1 {name=M480
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 2760 3 0 {name=l480 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 2760 2 1 {name=M481
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 2760 3 0 {name=l481 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 2760 2 1 {name=M482
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 2760 3 0 {name=l482 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 2770 3 1 {name=M483
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 2800 3 0 {name=l483 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 2770 3 1 {name=M484
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 2800 3 0 {name=l484 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2770 3 1 {name=M485
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2800 3 0 {name=l485 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 2770 3 1 {name=M486
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2800 3 0 {name=l486 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 2770 3 1 {name=M487
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 2800 3 0 {name=l487 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 2770 3 1 {name=M488
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2800 3 0 {name=l488 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2770 3 1 {name=M489
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2800 3 0 {name=l489 lab=VDD}
C {devices/opin.sym} 2610 2870 0 0 {name=p63 lab=word35}
C {sky130_fd_pr/nfet_01v8.sym} 2460 2840 2 1 {name=M490
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 2840 3 0 {name=l490 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 2840 2 1 {name=M491
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 2840 3 0 {name=l491 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 2840 2 1 {name=M492
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 2840 3 0 {name=l492 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 2840 2 1 {name=M493
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 2840 3 0 {name=l493 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 2840 2 1 {name=M494
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 2840 3 0 {name=l494 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 2840 2 1 {name=M495
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 2840 3 0 {name=l495 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 2840 2 1 {name=M496
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 2840 3 0 {name=l496 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 2850 3 1 {name=M497
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 2880 3 0 {name=l497 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 2850 3 1 {name=M498
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 2880 3 0 {name=l498 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 2850 3 1 {name=M499
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 2880 3 0 {name=l499 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 2850 3 1 {name=M500
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2880 3 0 {name=l500 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 2850 3 1 {name=M501
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 2880 3 0 {name=l501 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 2850 3 1 {name=M502
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2880 3 0 {name=l502 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2850 3 1 {name=M503
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2880 3 0 {name=l503 lab=VDD}
C {devices/opin.sym} 2610 2950 0 0 {name=p64 lab=word36}
C {sky130_fd_pr/nfet_01v8.sym} 2460 2920 2 1 {name=M504
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 2920 3 0 {name=l504 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 2920 2 1 {name=M505
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 2920 3 0 {name=l505 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 2920 2 1 {name=M506
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 2920 3 0 {name=l506 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 2920 2 1 {name=M507
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 2920 3 0 {name=l507 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 2920 2 1 {name=M508
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 2920 3 0 {name=l508 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 2920 2 1 {name=M509
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 2920 3 0 {name=l509 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 2920 2 1 {name=M510
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 2920 3 0 {name=l510 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 2930 3 1 {name=M511
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 2960 3 0 {name=l511 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 2930 3 1 {name=M512
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 2960 3 0 {name=l512 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 2930 3 1 {name=M513
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 2960 3 0 {name=l513 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 2930 3 1 {name=M514
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 2960 3 0 {name=l514 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 2930 3 1 {name=M515
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 2960 3 0 {name=l515 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 2930 3 1 {name=M516
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 2960 3 0 {name=l516 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 2930 3 1 {name=M517
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 2960 3 0 {name=l517 lab=VDD}
C {devices/opin.sym} 2610 3030 0 0 {name=p65 lab=word37}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3000 2 1 {name=M518
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3000 3 0 {name=l518 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3000 2 1 {name=M519
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3000 3 0 {name=l519 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 3000 2 1 {name=M520
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 3000 3 0 {name=l520 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 3000 2 1 {name=M521
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 3000 3 0 {name=l521 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 3000 2 1 {name=M522
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 3000 3 0 {name=l522 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 3000 2 1 {name=M523
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 3000 3 0 {name=l523 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 3000 2 1 {name=M524
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 3000 3 0 {name=l524 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 3010 3 1 {name=M525
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 3040 3 0 {name=l525 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 3010 3 1 {name=M526
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 3040 3 0 {name=l526 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 3010 3 1 {name=M527
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 3040 3 0 {name=l527 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 3010 3 1 {name=M528
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 3040 3 0 {name=l528 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3010 3 1 {name=M529
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3040 3 0 {name=l529 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3010 3 1 {name=M530
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 3040 3 0 {name=l530 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3010 3 1 {name=M531
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 3040 3 0 {name=l531 lab=VDD}
C {devices/opin.sym} 2610 3110 0 0 {name=p66 lab=word38}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3080 2 1 {name=M532
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3080 3 0 {name=l532 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3080 2 1 {name=M533
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3080 3 0 {name=l533 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 3080 2 1 {name=M534
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 3080 3 0 {name=l534 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 3080 2 1 {name=M535
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 3080 3 0 {name=l535 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 3080 2 1 {name=M536
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 3080 3 0 {name=l536 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 3080 2 1 {name=M537
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 3080 3 0 {name=l537 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 3080 2 1 {name=M538
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 3080 3 0 {name=l538 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 3090 3 1 {name=M539
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 3120 3 0 {name=l539 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 3090 3 1 {name=M540
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 3120 3 0 {name=l540 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 3090 3 1 {name=M541
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 3120 3 0 {name=l541 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 3090 3 1 {name=M542
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 3120 3 0 {name=l542 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3090 3 1 {name=M543
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3120 3 0 {name=l543 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3090 3 1 {name=M544
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 3120 3 0 {name=l544 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3090 3 1 {name=M545
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 3120 3 0 {name=l545 lab=VDD}
C {devices/opin.sym} 2610 3190 0 0 {name=p67 lab=word39}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3160 2 1 {name=M546
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3160 3 0 {name=l546 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3160 2 1 {name=M547
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3160 3 0 {name=l547 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 3160 2 1 {name=M548
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 3160 3 0 {name=l548 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 3160 2 1 {name=M549
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 3160 3 0 {name=l549 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 3160 2 1 {name=M550
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 3160 3 0 {name=l550 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 3160 2 1 {name=M551
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 3160 3 0 {name=l551 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 3160 2 1 {name=M552
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 3160 3 0 {name=l552 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 3170 3 1 {name=M553
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 3200 3 0 {name=l553 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 3170 3 1 {name=M554
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 3200 3 0 {name=l554 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 3170 3 1 {name=M555
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 3200 3 0 {name=l555 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 3170 3 1 {name=M556
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 3200 3 0 {name=l556 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3170 3 1 {name=M557
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3200 3 0 {name=l557 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3170 3 1 {name=M558
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 3200 3 0 {name=l558 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3170 3 1 {name=M559
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 3200 3 0 {name=l559 lab=VDD}
C {devices/opin.sym} 2610 3270 0 0 {name=p68 lab=word40}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3240 2 1 {name=M560
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3240 3 0 {name=l560 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3240 2 1 {name=M561
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3240 3 0 {name=l561 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 3240 2 1 {name=M562
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 3240 3 0 {name=l562 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 3240 2 1 {name=M563
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 3240 3 0 {name=l563 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 3240 2 1 {name=M564
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 3240 3 0 {name=l564 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 3240 2 1 {name=M565
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 3240 3 0 {name=l565 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 3240 2 1 {name=M566
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 3240 3 0 {name=l566 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 3250 3 1 {name=M567
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 3280 3 0 {name=l567 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 3250 3 1 {name=M568
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 3280 3 0 {name=l568 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 3250 3 1 {name=M569
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 3280 3 0 {name=l569 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 3250 3 1 {name=M570
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 3280 3 0 {name=l570 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3250 3 1 {name=M571
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3280 3 0 {name=l571 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3250 3 1 {name=M572
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 3280 3 0 {name=l572 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3250 3 1 {name=M573
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 3280 3 0 {name=l573 lab=VDD}
C {devices/opin.sym} 2610 3350 0 0 {name=p69 lab=word41}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3320 2 1 {name=M574
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3320 3 0 {name=l574 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3320 2 1 {name=M575
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3320 3 0 {name=l575 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 3320 2 1 {name=M576
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 3320 3 0 {name=l576 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 3320 2 1 {name=M577
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 3320 3 0 {name=l577 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 3320 2 1 {name=M578
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 3320 3 0 {name=l578 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 3320 2 1 {name=M579
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 3320 3 0 {name=l579 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 3320 2 1 {name=M580
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 3320 3 0 {name=l580 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 3330 3 1 {name=M581
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 3360 3 0 {name=l581 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 3330 3 1 {name=M582
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 3360 3 0 {name=l582 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 3330 3 1 {name=M583
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 3360 3 0 {name=l583 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 3330 3 1 {name=M584
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 3360 3 0 {name=l584 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3330 3 1 {name=M585
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3360 3 0 {name=l585 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3330 3 1 {name=M586
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 3360 3 0 {name=l586 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3330 3 1 {name=M587
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 3360 3 0 {name=l587 lab=VDD}
C {devices/opin.sym} 2610 3430 0 0 {name=p70 lab=word42}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3400 2 1 {name=M588
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3400 3 0 {name=l588 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3400 2 1 {name=M589
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3400 3 0 {name=l589 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 3400 2 1 {name=M590
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 3400 3 0 {name=l590 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 3400 2 1 {name=M591
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 3400 3 0 {name=l591 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 3400 2 1 {name=M592
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 3400 3 0 {name=l592 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 3400 2 1 {name=M593
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 3400 3 0 {name=l593 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 3400 2 1 {name=M594
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 3400 3 0 {name=l594 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 3410 3 1 {name=M595
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 3440 3 0 {name=l595 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 3410 3 1 {name=M596
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 3440 3 0 {name=l596 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 3410 3 1 {name=M597
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 3440 3 0 {name=l597 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 3410 3 1 {name=M598
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 3440 3 0 {name=l598 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3410 3 1 {name=M599
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3440 3 0 {name=l599 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3410 3 1 {name=M600
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 3440 3 0 {name=l600 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3410 3 1 {name=M601
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 3440 3 0 {name=l601 lab=VDD}
C {devices/opin.sym} 2610 3510 0 0 {name=p71 lab=word43}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3480 2 1 {name=M602
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3480 3 0 {name=l602 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3480 2 1 {name=M603
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3480 3 0 {name=l603 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 3480 2 1 {name=M604
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 3480 3 0 {name=l604 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 3480 2 1 {name=M605
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 3480 3 0 {name=l605 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 3480 2 1 {name=M606
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 3480 3 0 {name=l606 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 3480 2 1 {name=M607
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 3480 3 0 {name=l607 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 3480 2 1 {name=M608
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 3480 3 0 {name=l608 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 3490 3 1 {name=M609
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 3520 3 0 {name=l609 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 3490 3 1 {name=M610
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 3520 3 0 {name=l610 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 3490 3 1 {name=M611
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 3520 3 0 {name=l611 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 3490 3 1 {name=M612
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 3520 3 0 {name=l612 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3490 3 1 {name=M613
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3520 3 0 {name=l613 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3490 3 1 {name=M614
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 3520 3 0 {name=l614 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3490 3 1 {name=M615
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 3520 3 0 {name=l615 lab=VDD}
C {devices/opin.sym} 2610 3590 0 0 {name=p72 lab=word44}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3560 2 1 {name=M616
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3560 3 0 {name=l616 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3560 2 1 {name=M617
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3560 3 0 {name=l617 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 3560 2 1 {name=M618
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 3560 3 0 {name=l618 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 3560 2 1 {name=M619
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 3560 3 0 {name=l619 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 3560 2 1 {name=M620
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 3560 3 0 {name=l620 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 3560 2 1 {name=M621
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 3560 3 0 {name=l621 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 3560 2 1 {name=M622
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 3560 3 0 {name=l622 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 3570 3 1 {name=M623
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 3600 3 0 {name=l623 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 3570 3 1 {name=M624
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 3600 3 0 {name=l624 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 3570 3 1 {name=M625
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 3600 3 0 {name=l625 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 3570 3 1 {name=M626
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 3600 3 0 {name=l626 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3570 3 1 {name=M627
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3600 3 0 {name=l627 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3570 3 1 {name=M628
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 3600 3 0 {name=l628 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3570 3 1 {name=M629
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 3600 3 0 {name=l629 lab=VDD}
C {devices/opin.sym} 2610 3670 0 0 {name=p73 lab=word45}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3640 2 1 {name=M630
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3640 3 0 {name=l630 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3640 2 1 {name=M631
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3640 3 0 {name=l631 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 3640 2 1 {name=M632
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 3640 3 0 {name=l632 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 3640 2 1 {name=M633
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 3640 3 0 {name=l633 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 3640 2 1 {name=M634
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 3640 3 0 {name=l634 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 3640 2 1 {name=M635
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 3640 3 0 {name=l635 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 3640 2 1 {name=M636
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 3640 3 0 {name=l636 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 3650 3 1 {name=M637
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 3680 3 0 {name=l637 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 3650 3 1 {name=M638
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 3680 3 0 {name=l638 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 3650 3 1 {name=M639
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 3680 3 0 {name=l639 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 3650 3 1 {name=M640
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 3680 3 0 {name=l640 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3650 3 1 {name=M641
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3680 3 0 {name=l641 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3650 3 1 {name=M642
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 3680 3 0 {name=l642 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3650 3 1 {name=M643
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 3680 3 0 {name=l643 lab=VDD}
C {devices/opin.sym} 2610 3750 0 0 {name=p74 lab=word46}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3720 2 1 {name=M644
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3720 3 0 {name=l644 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3720 2 1 {name=M645
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3720 3 0 {name=l645 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 3720 2 1 {name=M646
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 3720 3 0 {name=l646 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 3720 2 1 {name=M647
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 3720 3 0 {name=l647 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 3720 2 1 {name=M648
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 3720 3 0 {name=l648 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 3720 2 1 {name=M649
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 3720 3 0 {name=l649 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 3720 2 1 {name=M650
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 3720 3 0 {name=l650 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 3730 3 1 {name=M651
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 3760 3 0 {name=l651 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 3730 3 1 {name=M652
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 3760 3 0 {name=l652 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 3730 3 1 {name=M653
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 3760 3 0 {name=l653 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 3730 3 1 {name=M654
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 3760 3 0 {name=l654 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3730 3 1 {name=M655
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3760 3 0 {name=l655 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3730 3 1 {name=M656
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 3760 3 0 {name=l656 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3730 3 1 {name=M657
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 3760 3 0 {name=l657 lab=VDD}
C {devices/opin.sym} 2610 3830 0 0 {name=p75 lab=word47}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3800 2 1 {name=M658
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3800 3 0 {name=l658 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3800 2 1 {name=M659
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3800 3 0 {name=l659 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2100 3800 2 1 {name=M660
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 3800 3 0 {name=l660 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 3800 2 1 {name=M661
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 3800 3 0 {name=l661 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 3800 2 1 {name=M662
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 3800 3 0 {name=l662 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 3800 2 1 {name=M663
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 3800 3 0 {name=l663 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 3800 2 1 {name=M664
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 3800 3 0 {name=l664 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 3810 3 1 {name=M665
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 3840 3 0 {name=l665 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 3810 3 1 {name=M666
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 3840 3 0 {name=l666 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 3810 3 1 {name=M667
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 3840 3 0 {name=l667 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 580 3810 3 1 {name=M668
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 580 3840 3 0 {name=l668 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 490 3810 3 1 {name=M669
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 490 3840 3 0 {name=l669 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3810 3 1 {name=M670
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 3840 3 0 {name=l670 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3810 3 1 {name=M671
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 3840 3 0 {name=l671 lab=VDD}
C {devices/opin.sym} 2610 3910 0 0 {name=p76 lab=word48}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3880 2 1 {name=M672
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3880 3 0 {name=l672 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3880 2 1 {name=M673
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3880 3 0 {name=l673 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 3880 2 1 {name=M674
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 3880 3 0 {name=l674 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 3880 2 1 {name=M675
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 3880 3 0 {name=l675 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 3880 2 1 {name=M676
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 3880 3 0 {name=l676 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 3880 2 1 {name=M677
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 3880 3 0 {name=l677 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 3880 2 1 {name=M678
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 3880 3 0 {name=l678 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 3890 3 1 {name=M679
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 3920 3 0 {name=l679 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 3890 3 1 {name=M680
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 3920 3 0 {name=l680 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 3890 3 1 {name=M681
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 3920 3 0 {name=l681 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 3890 3 1 {name=M682
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 3920 3 0 {name=l682 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 3890 3 1 {name=M683
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 3920 3 0 {name=l683 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3890 3 1 {name=M684
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 3920 3 0 {name=l684 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3890 3 1 {name=M685
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 3920 3 0 {name=l685 lab=VDD}
C {devices/opin.sym} 2610 3990 0 0 {name=p77 lab=word49}
C {sky130_fd_pr/nfet_01v8.sym} 2460 3960 2 1 {name=M686
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 3960 3 0 {name=l686 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 3960 2 1 {name=M687
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 3960 3 0 {name=l687 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 3960 2 1 {name=M688
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 3960 3 0 {name=l688 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 3960 2 1 {name=M689
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 3960 3 0 {name=l689 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 3960 2 1 {name=M690
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 3960 3 0 {name=l690 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 3960 2 1 {name=M691
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 3960 3 0 {name=l691 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 3960 2 1 {name=M692
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 3960 3 0 {name=l692 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 3970 3 1 {name=M693
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 4000 3 0 {name=l693 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 3970 3 1 {name=M694
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 4000 3 0 {name=l694 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 3970 3 1 {name=M695
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 4000 3 0 {name=l695 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 3970 3 1 {name=M696
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 4000 3 0 {name=l696 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 3970 3 1 {name=M697
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 4000 3 0 {name=l697 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 3970 3 1 {name=M698
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 4000 3 0 {name=l698 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 3970 3 1 {name=M699
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 4000 3 0 {name=l699 lab=VDD}
C {devices/opin.sym} 2610 4070 0 0 {name=p78 lab=word50}
C {sky130_fd_pr/nfet_01v8.sym} 2460 4040 2 1 {name=M700
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 4040 3 0 {name=l700 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 4040 2 1 {name=M701
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 4040 3 0 {name=l701 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 4040 2 1 {name=M702
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 4040 3 0 {name=l702 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 4040 2 1 {name=M703
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 4040 3 0 {name=l703 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 4040 2 1 {name=M704
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 4040 3 0 {name=l704 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 4040 2 1 {name=M705
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 4040 3 0 {name=l705 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 4040 2 1 {name=M706
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 4040 3 0 {name=l706 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 4050 3 1 {name=M707
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 4080 3 0 {name=l707 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 4050 3 1 {name=M708
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 4080 3 0 {name=l708 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 4050 3 1 {name=M709
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 4080 3 0 {name=l709 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 4050 3 1 {name=M710
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 4080 3 0 {name=l710 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 4050 3 1 {name=M711
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 4080 3 0 {name=l711 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 4050 3 1 {name=M712
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 4080 3 0 {name=l712 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 4050 3 1 {name=M713
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 4080 3 0 {name=l713 lab=VDD}
C {devices/opin.sym} 2610 4150 0 0 {name=p79 lab=word51}
C {sky130_fd_pr/nfet_01v8.sym} 2460 4120 2 1 {name=M714
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 4120 3 0 {name=l714 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 4120 2 1 {name=M715
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 4120 3 0 {name=l715 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 4120 2 1 {name=M716
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 4120 3 0 {name=l716 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 4120 2 1 {name=M717
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 4120 3 0 {name=l717 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 4120 2 1 {name=M718
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 4120 3 0 {name=l718 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 4120 2 1 {name=M719
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 4120 3 0 {name=l719 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 4120 2 1 {name=M720
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 4120 3 0 {name=l720 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 4130 3 1 {name=M721
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 4160 3 0 {name=l721 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 4130 3 1 {name=M722
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 4160 3 0 {name=l722 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 850 4130 3 1 {name=M723
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 850 4160 3 0 {name=l723 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 4130 3 1 {name=M724
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 4160 3 0 {name=l724 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 4130 3 1 {name=M725
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 4160 3 0 {name=l725 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 4130 3 1 {name=M726
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 4160 3 0 {name=l726 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 4130 3 1 {name=M727
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 4160 3 0 {name=l727 lab=VDD}
C {devices/opin.sym} 2610 4230 0 0 {name=p80 lab=word52}
C {sky130_fd_pr/nfet_01v8.sym} 2460 4200 2 1 {name=M728
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 4200 3 0 {name=l728 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 4200 2 1 {name=M729
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 4200 3 0 {name=l729 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 4200 2 1 {name=M730
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 4200 3 0 {name=l730 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 4200 2 1 {name=M731
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 4200 3 0 {name=l731 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 4200 2 1 {name=M732
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 4200 3 0 {name=l732 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 4200 2 1 {name=M733
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 4200 3 0 {name=l733 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 4200 2 1 {name=M734
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 4200 3 0 {name=l734 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 4210 3 1 {name=M735
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 4240 3 0 {name=l735 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 4210 3 1 {name=M736
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 4240 3 0 {name=l736 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 4210 3 1 {name=M737
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 4240 3 0 {name=l737 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 4210 3 1 {name=M738
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 4240 3 0 {name=l738 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 4210 3 1 {name=M739
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 4240 3 0 {name=l739 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 4210 3 1 {name=M740
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 4240 3 0 {name=l740 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 4210 3 1 {name=M741
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 4240 3 0 {name=l741 lab=VDD}
C {devices/opin.sym} 2610 4310 0 0 {name=p81 lab=word53}
C {sky130_fd_pr/nfet_01v8.sym} 2460 4280 2 1 {name=M742
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 4280 3 0 {name=l742 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 4280 2 1 {name=M743
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 4280 3 0 {name=l743 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 4280 2 1 {name=M744
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 4280 3 0 {name=l744 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 4280 2 1 {name=M745
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 4280 3 0 {name=l745 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 4280 2 1 {name=M746
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 4280 3 0 {name=l746 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1560 4280 2 1 {name=M747
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1590 4280 3 0 {name=l747 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 4280 2 1 {name=M748
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 4280 3 0 {name=l748 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 4290 3 1 {name=M749
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 4320 3 0 {name=l749 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1030 4290 3 1 {name=M750
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1030 4320 3 0 {name=l750 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 4290 3 1 {name=M751
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 4320 3 0 {name=l751 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 4290 3 1 {name=M752
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 4320 3 0 {name=l752 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 4290 3 1 {name=M753
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 4320 3 0 {name=l753 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 4290 3 1 {name=M754
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 4320 3 0 {name=l754 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 4290 3 1 {name=M755
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 4320 3 0 {name=l755 lab=VDD}
C {devices/opin.sym} 2610 4390 0 0 {name=p82 lab=word54}
C {sky130_fd_pr/nfet_01v8.sym} 2460 4360 2 1 {name=M756
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 4360 3 0 {name=l756 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 4360 2 1 {name=M757
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 4360 3 0 {name=l757 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 4360 2 1 {name=M758
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 4360 3 0 {name=l758 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 4360 2 1 {name=M759
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 4360 3 0 {name=l759 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 4360 2 1 {name=M760
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 4360 3 0 {name=l760 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 4360 2 1 {name=M761
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 4360 3 0 {name=l761 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1380 4360 2 1 {name=M762
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1410 4360 3 0 {name=l762 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1210 4370 3 1 {name=M763
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1210 4400 3 0 {name=l763 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 4370 3 1 {name=M764
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 4400 3 0 {name=l764 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 4370 3 1 {name=M765
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 4400 3 0 {name=l765 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 4370 3 1 {name=M766
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 4400 3 0 {name=l766 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 4370 3 1 {name=M767
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 4400 3 0 {name=l767 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 4370 3 1 {name=M768
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 4400 3 0 {name=l768 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 4370 3 1 {name=M769
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 4400 3 0 {name=l769 lab=VDD}
C {devices/opin.sym} 2610 4470 0 0 {name=p83 lab=word55}
C {sky130_fd_pr/nfet_01v8.sym} 2460 4440 2 1 {name=M770
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 4440 3 0 {name=l770 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 4440 2 1 {name=M771
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 4440 3 0 {name=l771 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 4440 2 1 {name=M772
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 4440 3 0 {name=l772 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1920 4440 2 1 {name=M773
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1950 4440 3 0 {name=l773 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1830 4440 2 1 {name=M774
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1860 4440 3 0 {name=l774 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1650 4440 2 1 {name=M775
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1680 4440 3 0 {name=l775 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1470 4440 2 1 {name=M776
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1500 4440 3 0 {name=l776 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1120 4450 3 1 {name=M777
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1120 4480 3 0 {name=l777 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 940 4450 3 1 {name=M778
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 940 4480 3 0 {name=l778 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 760 4450 3 1 {name=M779
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 760 4480 3 0 {name=l779 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 670 4450 3 1 {name=M780
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 670 4480 3 0 {name=l780 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 400 4450 3 1 {name=M781
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 400 4480 3 0 {name=l781 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 220 4450 3 1 {name=M782
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 220 4480 3 0 {name=l782 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 130 4450 3 1 {name=M783
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 130 4480 3 0 {name=l783 lab=VDD}
C {devices/opin.sym} 2610 4550 0 0 {name=p84 lab=word56}
C {sky130_fd_pr/nfet_01v8.sym} 2460 4520 2 1 {name=M784
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2490 4520 3 0 {name=l784 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 4520 2 1 {name=M785
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2400 4520 3 0 {name=l785 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2190 4520 2 1 {name=M786
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2220 4520 3 0 {name=l786 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2010 4520 2 1 {name=M787
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2040 4520 3 0 {name=l787 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1740 4520 2 1 {name=M788
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1770 4520 3 0 {name=l788 lab=GND}
