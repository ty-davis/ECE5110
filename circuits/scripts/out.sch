N 600 7850 600 7860 {
lab=GND}
N 560 7810 600 7810 {
lab=word130}
N 600 7810 640 7810 {
lab=word130}
N 570 7800 570 7850 {
lab=GND}
N 570 7850 570 7860 {
lab=GND}
N 630 7800 630 7850 {
lab=Y7}
N 630 7850 630 7860 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 7830 1 0 {name=M525
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 7870 0 0 {name=p154 lab=word131}
N 0 7870 40 7870 {
lab=word131}
N 40 7870 80 7870 {
lab=word131}
N 10 7860 10 7910 {
lab=GND}
N 10 7910 10 7920 {
lab=GND}
N 70 7860 70 7910 {
lab=Y0}
N 70 7910 70 7920 {
lab=Y0}
N 80 7870 120 7870 {
lab=word131}
N 120 7870 160 7870 {
lab=word131}
N 90 7860 90 7910 {
lab=GND}
N 90 7910 90 7920 {
lab=GND}
N 150 7860 150 7910 {
lab=Y1}
N 150 7910 150 7920 {
lab=Y1}
N 160 7870 200 7870 {
lab=word131}
N 200 7870 240 7870 {
lab=word131}
N 170 7860 170 7910 {
lab=GND}
N 170 7910 170 7920 {
lab=GND}
N 230 7860 230 7910 {
lab=Y2}
N 230 7910 230 7920 {
lab=Y2}
N 240 7870 280 7870 {
lab=word131}
N 280 7870 320 7870 {
lab=word131}
N 250 7860 250 7910 {
lab=GND}
N 250 7910 250 7920 {
lab=GND}
N 310 7860 310 7910 {
lab=Y3}
N 310 7910 310 7920 {
lab=Y3}

N 330 7920 360 7920 {
lab=GND}
N 360 7910 360 7920 {
lab=GND}
N 320 7870 360 7870 {
lab=word131}
N 360 7870 400 7870 {
lab=word131}
N 330 7860 330 7910 {
lab=GND}
N 330 7910 330 7920 {
lab=GND}
N 390 7860 390 7910 {
lab=Y4}
N 390 7910 390 7920 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 7890 1 0 {name=M526
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 7870 440 7870 {
lab=word131}
N 440 7870 480 7870 {
lab=word131}
N 410 7860 410 7910 {
lab=GND}
N 410 7910 410 7920 {
lab=GND}
N 470 7860 470 7910 {
lab=Y5}
N 470 7910 470 7920 {
lab=Y5}

N 490 7920 520 7920 {
lab=GND}
N 520 7910 520 7920 {
lab=GND}
N 480 7870 520 7870 {
lab=word131}
N 520 7870 560 7870 {
lab=word131}
N 490 7860 490 7910 {
lab=GND}
N 490 7910 490 7920 {
lab=GND}
N 550 7860 550 7910 {
lab=Y6}
N 550 7910 550 7920 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 7890 1 0 {name=M527
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 7920 600 7920 {
lab=GND}
N 600 7910 600 7920 {
lab=GND}
N 560 7870 600 7870 {
lab=word131}
N 600 7870 640 7870 {
lab=word131}
N 570 7860 570 7910 {
lab=GND}
N 570 7910 570 7920 {
lab=GND}
N 630 7860 630 7910 {
lab=Y7}
N 630 7910 630 7920 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 7890 1 0 {name=M528
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 7930 0 0 {name=p155 lab=word132}
N 0 7930 40 7930 {
lab=word132}
N 40 7930 80 7930 {
lab=word132}
N 10 7920 10 7970 {
lab=GND}
N 10 7970 10 7980 {
lab=GND}
N 70 7920 70 7970 {
lab=Y0}
N 70 7970 70 7980 {
lab=Y0}
N 80 7930 120 7930 {
lab=word132}
N 120 7930 160 7930 {
lab=word132}
N 90 7920 90 7970 {
lab=GND}
N 90 7970 90 7980 {
lab=GND}
N 150 7920 150 7970 {
lab=Y1}
N 150 7970 150 7980 {
lab=Y1}
N 160 7930 200 7930 {
lab=word132}
N 200 7930 240 7930 {
lab=word132}
N 170 7920 170 7970 {
lab=GND}
N 170 7970 170 7980 {
lab=GND}
N 230 7920 230 7970 {
lab=Y2}
N 230 7970 230 7980 {
lab=Y2}
N 240 7930 280 7930 {
lab=word132}
N 280 7930 320 7930 {
lab=word132}
N 250 7920 250 7970 {
lab=GND}
N 250 7970 250 7980 {
lab=GND}
N 310 7920 310 7970 {
lab=Y3}
N 310 7970 310 7980 {
lab=Y3}

N 330 7980 360 7980 {
lab=GND}
N 360 7970 360 7980 {
lab=GND}
N 320 7930 360 7930 {
lab=word132}
N 360 7930 400 7930 {
lab=word132}
N 330 7920 330 7970 {
lab=GND}
N 330 7970 330 7980 {
lab=GND}
N 390 7920 390 7970 {
lab=Y4}
N 390 7970 390 7980 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 7950 1 0 {name=M529
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 7980 440 7980 {
lab=GND}
N 440 7970 440 7980 {
lab=GND}
N 400 7930 440 7930 {
lab=word132}
N 440 7930 480 7930 {
lab=word132}
N 410 7920 410 7970 {
lab=GND}
N 410 7970 410 7980 {
lab=GND}
N 470 7920 470 7970 {
lab=Y5}
N 470 7970 470 7980 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 7950 1 0 {name=M530
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 7980 520 7980 {
lab=GND}
N 520 7970 520 7980 {
lab=GND}
N 480 7930 520 7930 {
lab=word132}
N 520 7930 560 7930 {
lab=word132}
N 490 7920 490 7970 {
lab=GND}
N 490 7970 490 7980 {
lab=GND}
N 550 7920 550 7970 {
lab=Y6}
N 550 7970 550 7980 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 7950 1 0 {name=M531
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 7980 600 7980 {
lab=GND}
N 600 7970 600 7980 {
lab=GND}
N 560 7930 600 7930 {
lab=word132}
N 600 7930 640 7930 {
lab=word132}
N 570 7920 570 7970 {
lab=GND}
N 570 7970 570 7980 {
lab=GND}
N 630 7920 630 7970 {
lab=Y7}
N 630 7970 630 7980 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 7950 1 0 {name=M532
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 7990 0 0 {name=p156 lab=word133}
N 0 7990 40 7990 {
lab=word133}
N 40 7990 80 7990 {
lab=word133}
N 10 7980 10 8030 {
lab=GND}
N 10 8030 10 8040 {
lab=GND}
N 70 7980 70 8030 {
lab=Y0}
N 70 8030 70 8040 {
lab=Y0}
N 80 7990 120 7990 {
lab=word133}
N 120 7990 160 7990 {
lab=word133}
N 90 7980 90 8030 {
lab=GND}
N 90 8030 90 8040 {
lab=GND}
N 150 7980 150 8030 {
lab=Y1}
N 150 8030 150 8040 {
lab=Y1}
N 160 7990 200 7990 {
lab=word133}
N 200 7990 240 7990 {
lab=word133}
N 170 7980 170 8030 {
lab=GND}
N 170 8030 170 8040 {
lab=GND}
N 230 7980 230 8030 {
lab=Y2}
N 230 8030 230 8040 {
lab=Y2}

N 250 8040 280 8040 {
lab=GND}
N 280 8030 280 8040 {
lab=GND}
N 240 7990 280 7990 {
lab=word133}
N 280 7990 320 7990 {
lab=word133}
N 250 7980 250 8030 {
lab=GND}
N 250 8030 250 8040 {
lab=GND}
N 310 7980 310 8030 {
lab=Y3}
N 310 8030 310 8040 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 8010 1 0 {name=M533
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 7990 360 7990 {
lab=word133}
N 360 7990 400 7990 {
lab=word133}
N 330 7980 330 8030 {
lab=GND}
N 330 8030 330 8040 {
lab=GND}
N 390 7980 390 8030 {
lab=Y4}
N 390 8030 390 8040 {
lab=Y4}
N 400 7990 440 7990 {
lab=word133}
N 440 7990 480 7990 {
lab=word133}
N 410 7980 410 8030 {
lab=GND}
N 410 8030 410 8040 {
lab=GND}
N 470 7980 470 8030 {
lab=Y5}
N 470 8030 470 8040 {
lab=Y5}

N 490 8040 520 8040 {
lab=GND}
N 520 8030 520 8040 {
lab=GND}
N 480 7990 520 7990 {
lab=word133}
N 520 7990 560 7990 {
lab=word133}
N 490 7980 490 8030 {
lab=GND}
N 490 8030 490 8040 {
lab=GND}
N 550 7980 550 8030 {
lab=Y6}
N 550 8030 550 8040 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8010 1 0 {name=M534
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8040 600 8040 {
lab=GND}
N 600 8030 600 8040 {
lab=GND}
N 560 7990 600 7990 {
lab=word133}
N 600 7990 640 7990 {
lab=word133}
N 570 7980 570 8030 {
lab=GND}
N 570 8030 570 8040 {
lab=GND}
N 630 7980 630 8030 {
lab=Y7}
N 630 8030 630 8040 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8010 1 0 {name=M535
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8050 0 0 {name=p157 lab=word134}
N 0 8050 40 8050 {
lab=word134}
N 40 8050 80 8050 {
lab=word134}
N 10 8040 10 8090 {
lab=GND}
N 10 8090 10 8100 {
lab=GND}
N 70 8040 70 8090 {
lab=Y0}
N 70 8090 70 8100 {
lab=Y0}
N 80 8050 120 8050 {
lab=word134}
N 120 8050 160 8050 {
lab=word134}
N 90 8040 90 8090 {
lab=GND}
N 90 8090 90 8100 {
lab=GND}
N 150 8040 150 8090 {
lab=Y1}
N 150 8090 150 8100 {
lab=Y1}
N 160 8050 200 8050 {
lab=word134}
N 200 8050 240 8050 {
lab=word134}
N 170 8040 170 8090 {
lab=GND}
N 170 8090 170 8100 {
lab=GND}
N 230 8040 230 8090 {
lab=Y2}
N 230 8090 230 8100 {
lab=Y2}

N 250 8100 280 8100 {
lab=GND}
N 280 8090 280 8100 {
lab=GND}
N 240 8050 280 8050 {
lab=word134}
N 280 8050 320 8050 {
lab=word134}
N 250 8040 250 8090 {
lab=GND}
N 250 8090 250 8100 {
lab=GND}
N 310 8040 310 8090 {
lab=Y3}
N 310 8090 310 8100 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 8070 1 0 {name=M536
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 8050 360 8050 {
lab=word134}
N 360 8050 400 8050 {
lab=word134}
N 330 8040 330 8090 {
lab=GND}
N 330 8090 330 8100 {
lab=GND}
N 390 8040 390 8090 {
lab=Y4}
N 390 8090 390 8100 {
lab=Y4}

N 410 8100 440 8100 {
lab=GND}
N 440 8090 440 8100 {
lab=GND}
N 400 8050 440 8050 {
lab=word134}
N 440 8050 480 8050 {
lab=word134}
N 410 8040 410 8090 {
lab=GND}
N 410 8090 410 8100 {
lab=GND}
N 470 8040 470 8090 {
lab=Y5}
N 470 8090 470 8100 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 8070 1 0 {name=M537
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 8100 520 8100 {
lab=GND}
N 520 8090 520 8100 {
lab=GND}
N 480 8050 520 8050 {
lab=word134}
N 520 8050 560 8050 {
lab=word134}
N 490 8040 490 8090 {
lab=GND}
N 490 8090 490 8100 {
lab=GND}
N 550 8040 550 8090 {
lab=Y6}
N 550 8090 550 8100 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8070 1 0 {name=M538
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8100 600 8100 {
lab=GND}
N 600 8090 600 8100 {
lab=GND}
N 560 8050 600 8050 {
lab=word134}
N 600 8050 640 8050 {
lab=word134}
N 570 8040 570 8090 {
lab=GND}
N 570 8090 570 8100 {
lab=GND}
N 630 8040 630 8090 {
lab=Y7}
N 630 8090 630 8100 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8070 1 0 {name=M539
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8110 0 0 {name=p158 lab=word135}
N 0 8110 40 8110 {
lab=word135}
N 40 8110 80 8110 {
lab=word135}
N 10 8100 10 8150 {
lab=GND}
N 10 8150 10 8160 {
lab=GND}
N 70 8100 70 8150 {
lab=Y0}
N 70 8150 70 8160 {
lab=Y0}
N 80 8110 120 8110 {
lab=word135}
N 120 8110 160 8110 {
lab=word135}
N 90 8100 90 8150 {
lab=GND}
N 90 8150 90 8160 {
lab=GND}
N 150 8100 150 8150 {
lab=Y1}
N 150 8150 150 8160 {
lab=Y1}
N 160 8110 200 8110 {
lab=word135}
N 200 8110 240 8110 {
lab=word135}
N 170 8100 170 8150 {
lab=GND}
N 170 8150 170 8160 {
lab=GND}
N 230 8100 230 8150 {
lab=Y2}
N 230 8150 230 8160 {
lab=Y2}

N 250 8160 280 8160 {
lab=GND}
N 280 8150 280 8160 {
lab=GND}
N 240 8110 280 8110 {
lab=word135}
N 280 8110 320 8110 {
lab=word135}
N 250 8100 250 8150 {
lab=GND}
N 250 8150 250 8160 {
lab=GND}
N 310 8100 310 8150 {
lab=Y3}
N 310 8150 310 8160 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 8130 1 0 {name=M540
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 8160 360 8160 {
lab=GND}
N 360 8150 360 8160 {
lab=GND}
N 320 8110 360 8110 {
lab=word135}
N 360 8110 400 8110 {
lab=word135}
N 330 8100 330 8150 {
lab=GND}
N 330 8150 330 8160 {
lab=GND}
N 390 8100 390 8150 {
lab=Y4}
N 390 8150 390 8160 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 8130 1 0 {name=M541
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 8110 440 8110 {
lab=word135}
N 440 8110 480 8110 {
lab=word135}
N 410 8100 410 8150 {
lab=GND}
N 410 8150 410 8160 {
lab=GND}
N 470 8100 470 8150 {
lab=Y5}
N 470 8150 470 8160 {
lab=Y5}

N 490 8160 520 8160 {
lab=GND}
N 520 8150 520 8160 {
lab=GND}
N 480 8110 520 8110 {
lab=word135}
N 520 8110 560 8110 {
lab=word135}
N 490 8100 490 8150 {
lab=GND}
N 490 8150 490 8160 {
lab=GND}
N 550 8100 550 8150 {
lab=Y6}
N 550 8150 550 8160 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8130 1 0 {name=M542
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8160 600 8160 {
lab=GND}
N 600 8150 600 8160 {
lab=GND}
N 560 8110 600 8110 {
lab=word135}
N 600 8110 640 8110 {
lab=word135}
N 570 8100 570 8150 {
lab=GND}
N 570 8150 570 8160 {
lab=GND}
N 630 8100 630 8150 {
lab=Y7}
N 630 8150 630 8160 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8130 1 0 {name=M543
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8170 0 0 {name=p159 lab=word136}
N 0 8170 40 8170 {
lab=word136}
N 40 8170 80 8170 {
lab=word136}
N 10 8160 10 8210 {
lab=GND}
N 10 8210 10 8220 {
lab=GND}
N 70 8160 70 8210 {
lab=Y0}
N 70 8210 70 8220 {
lab=Y0}
N 80 8170 120 8170 {
lab=word136}
N 120 8170 160 8170 {
lab=word136}
N 90 8160 90 8210 {
lab=GND}
N 90 8210 90 8220 {
lab=GND}
N 150 8160 150 8210 {
lab=Y1}
N 150 8210 150 8220 {
lab=Y1}
N 160 8170 200 8170 {
lab=word136}
N 200 8170 240 8170 {
lab=word136}
N 170 8160 170 8210 {
lab=GND}
N 170 8210 170 8220 {
lab=GND}
N 230 8160 230 8210 {
lab=Y2}
N 230 8210 230 8220 {
lab=Y2}

N 250 8220 280 8220 {
lab=GND}
N 280 8210 280 8220 {
lab=GND}
N 240 8170 280 8170 {
lab=word136}
N 280 8170 320 8170 {
lab=word136}
N 250 8160 250 8210 {
lab=GND}
N 250 8210 250 8220 {
lab=GND}
N 310 8160 310 8210 {
lab=Y3}
N 310 8210 310 8220 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 8190 1 0 {name=M544
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 8220 360 8220 {
lab=GND}
N 360 8210 360 8220 {
lab=GND}
N 320 8170 360 8170 {
lab=word136}
N 360 8170 400 8170 {
lab=word136}
N 330 8160 330 8210 {
lab=GND}
N 330 8210 330 8220 {
lab=GND}
N 390 8160 390 8210 {
lab=Y4}
N 390 8210 390 8220 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 8190 1 0 {name=M545
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 8220 440 8220 {
lab=GND}
N 440 8210 440 8220 {
lab=GND}
N 400 8170 440 8170 {
lab=word136}
N 440 8170 480 8170 {
lab=word136}
N 410 8160 410 8210 {
lab=GND}
N 410 8210 410 8220 {
lab=GND}
N 470 8160 470 8210 {
lab=Y5}
N 470 8210 470 8220 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 8190 1 0 {name=M546
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 8220 520 8220 {
lab=GND}
N 520 8210 520 8220 {
lab=GND}
N 480 8170 520 8170 {
lab=word136}
N 520 8170 560 8170 {
lab=word136}
N 490 8160 490 8210 {
lab=GND}
N 490 8210 490 8220 {
lab=GND}
N 550 8160 550 8210 {
lab=Y6}
N 550 8210 550 8220 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8190 1 0 {name=M547
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8220 600 8220 {
lab=GND}
N 600 8210 600 8220 {
lab=GND}
N 560 8170 600 8170 {
lab=word136}
N 600 8170 640 8170 {
lab=word136}
N 570 8160 570 8210 {
lab=GND}
N 570 8210 570 8220 {
lab=GND}
N 630 8160 630 8210 {
lab=Y7}
N 630 8210 630 8220 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8190 1 0 {name=M548
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8230 0 0 {name=p160 lab=word137}
N 0 8230 40 8230 {
lab=word137}
N 40 8230 80 8230 {
lab=word137}
N 10 8220 10 8270 {
lab=GND}
N 10 8270 10 8280 {
lab=GND}
N 70 8220 70 8270 {
lab=Y0}
N 70 8270 70 8280 {
lab=Y0}
N 80 8230 120 8230 {
lab=word137}
N 120 8230 160 8230 {
lab=word137}
N 90 8220 90 8270 {
lab=GND}
N 90 8270 90 8280 {
lab=GND}
N 150 8220 150 8270 {
lab=Y1}
N 150 8270 150 8280 {
lab=Y1}

N 170 8280 200 8280 {
lab=GND}
N 200 8270 200 8280 {
lab=GND}
N 160 8230 200 8230 {
lab=word137}
N 200 8230 240 8230 {
lab=word137}
N 170 8220 170 8270 {
lab=GND}
N 170 8270 170 8280 {
lab=GND}
N 230 8220 230 8270 {
lab=Y2}
N 230 8270 230 8280 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 8250 1 0 {name=M549
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 8230 280 8230 {
lab=word137}
N 280 8230 320 8230 {
lab=word137}
N 250 8220 250 8270 {
lab=GND}
N 250 8270 250 8280 {
lab=GND}
N 310 8220 310 8270 {
lab=Y3}
N 310 8270 310 8280 {
lab=Y3}
N 320 8230 360 8230 {
lab=word137}
N 360 8230 400 8230 {
lab=word137}
N 330 8220 330 8270 {
lab=GND}
N 330 8270 330 8280 {
lab=GND}
N 390 8220 390 8270 {
lab=Y4}
N 390 8270 390 8280 {
lab=Y4}
N 400 8230 440 8230 {
lab=word137}
N 440 8230 480 8230 {
lab=word137}
N 410 8220 410 8270 {
lab=GND}
N 410 8270 410 8280 {
lab=GND}
N 470 8220 470 8270 {
lab=Y5}
N 470 8270 470 8280 {
lab=Y5}

N 490 8280 520 8280 {
lab=GND}
N 520 8270 520 8280 {
lab=GND}
N 480 8230 520 8230 {
lab=word137}
N 520 8230 560 8230 {
lab=word137}
N 490 8220 490 8270 {
lab=GND}
N 490 8270 490 8280 {
lab=GND}
N 550 8220 550 8270 {
lab=Y6}
N 550 8270 550 8280 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8250 1 0 {name=M550
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8280 600 8280 {
lab=GND}
N 600 8270 600 8280 {
lab=GND}
N 560 8230 600 8230 {
lab=word137}
N 600 8230 640 8230 {
lab=word137}
N 570 8220 570 8270 {
lab=GND}
N 570 8270 570 8280 {
lab=GND}
N 630 8220 630 8270 {
lab=Y7}
N 630 8270 630 8280 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8250 1 0 {name=M551
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8290 0 0 {name=p161 lab=word138}
N 0 8290 40 8290 {
lab=word138}
N 40 8290 80 8290 {
lab=word138}
N 10 8280 10 8330 {
lab=GND}
N 10 8330 10 8340 {
lab=GND}
N 70 8280 70 8330 {
lab=Y0}
N 70 8330 70 8340 {
lab=Y0}
N 80 8290 120 8290 {
lab=word138}
N 120 8290 160 8290 {
lab=word138}
N 90 8280 90 8330 {
lab=GND}
N 90 8330 90 8340 {
lab=GND}
N 150 8280 150 8330 {
lab=Y1}
N 150 8330 150 8340 {
lab=Y1}

N 170 8340 200 8340 {
lab=GND}
N 200 8330 200 8340 {
lab=GND}
N 160 8290 200 8290 {
lab=word138}
N 200 8290 240 8290 {
lab=word138}
N 170 8280 170 8330 {
lab=GND}
N 170 8330 170 8340 {
lab=GND}
N 230 8280 230 8330 {
lab=Y2}
N 230 8330 230 8340 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 8310 1 0 {name=M552
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 8290 280 8290 {
lab=word138}
N 280 8290 320 8290 {
lab=word138}
N 250 8280 250 8330 {
lab=GND}
N 250 8330 250 8340 {
lab=GND}
N 310 8280 310 8330 {
lab=Y3}
N 310 8330 310 8340 {
lab=Y3}
N 320 8290 360 8290 {
lab=word138}
N 360 8290 400 8290 {
lab=word138}
N 330 8280 330 8330 {
lab=GND}
N 330 8330 330 8340 {
lab=GND}
N 390 8280 390 8330 {
lab=Y4}
N 390 8330 390 8340 {
lab=Y4}

N 410 8340 440 8340 {
lab=GND}
N 440 8330 440 8340 {
lab=GND}
N 400 8290 440 8290 {
lab=word138}
N 440 8290 480 8290 {
lab=word138}
N 410 8280 410 8330 {
lab=GND}
N 410 8330 410 8340 {
lab=GND}
N 470 8280 470 8330 {
lab=Y5}
N 470 8330 470 8340 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 8310 1 0 {name=M553
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 8340 520 8340 {
lab=GND}
N 520 8330 520 8340 {
lab=GND}
N 480 8290 520 8290 {
lab=word138}
N 520 8290 560 8290 {
lab=word138}
N 490 8280 490 8330 {
lab=GND}
N 490 8330 490 8340 {
lab=GND}
N 550 8280 550 8330 {
lab=Y6}
N 550 8330 550 8340 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8310 1 0 {name=M554
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8340 600 8340 {
lab=GND}
N 600 8330 600 8340 {
lab=GND}
N 560 8290 600 8290 {
lab=word138}
N 600 8290 640 8290 {
lab=word138}
N 570 8280 570 8330 {
lab=GND}
N 570 8330 570 8340 {
lab=GND}
N 630 8280 630 8330 {
lab=Y7}
N 630 8330 630 8340 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8310 1 0 {name=M555
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8350 0 0 {name=p162 lab=word139}
N 0 8350 40 8350 {
lab=word139}
N 40 8350 80 8350 {
lab=word139}
N 10 8340 10 8390 {
lab=GND}
N 10 8390 10 8400 {
lab=GND}
N 70 8340 70 8390 {
lab=Y0}
N 70 8390 70 8400 {
lab=Y0}
N 80 8350 120 8350 {
lab=word139}
N 120 8350 160 8350 {
lab=word139}
N 90 8340 90 8390 {
lab=GND}
N 90 8390 90 8400 {
lab=GND}
N 150 8340 150 8390 {
lab=Y1}
N 150 8390 150 8400 {
lab=Y1}

N 170 8400 200 8400 {
lab=GND}
N 200 8390 200 8400 {
lab=GND}
N 160 8350 200 8350 {
lab=word139}
N 200 8350 240 8350 {
lab=word139}
N 170 8340 170 8390 {
lab=GND}
N 170 8390 170 8400 {
lab=GND}
N 230 8340 230 8390 {
lab=Y2}
N 230 8390 230 8400 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 8370 1 0 {name=M556
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 8350 280 8350 {
lab=word139}
N 280 8350 320 8350 {
lab=word139}
N 250 8340 250 8390 {
lab=GND}
N 250 8390 250 8400 {
lab=GND}
N 310 8340 310 8390 {
lab=Y3}
N 310 8390 310 8400 {
lab=Y3}

N 330 8400 360 8400 {
lab=GND}
N 360 8390 360 8400 {
lab=GND}
N 320 8350 360 8350 {
lab=word139}
N 360 8350 400 8350 {
lab=word139}
N 330 8340 330 8390 {
lab=GND}
N 330 8390 330 8400 {
lab=GND}
N 390 8340 390 8390 {
lab=Y4}
N 390 8390 390 8400 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 8370 1 0 {name=M557
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 8350 440 8350 {
lab=word139}
N 440 8350 480 8350 {
lab=word139}
N 410 8340 410 8390 {
lab=GND}
N 410 8390 410 8400 {
lab=GND}
N 470 8340 470 8390 {
lab=Y5}
N 470 8390 470 8400 {
lab=Y5}

N 490 8400 520 8400 {
lab=GND}
N 520 8390 520 8400 {
lab=GND}
N 480 8350 520 8350 {
lab=word139}
N 520 8350 560 8350 {
lab=word139}
N 490 8340 490 8390 {
lab=GND}
N 490 8390 490 8400 {
lab=GND}
N 550 8340 550 8390 {
lab=Y6}
N 550 8390 550 8400 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8370 1 0 {name=M558
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8400 600 8400 {
lab=GND}
N 600 8390 600 8400 {
lab=GND}
N 560 8350 600 8350 {
lab=word139}
N 600 8350 640 8350 {
lab=word139}
N 570 8340 570 8390 {
lab=GND}
N 570 8390 570 8400 {
lab=GND}
N 630 8340 630 8390 {
lab=Y7}
N 630 8390 630 8400 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8370 1 0 {name=M559
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8410 0 0 {name=p163 lab=word140}
N 0 8410 40 8410 {
lab=word140}
N 40 8410 80 8410 {
lab=word140}
N 10 8400 10 8450 {
lab=GND}
N 10 8450 10 8460 {
lab=GND}
N 70 8400 70 8450 {
lab=Y0}
N 70 8450 70 8460 {
lab=Y0}
N 80 8410 120 8410 {
lab=word140}
N 120 8410 160 8410 {
lab=word140}
N 90 8400 90 8450 {
lab=GND}
N 90 8450 90 8460 {
lab=GND}
N 150 8400 150 8450 {
lab=Y1}
N 150 8450 150 8460 {
lab=Y1}

N 170 8460 200 8460 {
lab=GND}
N 200 8450 200 8460 {
lab=GND}
N 160 8410 200 8410 {
lab=word140}
N 200 8410 240 8410 {
lab=word140}
N 170 8400 170 8450 {
lab=GND}
N 170 8450 170 8460 {
lab=GND}
N 230 8400 230 8450 {
lab=Y2}
N 230 8450 230 8460 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 8430 1 0 {name=M560
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 8410 280 8410 {
lab=word140}
N 280 8410 320 8410 {
lab=word140}
N 250 8400 250 8450 {
lab=GND}
N 250 8450 250 8460 {
lab=GND}
N 310 8400 310 8450 {
lab=Y3}
N 310 8450 310 8460 {
lab=Y3}

N 330 8460 360 8460 {
lab=GND}
N 360 8450 360 8460 {
lab=GND}
N 320 8410 360 8410 {
lab=word140}
N 360 8410 400 8410 {
lab=word140}
N 330 8400 330 8450 {
lab=GND}
N 330 8450 330 8460 {
lab=GND}
N 390 8400 390 8450 {
lab=Y4}
N 390 8450 390 8460 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 8430 1 0 {name=M561
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 8460 440 8460 {
lab=GND}
N 440 8450 440 8460 {
lab=GND}
N 400 8410 440 8410 {
lab=word140}
N 440 8410 480 8410 {
lab=word140}
N 410 8400 410 8450 {
lab=GND}
N 410 8450 410 8460 {
lab=GND}
N 470 8400 470 8450 {
lab=Y5}
N 470 8450 470 8460 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 8430 1 0 {name=M562
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 8460 520 8460 {
lab=GND}
N 520 8450 520 8460 {
lab=GND}
N 480 8410 520 8410 {
lab=word140}
N 520 8410 560 8410 {
lab=word140}
N 490 8400 490 8450 {
lab=GND}
N 490 8450 490 8460 {
lab=GND}
N 550 8400 550 8450 {
lab=Y6}
N 550 8450 550 8460 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8430 1 0 {name=M563
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8460 600 8460 {
lab=GND}
N 600 8450 600 8460 {
lab=GND}
N 560 8410 600 8410 {
lab=word140}
N 600 8410 640 8410 {
lab=word140}
N 570 8400 570 8450 {
lab=GND}
N 570 8450 570 8460 {
lab=GND}
N 630 8400 630 8450 {
lab=Y7}
N 630 8450 630 8460 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8430 1 0 {name=M564
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8470 0 0 {name=p164 lab=word141}
N 0 8470 40 8470 {
lab=word141}
N 40 8470 80 8470 {
lab=word141}
N 10 8460 10 8510 {
lab=GND}
N 10 8510 10 8520 {
lab=GND}
N 70 8460 70 8510 {
lab=Y0}
N 70 8510 70 8520 {
lab=Y0}
N 80 8470 120 8470 {
lab=word141}
N 120 8470 160 8470 {
lab=word141}
N 90 8460 90 8510 {
lab=GND}
N 90 8510 90 8520 {
lab=GND}
N 150 8460 150 8510 {
lab=Y1}
N 150 8510 150 8520 {
lab=Y1}

N 170 8520 200 8520 {
lab=GND}
N 200 8510 200 8520 {
lab=GND}
N 160 8470 200 8470 {
lab=word141}
N 200 8470 240 8470 {
lab=word141}
N 170 8460 170 8510 {
lab=GND}
N 170 8510 170 8520 {
lab=GND}
N 230 8460 230 8510 {
lab=Y2}
N 230 8510 230 8520 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 8490 1 0 {name=M565
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 8520 280 8520 {
lab=GND}
N 280 8510 280 8520 {
lab=GND}
N 240 8470 280 8470 {
lab=word141}
N 280 8470 320 8470 {
lab=word141}
N 250 8460 250 8510 {
lab=GND}
N 250 8510 250 8520 {
lab=GND}
N 310 8460 310 8510 {
lab=Y3}
N 310 8510 310 8520 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 8490 1 0 {name=M566
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 8470 360 8470 {
lab=word141}
N 360 8470 400 8470 {
lab=word141}
N 330 8460 330 8510 {
lab=GND}
N 330 8510 330 8520 {
lab=GND}
N 390 8460 390 8510 {
lab=Y4}
N 390 8510 390 8520 {
lab=Y4}
N 400 8470 440 8470 {
lab=word141}
N 440 8470 480 8470 {
lab=word141}
N 410 8460 410 8510 {
lab=GND}
N 410 8510 410 8520 {
lab=GND}
N 470 8460 470 8510 {
lab=Y5}
N 470 8510 470 8520 {
lab=Y5}

N 490 8520 520 8520 {
lab=GND}
N 520 8510 520 8520 {
lab=GND}
N 480 8470 520 8470 {
lab=word141}
N 520 8470 560 8470 {
lab=word141}
N 490 8460 490 8510 {
lab=GND}
N 490 8510 490 8520 {
lab=GND}
N 550 8460 550 8510 {
lab=Y6}
N 550 8510 550 8520 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8490 1 0 {name=M567
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8520 600 8520 {
lab=GND}
N 600 8510 600 8520 {
lab=GND}
N 560 8470 600 8470 {
lab=word141}
N 600 8470 640 8470 {
lab=word141}
N 570 8460 570 8510 {
lab=GND}
N 570 8510 570 8520 {
lab=GND}
N 630 8460 630 8510 {
lab=Y7}
N 630 8510 630 8520 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8490 1 0 {name=M568
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8530 0 0 {name=p165 lab=word142}
N 0 8530 40 8530 {
lab=word142}
N 40 8530 80 8530 {
lab=word142}
N 10 8520 10 8570 {
lab=GND}
N 10 8570 10 8580 {
lab=GND}
N 70 8520 70 8570 {
lab=Y0}
N 70 8570 70 8580 {
lab=Y0}
N 80 8530 120 8530 {
lab=word142}
N 120 8530 160 8530 {
lab=word142}
N 90 8520 90 8570 {
lab=GND}
N 90 8570 90 8580 {
lab=GND}
N 150 8520 150 8570 {
lab=Y1}
N 150 8570 150 8580 {
lab=Y1}

N 170 8580 200 8580 {
lab=GND}
N 200 8570 200 8580 {
lab=GND}
N 160 8530 200 8530 {
lab=word142}
N 200 8530 240 8530 {
lab=word142}
N 170 8520 170 8570 {
lab=GND}
N 170 8570 170 8580 {
lab=GND}
N 230 8520 230 8570 {
lab=Y2}
N 230 8570 230 8580 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 8550 1 0 {name=M569
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 8580 280 8580 {
lab=GND}
N 280 8570 280 8580 {
lab=GND}
N 240 8530 280 8530 {
lab=word142}
N 280 8530 320 8530 {
lab=word142}
N 250 8520 250 8570 {
lab=GND}
N 250 8570 250 8580 {
lab=GND}
N 310 8520 310 8570 {
lab=Y3}
N 310 8570 310 8580 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 8550 1 0 {name=M570
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 8530 360 8530 {
lab=word142}
N 360 8530 400 8530 {
lab=word142}
N 330 8520 330 8570 {
lab=GND}
N 330 8570 330 8580 {
lab=GND}
N 390 8520 390 8570 {
lab=Y4}
N 390 8570 390 8580 {
lab=Y4}

N 410 8580 440 8580 {
lab=GND}
N 440 8570 440 8580 {
lab=GND}
N 400 8530 440 8530 {
lab=word142}
N 440 8530 480 8530 {
lab=word142}
N 410 8520 410 8570 {
lab=GND}
N 410 8570 410 8580 {
lab=GND}
N 470 8520 470 8570 {
lab=Y5}
N 470 8570 470 8580 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 8550 1 0 {name=M571
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 8580 520 8580 {
lab=GND}
N 520 8570 520 8580 {
lab=GND}
N 480 8530 520 8530 {
lab=word142}
N 520 8530 560 8530 {
lab=word142}
N 490 8520 490 8570 {
lab=GND}
N 490 8570 490 8580 {
lab=GND}
N 550 8520 550 8570 {
lab=Y6}
N 550 8570 550 8580 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8550 1 0 {name=M572
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8580 600 8580 {
lab=GND}
N 600 8570 600 8580 {
lab=GND}
N 560 8530 600 8530 {
lab=word142}
N 600 8530 640 8530 {
lab=word142}
N 570 8520 570 8570 {
lab=GND}
N 570 8570 570 8580 {
lab=GND}
N 630 8520 630 8570 {
lab=Y7}
N 630 8570 630 8580 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8550 1 0 {name=M573
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8590 0 0 {name=p166 lab=word143}
N 0 8590 40 8590 {
lab=word143}
N 40 8590 80 8590 {
lab=word143}
N 10 8580 10 8630 {
lab=GND}
N 10 8630 10 8640 {
lab=GND}
N 70 8580 70 8630 {
lab=Y0}
N 70 8630 70 8640 {
lab=Y0}
N 80 8590 120 8590 {
lab=word143}
N 120 8590 160 8590 {
lab=word143}
N 90 8580 90 8630 {
lab=GND}
N 90 8630 90 8640 {
lab=GND}
N 150 8580 150 8630 {
lab=Y1}
N 150 8630 150 8640 {
lab=Y1}

N 170 8640 200 8640 {
lab=GND}
N 200 8630 200 8640 {
lab=GND}
N 160 8590 200 8590 {
lab=word143}
N 200 8590 240 8590 {
lab=word143}
N 170 8580 170 8630 {
lab=GND}
N 170 8630 170 8640 {
lab=GND}
N 230 8580 230 8630 {
lab=Y2}
N 230 8630 230 8640 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 8610 1 0 {name=M574
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 8640 280 8640 {
lab=GND}
N 280 8630 280 8640 {
lab=GND}
N 240 8590 280 8590 {
lab=word143}
N 280 8590 320 8590 {
lab=word143}
N 250 8580 250 8630 {
lab=GND}
N 250 8630 250 8640 {
lab=GND}
N 310 8580 310 8630 {
lab=Y3}
N 310 8630 310 8640 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 8610 1 0 {name=M575
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 8640 360 8640 {
lab=GND}
N 360 8630 360 8640 {
lab=GND}
N 320 8590 360 8590 {
lab=word143}
N 360 8590 400 8590 {
lab=word143}
N 330 8580 330 8630 {
lab=GND}
N 330 8630 330 8640 {
lab=GND}
N 390 8580 390 8630 {
lab=Y4}
N 390 8630 390 8640 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 8610 1 0 {name=M576
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 8590 440 8590 {
lab=word143}
N 440 8590 480 8590 {
lab=word143}
N 410 8580 410 8630 {
lab=GND}
N 410 8630 410 8640 {
lab=GND}
N 470 8580 470 8630 {
lab=Y5}
N 470 8630 470 8640 {
lab=Y5}

N 490 8640 520 8640 {
lab=GND}
N 520 8630 520 8640 {
lab=GND}
N 480 8590 520 8590 {
lab=word143}
N 520 8590 560 8590 {
lab=word143}
N 490 8580 490 8630 {
lab=GND}
N 490 8630 490 8640 {
lab=GND}
N 550 8580 550 8630 {
lab=Y6}
N 550 8630 550 8640 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8610 1 0 {name=M577
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8640 600 8640 {
lab=GND}
N 600 8630 600 8640 {
lab=GND}
N 560 8590 600 8590 {
lab=word143}
N 600 8590 640 8590 {
lab=word143}
N 570 8580 570 8630 {
lab=GND}
N 570 8630 570 8640 {
lab=GND}
N 630 8580 630 8630 {
lab=Y7}
N 630 8630 630 8640 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8610 1 0 {name=M578
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8650 0 0 {name=p167 lab=word144}
N 0 8650 40 8650 {
lab=word144}
N 40 8650 80 8650 {
lab=word144}
N 10 8640 10 8690 {
lab=GND}
N 10 8690 10 8700 {
lab=GND}
N 70 8640 70 8690 {
lab=Y0}
N 70 8690 70 8700 {
lab=Y0}
N 80 8650 120 8650 {
lab=word144}
N 120 8650 160 8650 {
lab=word144}
N 90 8640 90 8690 {
lab=GND}
N 90 8690 90 8700 {
lab=GND}
N 150 8640 150 8690 {
lab=Y1}
N 150 8690 150 8700 {
lab=Y1}

N 170 8700 200 8700 {
lab=GND}
N 200 8690 200 8700 {
lab=GND}
N 160 8650 200 8650 {
lab=word144}
N 200 8650 240 8650 {
lab=word144}
N 170 8640 170 8690 {
lab=GND}
N 170 8690 170 8700 {
lab=GND}
N 230 8640 230 8690 {
lab=Y2}
N 230 8690 230 8700 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 8670 1 0 {name=M579
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 8700 280 8700 {
lab=GND}
N 280 8690 280 8700 {
lab=GND}
N 240 8650 280 8650 {
lab=word144}
N 280 8650 320 8650 {
lab=word144}
N 250 8640 250 8690 {
lab=GND}
N 250 8690 250 8700 {
lab=GND}
N 310 8640 310 8690 {
lab=Y3}
N 310 8690 310 8700 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 8670 1 0 {name=M580
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 8700 360 8700 {
lab=GND}
N 360 8690 360 8700 {
lab=GND}
N 320 8650 360 8650 {
lab=word144}
N 360 8650 400 8650 {
lab=word144}
N 330 8640 330 8690 {
lab=GND}
N 330 8690 330 8700 {
lab=GND}
N 390 8640 390 8690 {
lab=Y4}
N 390 8690 390 8700 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 8670 1 0 {name=M581
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 8700 440 8700 {
lab=GND}
N 440 8690 440 8700 {
lab=GND}
N 400 8650 440 8650 {
lab=word144}
N 440 8650 480 8650 {
lab=word144}
N 410 8640 410 8690 {
lab=GND}
N 410 8690 410 8700 {
lab=GND}
N 470 8640 470 8690 {
lab=Y5}
N 470 8690 470 8700 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 8670 1 0 {name=M582
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 8700 520 8700 {
lab=GND}
N 520 8690 520 8700 {
lab=GND}
N 480 8650 520 8650 {
lab=word144}
N 520 8650 560 8650 {
lab=word144}
N 490 8640 490 8690 {
lab=GND}
N 490 8690 490 8700 {
lab=GND}
N 550 8640 550 8690 {
lab=Y6}
N 550 8690 550 8700 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8670 1 0 {name=M583
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8700 600 8700 {
lab=GND}
N 600 8690 600 8700 {
lab=GND}
N 560 8650 600 8650 {
lab=word144}
N 600 8650 640 8650 {
lab=word144}
N 570 8640 570 8690 {
lab=GND}
N 570 8690 570 8700 {
lab=GND}
N 630 8640 630 8690 {
lab=Y7}
N 630 8690 630 8700 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8670 1 0 {name=M584
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8710 0 0 {name=p168 lab=word145}
N 0 8710 40 8710 {
lab=word145}
N 40 8710 80 8710 {
lab=word145}
N 10 8700 10 8750 {
lab=GND}
N 10 8750 10 8760 {
lab=GND}
N 70 8700 70 8750 {
lab=Y0}
N 70 8750 70 8760 {
lab=Y0}

N 90 8760 120 8760 {
lab=GND}
N 120 8750 120 8760 {
lab=GND}
N 80 8710 120 8710 {
lab=word145}
N 120 8710 160 8710 {
lab=word145}
N 90 8700 90 8750 {
lab=GND}
N 90 8750 90 8760 {
lab=GND}
N 150 8700 150 8750 {
lab=Y1}
N 150 8750 150 8760 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 8730 1 0 {name=M585
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 8710 200 8710 {
lab=word145}
N 200 8710 240 8710 {
lab=word145}
N 170 8700 170 8750 {
lab=GND}
N 170 8750 170 8760 {
lab=GND}
N 230 8700 230 8750 {
lab=Y2}
N 230 8750 230 8760 {
lab=Y2}
N 240 8710 280 8710 {
lab=word145}
N 280 8710 320 8710 {
lab=word145}
N 250 8700 250 8750 {
lab=GND}
N 250 8750 250 8760 {
lab=GND}
N 310 8700 310 8750 {
lab=Y3}
N 310 8750 310 8760 {
lab=Y3}
N 320 8710 360 8710 {
lab=word145}
N 360 8710 400 8710 {
lab=word145}
N 330 8700 330 8750 {
lab=GND}
N 330 8750 330 8760 {
lab=GND}
N 390 8700 390 8750 {
lab=Y4}
N 390 8750 390 8760 {
lab=Y4}
N 400 8710 440 8710 {
lab=word145}
N 440 8710 480 8710 {
lab=word145}
N 410 8700 410 8750 {
lab=GND}
N 410 8750 410 8760 {
lab=GND}
N 470 8700 470 8750 {
lab=Y5}
N 470 8750 470 8760 {
lab=Y5}

N 490 8760 520 8760 {
lab=GND}
N 520 8750 520 8760 {
lab=GND}
N 480 8710 520 8710 {
lab=word145}
N 520 8710 560 8710 {
lab=word145}
N 490 8700 490 8750 {
lab=GND}
N 490 8750 490 8760 {
lab=GND}
N 550 8700 550 8750 {
lab=Y6}
N 550 8750 550 8760 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8730 1 0 {name=M586
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8760 600 8760 {
lab=GND}
N 600 8750 600 8760 {
lab=GND}
N 560 8710 600 8710 {
lab=word145}
N 600 8710 640 8710 {
lab=word145}
N 570 8700 570 8750 {
lab=GND}
N 570 8750 570 8760 {
lab=GND}
N 630 8700 630 8750 {
lab=Y7}
N 630 8750 630 8760 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8730 1 0 {name=M587
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8770 0 0 {name=p169 lab=word146}
N 0 8770 40 8770 {
lab=word146}
N 40 8770 80 8770 {
lab=word146}
N 10 8760 10 8810 {
lab=GND}
N 10 8810 10 8820 {
lab=GND}
N 70 8760 70 8810 {
lab=Y0}
N 70 8810 70 8820 {
lab=Y0}

N 90 8820 120 8820 {
lab=GND}
N 120 8810 120 8820 {
lab=GND}
N 80 8770 120 8770 {
lab=word146}
N 120 8770 160 8770 {
lab=word146}
N 90 8760 90 8810 {
lab=GND}
N 90 8810 90 8820 {
lab=GND}
N 150 8760 150 8810 {
lab=Y1}
N 150 8810 150 8820 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 8790 1 0 {name=M588
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 8770 200 8770 {
lab=word146}
N 200 8770 240 8770 {
lab=word146}
N 170 8760 170 8810 {
lab=GND}
N 170 8810 170 8820 {
lab=GND}
N 230 8760 230 8810 {
lab=Y2}
N 230 8810 230 8820 {
lab=Y2}
N 240 8770 280 8770 {
lab=word146}
N 280 8770 320 8770 {
lab=word146}
N 250 8760 250 8810 {
lab=GND}
N 250 8810 250 8820 {
lab=GND}
N 310 8760 310 8810 {
lab=Y3}
N 310 8810 310 8820 {
lab=Y3}
N 320 8770 360 8770 {
lab=word146}
N 360 8770 400 8770 {
lab=word146}
N 330 8760 330 8810 {
lab=GND}
N 330 8810 330 8820 {
lab=GND}
N 390 8760 390 8810 {
lab=Y4}
N 390 8810 390 8820 {
lab=Y4}

N 410 8820 440 8820 {
lab=GND}
N 440 8810 440 8820 {
lab=GND}
N 400 8770 440 8770 {
lab=word146}
N 440 8770 480 8770 {
lab=word146}
N 410 8760 410 8810 {
lab=GND}
N 410 8810 410 8820 {
lab=GND}
N 470 8760 470 8810 {
lab=Y5}
N 470 8810 470 8820 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 8790 1 0 {name=M589
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 8820 520 8820 {
lab=GND}
N 520 8810 520 8820 {
lab=GND}
N 480 8770 520 8770 {
lab=word146}
N 520 8770 560 8770 {
lab=word146}
N 490 8760 490 8810 {
lab=GND}
N 490 8810 490 8820 {
lab=GND}
N 550 8760 550 8810 {
lab=Y6}
N 550 8810 550 8820 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8790 1 0 {name=M590
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8820 600 8820 {
lab=GND}
N 600 8810 600 8820 {
lab=GND}
N 560 8770 600 8770 {
lab=word146}
N 600 8770 640 8770 {
lab=word146}
N 570 8760 570 8810 {
lab=GND}
N 570 8810 570 8820 {
lab=GND}
N 630 8760 630 8810 {
lab=Y7}
N 630 8810 630 8820 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8790 1 0 {name=M591
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8830 0 0 {name=p170 lab=word147}
N 0 8830 40 8830 {
lab=word147}
N 40 8830 80 8830 {
lab=word147}
N 10 8820 10 8870 {
lab=GND}
N 10 8870 10 8880 {
lab=GND}
N 70 8820 70 8870 {
lab=Y0}
N 70 8870 70 8880 {
lab=Y0}

N 90 8880 120 8880 {
lab=GND}
N 120 8870 120 8880 {
lab=GND}
N 80 8830 120 8830 {
lab=word147}
N 120 8830 160 8830 {
lab=word147}
N 90 8820 90 8870 {
lab=GND}
N 90 8870 90 8880 {
lab=GND}
N 150 8820 150 8870 {
lab=Y1}
N 150 8870 150 8880 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 8850 1 0 {name=M592
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 8830 200 8830 {
lab=word147}
N 200 8830 240 8830 {
lab=word147}
N 170 8820 170 8870 {
lab=GND}
N 170 8870 170 8880 {
lab=GND}
N 230 8820 230 8870 {
lab=Y2}
N 230 8870 230 8880 {
lab=Y2}
N 240 8830 280 8830 {
lab=word147}
N 280 8830 320 8830 {
lab=word147}
N 250 8820 250 8870 {
lab=GND}
N 250 8870 250 8880 {
lab=GND}
N 310 8820 310 8870 {
lab=Y3}
N 310 8870 310 8880 {
lab=Y3}

N 330 8880 360 8880 {
lab=GND}
N 360 8870 360 8880 {
lab=GND}
N 320 8830 360 8830 {
lab=word147}
N 360 8830 400 8830 {
lab=word147}
N 330 8820 330 8870 {
lab=GND}
N 330 8870 330 8880 {
lab=GND}
N 390 8820 390 8870 {
lab=Y4}
N 390 8870 390 8880 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 8850 1 0 {name=M593
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 8830 440 8830 {
lab=word147}
N 440 8830 480 8830 {
lab=word147}
N 410 8820 410 8870 {
lab=GND}
N 410 8870 410 8880 {
lab=GND}
N 470 8820 470 8870 {
lab=Y5}
N 470 8870 470 8880 {
lab=Y5}

N 490 8880 520 8880 {
lab=GND}
N 520 8870 520 8880 {
lab=GND}
N 480 8830 520 8830 {
lab=word147}
N 520 8830 560 8830 {
lab=word147}
N 490 8820 490 8870 {
lab=GND}
N 490 8870 490 8880 {
lab=GND}
N 550 8820 550 8870 {
lab=Y6}
N 550 8870 550 8880 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8850 1 0 {name=M594
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8880 600 8880 {
lab=GND}
N 600 8870 600 8880 {
lab=GND}
N 560 8830 600 8830 {
lab=word147}
N 600 8830 640 8830 {
lab=word147}
N 570 8820 570 8870 {
lab=GND}
N 570 8870 570 8880 {
lab=GND}
N 630 8820 630 8870 {
lab=Y7}
N 630 8870 630 8880 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8850 1 0 {name=M595
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8890 0 0 {name=p171 lab=word148}
N 0 8890 40 8890 {
lab=word148}
N 40 8890 80 8890 {
lab=word148}
N 10 8880 10 8930 {
lab=GND}
N 10 8930 10 8940 {
lab=GND}
N 70 8880 70 8930 {
lab=Y0}
N 70 8930 70 8940 {
lab=Y0}

N 90 8940 120 8940 {
lab=GND}
N 120 8930 120 8940 {
lab=GND}
N 80 8890 120 8890 {
lab=word148}
N 120 8890 160 8890 {
lab=word148}
N 90 8880 90 8930 {
lab=GND}
N 90 8930 90 8940 {
lab=GND}
N 150 8880 150 8930 {
lab=Y1}
N 150 8930 150 8940 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 8910 1 0 {name=M596
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 8890 200 8890 {
lab=word148}
N 200 8890 240 8890 {
lab=word148}
N 170 8880 170 8930 {
lab=GND}
N 170 8930 170 8940 {
lab=GND}
N 230 8880 230 8930 {
lab=Y2}
N 230 8930 230 8940 {
lab=Y2}
N 240 8890 280 8890 {
lab=word148}
N 280 8890 320 8890 {
lab=word148}
N 250 8880 250 8930 {
lab=GND}
N 250 8930 250 8940 {
lab=GND}
N 310 8880 310 8930 {
lab=Y3}
N 310 8930 310 8940 {
lab=Y3}

N 330 8940 360 8940 {
lab=GND}
N 360 8930 360 8940 {
lab=GND}
N 320 8890 360 8890 {
lab=word148}
N 360 8890 400 8890 {
lab=word148}
N 330 8880 330 8930 {
lab=GND}
N 330 8930 330 8940 {
lab=GND}
N 390 8880 390 8930 {
lab=Y4}
N 390 8930 390 8940 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 8910 1 0 {name=M597
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 8940 440 8940 {
lab=GND}
N 440 8930 440 8940 {
lab=GND}
N 400 8890 440 8890 {
lab=word148}
N 440 8890 480 8890 {
lab=word148}
N 410 8880 410 8930 {
lab=GND}
N 410 8930 410 8940 {
lab=GND}
N 470 8880 470 8930 {
lab=Y5}
N 470 8930 470 8940 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 8910 1 0 {name=M598
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 8940 520 8940 {
lab=GND}
N 520 8930 520 8940 {
lab=GND}
N 480 8890 520 8890 {
lab=word148}
N 520 8890 560 8890 {
lab=word148}
N 490 8880 490 8930 {
lab=GND}
N 490 8930 490 8940 {
lab=GND}
N 550 8880 550 8930 {
lab=Y6}
N 550 8930 550 8940 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8910 1 0 {name=M599
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 8940 600 8940 {
lab=GND}
N 600 8930 600 8940 {
lab=GND}
N 560 8890 600 8890 {
lab=word148}
N 600 8890 640 8890 {
lab=word148}
N 570 8880 570 8930 {
lab=GND}
N 570 8930 570 8940 {
lab=GND}
N 630 8880 630 8930 {
lab=Y7}
N 630 8930 630 8940 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8910 1 0 {name=M600
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 8950 0 0 {name=p172 lab=word149}
N 0 8950 40 8950 {
lab=word149}
N 40 8950 80 8950 {
lab=word149}
N 10 8940 10 8990 {
lab=GND}
N 10 8990 10 9000 {
lab=GND}
N 70 8940 70 8990 {
lab=Y0}
N 70 8990 70 9000 {
lab=Y0}

N 90 9000 120 9000 {
lab=GND}
N 120 8990 120 9000 {
lab=GND}
N 80 8950 120 8950 {
lab=word149}
N 120 8950 160 8950 {
lab=word149}
N 90 8940 90 8990 {
lab=GND}
N 90 8990 90 9000 {
lab=GND}
N 150 8940 150 8990 {
lab=Y1}
N 150 8990 150 9000 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 8970 1 0 {name=M601
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 8950 200 8950 {
lab=word149}
N 200 8950 240 8950 {
lab=word149}
N 170 8940 170 8990 {
lab=GND}
N 170 8990 170 9000 {
lab=GND}
N 230 8940 230 8990 {
lab=Y2}
N 230 8990 230 9000 {
lab=Y2}

N 250 9000 280 9000 {
lab=GND}
N 280 8990 280 9000 {
lab=GND}
N 240 8950 280 8950 {
lab=word149}
N 280 8950 320 8950 {
lab=word149}
N 250 8940 250 8990 {
lab=GND}
N 250 8990 250 9000 {
lab=GND}
N 310 8940 310 8990 {
lab=Y3}
N 310 8990 310 9000 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 8970 1 0 {name=M602
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 8950 360 8950 {
lab=word149}
N 360 8950 400 8950 {
lab=word149}
N 330 8940 330 8990 {
lab=GND}
N 330 8990 330 9000 {
lab=GND}
N 390 8940 390 8990 {
lab=Y4}
N 390 8990 390 9000 {
lab=Y4}
N 400 8950 440 8950 {
lab=word149}
N 440 8950 480 8950 {
lab=word149}
N 410 8940 410 8990 {
lab=GND}
N 410 8990 410 9000 {
lab=GND}
N 470 8940 470 8990 {
lab=Y5}
N 470 8990 470 9000 {
lab=Y5}

N 490 9000 520 9000 {
lab=GND}
N 520 8990 520 9000 {
lab=GND}
N 480 8950 520 8950 {
lab=word149}
N 520 8950 560 8950 {
lab=word149}
N 490 8940 490 8990 {
lab=GND}
N 490 8990 490 9000 {
lab=GND}
N 550 8940 550 8990 {
lab=Y6}
N 550 8990 550 9000 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 8970 1 0 {name=M603
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9000 600 9000 {
lab=GND}
N 600 8990 600 9000 {
lab=GND}
N 560 8950 600 8950 {
lab=word149}
N 600 8950 640 8950 {
lab=word149}
N 570 8940 570 8990 {
lab=GND}
N 570 8990 570 9000 {
lab=GND}
N 630 8940 630 8990 {
lab=Y7}
N 630 8990 630 9000 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 8970 1 0 {name=M604
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9010 0 0 {name=p173 lab=word150}
N 0 9010 40 9010 {
lab=word150}
N 40 9010 80 9010 {
lab=word150}
N 10 9000 10 9050 {
lab=GND}
N 10 9050 10 9060 {
lab=GND}
N 70 9000 70 9050 {
lab=Y0}
N 70 9050 70 9060 {
lab=Y0}

N 90 9060 120 9060 {
lab=GND}
N 120 9050 120 9060 {
lab=GND}
N 80 9010 120 9010 {
lab=word150}
N 120 9010 160 9010 {
lab=word150}
N 90 9000 90 9050 {
lab=GND}
N 90 9050 90 9060 {
lab=GND}
N 150 9000 150 9050 {
lab=Y1}
N 150 9050 150 9060 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 9030 1 0 {name=M605
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 9010 200 9010 {
lab=word150}
N 200 9010 240 9010 {
lab=word150}
N 170 9000 170 9050 {
lab=GND}
N 170 9050 170 9060 {
lab=GND}
N 230 9000 230 9050 {
lab=Y2}
N 230 9050 230 9060 {
lab=Y2}

N 250 9060 280 9060 {
lab=GND}
N 280 9050 280 9060 {
lab=GND}
N 240 9010 280 9010 {
lab=word150}
N 280 9010 320 9010 {
lab=word150}
N 250 9000 250 9050 {
lab=GND}
N 250 9050 250 9060 {
lab=GND}
N 310 9000 310 9050 {
lab=Y3}
N 310 9050 310 9060 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 9030 1 0 {name=M606
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 9010 360 9010 {
lab=word150}
N 360 9010 400 9010 {
lab=word150}
N 330 9000 330 9050 {
lab=GND}
N 330 9050 330 9060 {
lab=GND}
N 390 9000 390 9050 {
lab=Y4}
N 390 9050 390 9060 {
lab=Y4}

N 410 9060 440 9060 {
lab=GND}
N 440 9050 440 9060 {
lab=GND}
N 400 9010 440 9010 {
lab=word150}
N 440 9010 480 9010 {
lab=word150}
N 410 9000 410 9050 {
lab=GND}
N 410 9050 410 9060 {
lab=GND}
N 470 9000 470 9050 {
lab=Y5}
N 470 9050 470 9060 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 9030 1 0 {name=M607
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 9060 520 9060 {
lab=GND}
N 520 9050 520 9060 {
lab=GND}
N 480 9010 520 9010 {
lab=word150}
N 520 9010 560 9010 {
lab=word150}
N 490 9000 490 9050 {
lab=GND}
N 490 9050 490 9060 {
lab=GND}
N 550 9000 550 9050 {
lab=Y6}
N 550 9050 550 9060 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9030 1 0 {name=M608
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9060 600 9060 {
lab=GND}
N 600 9050 600 9060 {
lab=GND}
N 560 9010 600 9010 {
lab=word150}
N 600 9010 640 9010 {
lab=word150}
N 570 9000 570 9050 {
lab=GND}
N 570 9050 570 9060 {
lab=GND}
N 630 9000 630 9050 {
lab=Y7}
N 630 9050 630 9060 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9030 1 0 {name=M609
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9070 0 0 {name=p174 lab=word151}
N 0 9070 40 9070 {
lab=word151}
N 40 9070 80 9070 {
lab=word151}
N 10 9060 10 9110 {
lab=GND}
N 10 9110 10 9120 {
lab=GND}
N 70 9060 70 9110 {
lab=Y0}
N 70 9110 70 9120 {
lab=Y0}

N 90 9120 120 9120 {
lab=GND}
N 120 9110 120 9120 {
lab=GND}
N 80 9070 120 9070 {
lab=word151}
N 120 9070 160 9070 {
lab=word151}
N 90 9060 90 9110 {
lab=GND}
N 90 9110 90 9120 {
lab=GND}
N 150 9060 150 9110 {
lab=Y1}
N 150 9110 150 9120 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 9090 1 0 {name=M610
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 9070 200 9070 {
lab=word151}
N 200 9070 240 9070 {
lab=word151}
N 170 9060 170 9110 {
lab=GND}
N 170 9110 170 9120 {
lab=GND}
N 230 9060 230 9110 {
lab=Y2}
N 230 9110 230 9120 {
lab=Y2}

N 250 9120 280 9120 {
lab=GND}
N 280 9110 280 9120 {
lab=GND}
N 240 9070 280 9070 {
lab=word151}
N 280 9070 320 9070 {
lab=word151}
N 250 9060 250 9110 {
lab=GND}
N 250 9110 250 9120 {
lab=GND}
N 310 9060 310 9110 {
lab=Y3}
N 310 9110 310 9120 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 9090 1 0 {name=M611
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 9120 360 9120 {
lab=GND}
N 360 9110 360 9120 {
lab=GND}
N 320 9070 360 9070 {
lab=word151}
N 360 9070 400 9070 {
lab=word151}
N 330 9060 330 9110 {
lab=GND}
N 330 9110 330 9120 {
lab=GND}
N 390 9060 390 9110 {
lab=Y4}
N 390 9110 390 9120 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 9090 1 0 {name=M612
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 9070 440 9070 {
lab=word151}
N 440 9070 480 9070 {
lab=word151}
N 410 9060 410 9110 {
lab=GND}
N 410 9110 410 9120 {
lab=GND}
N 470 9060 470 9110 {
lab=Y5}
N 470 9110 470 9120 {
lab=Y5}

N 490 9120 520 9120 {
lab=GND}
N 520 9110 520 9120 {
lab=GND}
N 480 9070 520 9070 {
lab=word151}
N 520 9070 560 9070 {
lab=word151}
N 490 9060 490 9110 {
lab=GND}
N 490 9110 490 9120 {
lab=GND}
N 550 9060 550 9110 {
lab=Y6}
N 550 9110 550 9120 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9090 1 0 {name=M613
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9120 600 9120 {
lab=GND}
N 600 9110 600 9120 {
lab=GND}
N 560 9070 600 9070 {
lab=word151}
N 600 9070 640 9070 {
lab=word151}
N 570 9060 570 9110 {
lab=GND}
N 570 9110 570 9120 {
lab=GND}
N 630 9060 630 9110 {
lab=Y7}
N 630 9110 630 9120 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9090 1 0 {name=M614
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9130 0 0 {name=p175 lab=word152}
N 0 9130 40 9130 {
lab=word152}
N 40 9130 80 9130 {
lab=word152}
N 10 9120 10 9170 {
lab=GND}
N 10 9170 10 9180 {
lab=GND}
N 70 9120 70 9170 {
lab=Y0}
N 70 9170 70 9180 {
lab=Y0}

N 90 9180 120 9180 {
lab=GND}
N 120 9170 120 9180 {
lab=GND}
N 80 9130 120 9130 {
lab=word152}
N 120 9130 160 9130 {
lab=word152}
N 90 9120 90 9170 {
lab=GND}
N 90 9170 90 9180 {
lab=GND}
N 150 9120 150 9170 {
lab=Y1}
N 150 9170 150 9180 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 9150 1 0 {name=M615
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 9130 200 9130 {
lab=word152}
N 200 9130 240 9130 {
lab=word152}
N 170 9120 170 9170 {
lab=GND}
N 170 9170 170 9180 {
lab=GND}
N 230 9120 230 9170 {
lab=Y2}
N 230 9170 230 9180 {
lab=Y2}

N 250 9180 280 9180 {
lab=GND}
N 280 9170 280 9180 {
lab=GND}
N 240 9130 280 9130 {
lab=word152}
N 280 9130 320 9130 {
lab=word152}
N 250 9120 250 9170 {
lab=GND}
N 250 9170 250 9180 {
lab=GND}
N 310 9120 310 9170 {
lab=Y3}
N 310 9170 310 9180 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 9150 1 0 {name=M616
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 9180 360 9180 {
lab=GND}
N 360 9170 360 9180 {
lab=GND}
N 320 9130 360 9130 {
lab=word152}
N 360 9130 400 9130 {
lab=word152}
N 330 9120 330 9170 {
lab=GND}
N 330 9170 330 9180 {
lab=GND}
N 390 9120 390 9170 {
lab=Y4}
N 390 9170 390 9180 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 9150 1 0 {name=M617
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 9180 440 9180 {
lab=GND}
N 440 9170 440 9180 {
lab=GND}
N 400 9130 440 9130 {
lab=word152}
N 440 9130 480 9130 {
lab=word152}
N 410 9120 410 9170 {
lab=GND}
N 410 9170 410 9180 {
lab=GND}
N 470 9120 470 9170 {
lab=Y5}
N 470 9170 470 9180 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 9150 1 0 {name=M618
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 9180 520 9180 {
lab=GND}
N 520 9170 520 9180 {
lab=GND}
N 480 9130 520 9130 {
lab=word152}
N 520 9130 560 9130 {
lab=word152}
N 490 9120 490 9170 {
lab=GND}
N 490 9170 490 9180 {
lab=GND}
N 550 9120 550 9170 {
lab=Y6}
N 550 9170 550 9180 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9150 1 0 {name=M619
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9180 600 9180 {
lab=GND}
N 600 9170 600 9180 {
lab=GND}
N 560 9130 600 9130 {
lab=word152}
N 600 9130 640 9130 {
lab=word152}
N 570 9120 570 9170 {
lab=GND}
N 570 9170 570 9180 {
lab=GND}
N 630 9120 630 9170 {
lab=Y7}
N 630 9170 630 9180 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9150 1 0 {name=M620
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9190 0 0 {name=p176 lab=word153}
N 0 9190 40 9190 {
lab=word153}
N 40 9190 80 9190 {
lab=word153}
N 10 9180 10 9230 {
lab=GND}
N 10 9230 10 9240 {
lab=GND}
N 70 9180 70 9230 {
lab=Y0}
N 70 9230 70 9240 {
lab=Y0}

N 90 9240 120 9240 {
lab=GND}
N 120 9230 120 9240 {
lab=GND}
N 80 9190 120 9190 {
lab=word153}
N 120 9190 160 9190 {
lab=word153}
N 90 9180 90 9230 {
lab=GND}
N 90 9230 90 9240 {
lab=GND}
N 150 9180 150 9230 {
lab=Y1}
N 150 9230 150 9240 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 9210 1 0 {name=M621
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 9240 200 9240 {
lab=GND}
N 200 9230 200 9240 {
lab=GND}
N 160 9190 200 9190 {
lab=word153}
N 200 9190 240 9190 {
lab=word153}
N 170 9180 170 9230 {
lab=GND}
N 170 9230 170 9240 {
lab=GND}
N 230 9180 230 9230 {
lab=Y2}
N 230 9230 230 9240 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 9210 1 0 {name=M622
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 9190 280 9190 {
lab=word153}
N 280 9190 320 9190 {
lab=word153}
N 250 9180 250 9230 {
lab=GND}
N 250 9230 250 9240 {
lab=GND}
N 310 9180 310 9230 {
lab=Y3}
N 310 9230 310 9240 {
lab=Y3}
N 320 9190 360 9190 {
lab=word153}
N 360 9190 400 9190 {
lab=word153}
N 330 9180 330 9230 {
lab=GND}
N 330 9230 330 9240 {
lab=GND}
N 390 9180 390 9230 {
lab=Y4}
N 390 9230 390 9240 {
lab=Y4}
N 400 9190 440 9190 {
lab=word153}
N 440 9190 480 9190 {
lab=word153}
N 410 9180 410 9230 {
lab=GND}
N 410 9230 410 9240 {
lab=GND}
N 470 9180 470 9230 {
lab=Y5}
N 470 9230 470 9240 {
lab=Y5}

N 490 9240 520 9240 {
lab=GND}
N 520 9230 520 9240 {
lab=GND}
N 480 9190 520 9190 {
lab=word153}
N 520 9190 560 9190 {
lab=word153}
N 490 9180 490 9230 {
lab=GND}
N 490 9230 490 9240 {
lab=GND}
N 550 9180 550 9230 {
lab=Y6}
N 550 9230 550 9240 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9210 1 0 {name=M623
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9240 600 9240 {
lab=GND}
N 600 9230 600 9240 {
lab=GND}
N 560 9190 600 9190 {
lab=word153}
N 600 9190 640 9190 {
lab=word153}
N 570 9180 570 9230 {
lab=GND}
N 570 9230 570 9240 {
lab=GND}
N 630 9180 630 9230 {
lab=Y7}
N 630 9230 630 9240 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9210 1 0 {name=M624
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9250 0 0 {name=p177 lab=word154}
N 0 9250 40 9250 {
lab=word154}
N 40 9250 80 9250 {
lab=word154}
N 10 9240 10 9290 {
lab=GND}
N 10 9290 10 9300 {
lab=GND}
N 70 9240 70 9290 {
lab=Y0}
N 70 9290 70 9300 {
lab=Y0}

N 90 9300 120 9300 {
lab=GND}
N 120 9290 120 9300 {
lab=GND}
N 80 9250 120 9250 {
lab=word154}
N 120 9250 160 9250 {
lab=word154}
N 90 9240 90 9290 {
lab=GND}
N 90 9290 90 9300 {
lab=GND}
N 150 9240 150 9290 {
lab=Y1}
N 150 9290 150 9300 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 9270 1 0 {name=M625
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 9300 200 9300 {
lab=GND}
N 200 9290 200 9300 {
lab=GND}
N 160 9250 200 9250 {
lab=word154}
N 200 9250 240 9250 {
lab=word154}
N 170 9240 170 9290 {
lab=GND}
N 170 9290 170 9300 {
lab=GND}
N 230 9240 230 9290 {
lab=Y2}
N 230 9290 230 9300 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 9270 1 0 {name=M626
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 9250 280 9250 {
lab=word154}
N 280 9250 320 9250 {
lab=word154}
N 250 9240 250 9290 {
lab=GND}
N 250 9290 250 9300 {
lab=GND}
N 310 9240 310 9290 {
lab=Y3}
N 310 9290 310 9300 {
lab=Y3}
N 320 9250 360 9250 {
lab=word154}
N 360 9250 400 9250 {
lab=word154}
N 330 9240 330 9290 {
lab=GND}
N 330 9290 330 9300 {
lab=GND}
N 390 9240 390 9290 {
lab=Y4}
N 390 9290 390 9300 {
lab=Y4}

N 410 9300 440 9300 {
lab=GND}
N 440 9290 440 9300 {
lab=GND}
N 400 9250 440 9250 {
lab=word154}
N 440 9250 480 9250 {
lab=word154}
N 410 9240 410 9290 {
lab=GND}
N 410 9290 410 9300 {
lab=GND}
N 470 9240 470 9290 {
lab=Y5}
N 470 9290 470 9300 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 9270 1 0 {name=M627
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 9300 520 9300 {
lab=GND}
N 520 9290 520 9300 {
lab=GND}
N 480 9250 520 9250 {
lab=word154}
N 520 9250 560 9250 {
lab=word154}
N 490 9240 490 9290 {
lab=GND}
N 490 9290 490 9300 {
lab=GND}
N 550 9240 550 9290 {
lab=Y6}
N 550 9290 550 9300 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9270 1 0 {name=M628
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9300 600 9300 {
lab=GND}
N 600 9290 600 9300 {
lab=GND}
N 560 9250 600 9250 {
lab=word154}
N 600 9250 640 9250 {
lab=word154}
N 570 9240 570 9290 {
lab=GND}
N 570 9290 570 9300 {
lab=GND}
N 630 9240 630 9290 {
lab=Y7}
N 630 9290 630 9300 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9270 1 0 {name=M629
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9310 0 0 {name=p178 lab=word155}
N 0 9310 40 9310 {
lab=word155}
N 40 9310 80 9310 {
lab=word155}
N 10 9300 10 9350 {
lab=GND}
N 10 9350 10 9360 {
lab=GND}
N 70 9300 70 9350 {
lab=Y0}
N 70 9350 70 9360 {
lab=Y0}

N 90 9360 120 9360 {
lab=GND}
N 120 9350 120 9360 {
lab=GND}
N 80 9310 120 9310 {
lab=word155}
N 120 9310 160 9310 {
lab=word155}
N 90 9300 90 9350 {
lab=GND}
N 90 9350 90 9360 {
lab=GND}
N 150 9300 150 9350 {
lab=Y1}
N 150 9350 150 9360 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 9330 1 0 {name=M630
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 9360 200 9360 {
lab=GND}
N 200 9350 200 9360 {
lab=GND}
N 160 9310 200 9310 {
lab=word155}
N 200 9310 240 9310 {
lab=word155}
N 170 9300 170 9350 {
lab=GND}
N 170 9350 170 9360 {
lab=GND}
N 230 9300 230 9350 {
lab=Y2}
N 230 9350 230 9360 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 9330 1 0 {name=M631
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 9310 280 9310 {
lab=word155}
N 280 9310 320 9310 {
lab=word155}
N 250 9300 250 9350 {
lab=GND}
N 250 9350 250 9360 {
lab=GND}
N 310 9300 310 9350 {
lab=Y3}
N 310 9350 310 9360 {
lab=Y3}

N 330 9360 360 9360 {
lab=GND}
N 360 9350 360 9360 {
lab=GND}
N 320 9310 360 9310 {
lab=word155}
N 360 9310 400 9310 {
lab=word155}
N 330 9300 330 9350 {
lab=GND}
N 330 9350 330 9360 {
lab=GND}
N 390 9300 390 9350 {
lab=Y4}
N 390 9350 390 9360 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 9330 1 0 {name=M632
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 9310 440 9310 {
lab=word155}
N 440 9310 480 9310 {
lab=word155}
N 410 9300 410 9350 {
lab=GND}
N 410 9350 410 9360 {
lab=GND}
N 470 9300 470 9350 {
lab=Y5}
N 470 9350 470 9360 {
lab=Y5}

N 490 9360 520 9360 {
lab=GND}
N 520 9350 520 9360 {
lab=GND}
N 480 9310 520 9310 {
lab=word155}
N 520 9310 560 9310 {
lab=word155}
N 490 9300 490 9350 {
lab=GND}
N 490 9350 490 9360 {
lab=GND}
N 550 9300 550 9350 {
lab=Y6}
N 550 9350 550 9360 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9330 1 0 {name=M633
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9360 600 9360 {
lab=GND}
N 600 9350 600 9360 {
lab=GND}
N 560 9310 600 9310 {
lab=word155}
N 600 9310 640 9310 {
lab=word155}
N 570 9300 570 9350 {
lab=GND}
N 570 9350 570 9360 {
lab=GND}
N 630 9300 630 9350 {
lab=Y7}
N 630 9350 630 9360 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9330 1 0 {name=M634
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9370 0 0 {name=p179 lab=word156}
N 0 9370 40 9370 {
lab=word156}
N 40 9370 80 9370 {
lab=word156}
N 10 9360 10 9410 {
lab=GND}
N 10 9410 10 9420 {
lab=GND}
N 70 9360 70 9410 {
lab=Y0}
N 70 9410 70 9420 {
lab=Y0}

N 90 9420 120 9420 {
lab=GND}
N 120 9410 120 9420 {
lab=GND}
N 80 9370 120 9370 {
lab=word156}
N 120 9370 160 9370 {
lab=word156}
N 90 9360 90 9410 {
lab=GND}
N 90 9410 90 9420 {
lab=GND}
N 150 9360 150 9410 {
lab=Y1}
N 150 9410 150 9420 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 9390 1 0 {name=M635
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 9420 200 9420 {
lab=GND}
N 200 9410 200 9420 {
lab=GND}
N 160 9370 200 9370 {
lab=word156}
N 200 9370 240 9370 {
lab=word156}
N 170 9360 170 9410 {
lab=GND}
N 170 9410 170 9420 {
lab=GND}
N 230 9360 230 9410 {
lab=Y2}
N 230 9410 230 9420 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 9390 1 0 {name=M636
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 9370 280 9370 {
lab=word156}
N 280 9370 320 9370 {
lab=word156}
N 250 9360 250 9410 {
lab=GND}
N 250 9410 250 9420 {
lab=GND}
N 310 9360 310 9410 {
lab=Y3}
N 310 9410 310 9420 {
lab=Y3}

N 330 9420 360 9420 {
lab=GND}
N 360 9410 360 9420 {
lab=GND}
N 320 9370 360 9370 {
lab=word156}
N 360 9370 400 9370 {
lab=word156}
N 330 9360 330 9410 {
lab=GND}
N 330 9410 330 9420 {
lab=GND}
N 390 9360 390 9410 {
lab=Y4}
N 390 9410 390 9420 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 9390 1 0 {name=M637
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 9420 440 9420 {
lab=GND}
N 440 9410 440 9420 {
lab=GND}
N 400 9370 440 9370 {
lab=word156}
N 440 9370 480 9370 {
lab=word156}
N 410 9360 410 9410 {
lab=GND}
N 410 9410 410 9420 {
lab=GND}
N 470 9360 470 9410 {
lab=Y5}
N 470 9410 470 9420 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 9390 1 0 {name=M638
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 9420 520 9420 {
lab=GND}
N 520 9410 520 9420 {
lab=GND}
N 480 9370 520 9370 {
lab=word156}
N 520 9370 560 9370 {
lab=word156}
N 490 9360 490 9410 {
lab=GND}
N 490 9410 490 9420 {
lab=GND}
N 550 9360 550 9410 {
lab=Y6}
N 550 9410 550 9420 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9390 1 0 {name=M639
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9420 600 9420 {
lab=GND}
N 600 9410 600 9420 {
lab=GND}
N 560 9370 600 9370 {
lab=word156}
N 600 9370 640 9370 {
lab=word156}
N 570 9360 570 9410 {
lab=GND}
N 570 9410 570 9420 {
lab=GND}
N 630 9360 630 9410 {
lab=Y7}
N 630 9410 630 9420 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9390 1 0 {name=M640
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9430 0 0 {name=p180 lab=word157}
N 0 9430 40 9430 {
lab=word157}
N 40 9430 80 9430 {
lab=word157}
N 10 9420 10 9470 {
lab=GND}
N 10 9470 10 9480 {
lab=GND}
N 70 9420 70 9470 {
lab=Y0}
N 70 9470 70 9480 {
lab=Y0}

N 90 9480 120 9480 {
lab=GND}
N 120 9470 120 9480 {
lab=GND}
N 80 9430 120 9430 {
lab=word157}
N 120 9430 160 9430 {
lab=word157}
N 90 9420 90 9470 {
lab=GND}
N 90 9470 90 9480 {
lab=GND}
N 150 9420 150 9470 {
lab=Y1}
N 150 9470 150 9480 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 9450 1 0 {name=M641
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 9480 200 9480 {
lab=GND}
N 200 9470 200 9480 {
lab=GND}
N 160 9430 200 9430 {
lab=word157}
N 200 9430 240 9430 {
lab=word157}
N 170 9420 170 9470 {
lab=GND}
N 170 9470 170 9480 {
lab=GND}
N 230 9420 230 9470 {
lab=Y2}
N 230 9470 230 9480 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 9450 1 0 {name=M642
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 9480 280 9480 {
lab=GND}
N 280 9470 280 9480 {
lab=GND}
N 240 9430 280 9430 {
lab=word157}
N 280 9430 320 9430 {
lab=word157}
N 250 9420 250 9470 {
lab=GND}
N 250 9470 250 9480 {
lab=GND}
N 310 9420 310 9470 {
lab=Y3}
N 310 9470 310 9480 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 9450 1 0 {name=M643
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 9430 360 9430 {
lab=word157}
N 360 9430 400 9430 {
lab=word157}
N 330 9420 330 9470 {
lab=GND}
N 330 9470 330 9480 {
lab=GND}
N 390 9420 390 9470 {
lab=Y4}
N 390 9470 390 9480 {
lab=Y4}
N 400 9430 440 9430 {
lab=word157}
N 440 9430 480 9430 {
lab=word157}
N 410 9420 410 9470 {
lab=GND}
N 410 9470 410 9480 {
lab=GND}
N 470 9420 470 9470 {
lab=Y5}
N 470 9470 470 9480 {
lab=Y5}

N 490 9480 520 9480 {
lab=GND}
N 520 9470 520 9480 {
lab=GND}
N 480 9430 520 9430 {
lab=word157}
N 520 9430 560 9430 {
lab=word157}
N 490 9420 490 9470 {
lab=GND}
N 490 9470 490 9480 {
lab=GND}
N 550 9420 550 9470 {
lab=Y6}
N 550 9470 550 9480 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9450 1 0 {name=M644
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9480 600 9480 {
lab=GND}
N 600 9470 600 9480 {
lab=GND}
N 560 9430 600 9430 {
lab=word157}
N 600 9430 640 9430 {
lab=word157}
N 570 9420 570 9470 {
lab=GND}
N 570 9470 570 9480 {
lab=GND}
N 630 9420 630 9470 {
lab=Y7}
N 630 9470 630 9480 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9450 1 0 {name=M645
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9490 0 0 {name=p181 lab=word158}
N 0 9490 40 9490 {
lab=word158}
N 40 9490 80 9490 {
lab=word158}
N 10 9480 10 9530 {
lab=GND}
N 10 9530 10 9540 {
lab=GND}
N 70 9480 70 9530 {
lab=Y0}
N 70 9530 70 9540 {
lab=Y0}

N 90 9540 120 9540 {
lab=GND}
N 120 9530 120 9540 {
lab=GND}
N 80 9490 120 9490 {
lab=word158}
N 120 9490 160 9490 {
lab=word158}
N 90 9480 90 9530 {
lab=GND}
N 90 9530 90 9540 {
lab=GND}
N 150 9480 150 9530 {
lab=Y1}
N 150 9530 150 9540 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 9510 1 0 {name=M646
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 9540 200 9540 {
lab=GND}
N 200 9530 200 9540 {
lab=GND}
N 160 9490 200 9490 {
lab=word158}
N 200 9490 240 9490 {
lab=word158}
N 170 9480 170 9530 {
lab=GND}
N 170 9530 170 9540 {
lab=GND}
N 230 9480 230 9530 {
lab=Y2}
N 230 9530 230 9540 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 9510 1 0 {name=M647
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 9540 280 9540 {
lab=GND}
N 280 9530 280 9540 {
lab=GND}
N 240 9490 280 9490 {
lab=word158}
N 280 9490 320 9490 {
lab=word158}
N 250 9480 250 9530 {
lab=GND}
N 250 9530 250 9540 {
lab=GND}
N 310 9480 310 9530 {
lab=Y3}
N 310 9530 310 9540 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 9510 1 0 {name=M648
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 9490 360 9490 {
lab=word158}
N 360 9490 400 9490 {
lab=word158}
N 330 9480 330 9530 {
lab=GND}
N 330 9530 330 9540 {
lab=GND}
N 390 9480 390 9530 {
lab=Y4}
N 390 9530 390 9540 {
lab=Y4}

N 410 9540 440 9540 {
lab=GND}
N 440 9530 440 9540 {
lab=GND}
N 400 9490 440 9490 {
lab=word158}
N 440 9490 480 9490 {
lab=word158}
N 410 9480 410 9530 {
lab=GND}
N 410 9530 410 9540 {
lab=GND}
N 470 9480 470 9530 {
lab=Y5}
N 470 9530 470 9540 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 9510 1 0 {name=M649
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 9540 520 9540 {
lab=GND}
N 520 9530 520 9540 {
lab=GND}
N 480 9490 520 9490 {
lab=word158}
N 520 9490 560 9490 {
lab=word158}
N 490 9480 490 9530 {
lab=GND}
N 490 9530 490 9540 {
lab=GND}
N 550 9480 550 9530 {
lab=Y6}
N 550 9530 550 9540 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9510 1 0 {name=M650
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9540 600 9540 {
lab=GND}
N 600 9530 600 9540 {
lab=GND}
N 560 9490 600 9490 {
lab=word158}
N 600 9490 640 9490 {
lab=word158}
N 570 9480 570 9530 {
lab=GND}
N 570 9530 570 9540 {
lab=GND}
N 630 9480 630 9530 {
lab=Y7}
N 630 9530 630 9540 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9510 1 0 {name=M651
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9550 0 0 {name=p182 lab=word159}
N 0 9550 40 9550 {
lab=word159}
N 40 9550 80 9550 {
lab=word159}
N 10 9540 10 9590 {
lab=GND}
N 10 9590 10 9600 {
lab=GND}
N 70 9540 70 9590 {
lab=Y0}
N 70 9590 70 9600 {
lab=Y0}

N 90 9600 120 9600 {
lab=GND}
N 120 9590 120 9600 {
lab=GND}
N 80 9550 120 9550 {
lab=word159}
N 120 9550 160 9550 {
lab=word159}
N 90 9540 90 9590 {
lab=GND}
N 90 9590 90 9600 {
lab=GND}
N 150 9540 150 9590 {
lab=Y1}
N 150 9590 150 9600 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 9570 1 0 {name=M652
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 9600 200 9600 {
lab=GND}
N 200 9590 200 9600 {
lab=GND}
N 160 9550 200 9550 {
lab=word159}
N 200 9550 240 9550 {
lab=word159}
N 170 9540 170 9590 {
lab=GND}
N 170 9590 170 9600 {
lab=GND}
N 230 9540 230 9590 {
lab=Y2}
N 230 9590 230 9600 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 9570 1 0 {name=M653
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 9600 280 9600 {
lab=GND}
N 280 9590 280 9600 {
lab=GND}
N 240 9550 280 9550 {
lab=word159}
N 280 9550 320 9550 {
lab=word159}
N 250 9540 250 9590 {
lab=GND}
N 250 9590 250 9600 {
lab=GND}
N 310 9540 310 9590 {
lab=Y3}
N 310 9590 310 9600 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 9570 1 0 {name=M654
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 9600 360 9600 {
lab=GND}
N 360 9590 360 9600 {
lab=GND}
N 320 9550 360 9550 {
lab=word159}
N 360 9550 400 9550 {
lab=word159}
N 330 9540 330 9590 {
lab=GND}
N 330 9590 330 9600 {
lab=GND}
N 390 9540 390 9590 {
lab=Y4}
N 390 9590 390 9600 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 9570 1 0 {name=M655
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 9550 440 9550 {
lab=word159}
N 440 9550 480 9550 {
lab=word159}
N 410 9540 410 9590 {
lab=GND}
N 410 9590 410 9600 {
lab=GND}
N 470 9540 470 9590 {
lab=Y5}
N 470 9590 470 9600 {
lab=Y5}

N 490 9600 520 9600 {
lab=GND}
N 520 9590 520 9600 {
lab=GND}
N 480 9550 520 9550 {
lab=word159}
N 520 9550 560 9550 {
lab=word159}
N 490 9540 490 9590 {
lab=GND}
N 490 9590 490 9600 {
lab=GND}
N 550 9540 550 9590 {
lab=Y6}
N 550 9590 550 9600 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9570 1 0 {name=M656
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9600 600 9600 {
lab=GND}
N 600 9590 600 9600 {
lab=GND}
N 560 9550 600 9550 {
lab=word159}
N 600 9550 640 9550 {
lab=word159}
N 570 9540 570 9590 {
lab=GND}
N 570 9590 570 9600 {
lab=GND}
N 630 9540 630 9590 {
lab=Y7}
N 630 9590 630 9600 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9570 1 0 {name=M657
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9610 0 0 {name=p183 lab=word160}
N 0 9610 40 9610 {
lab=word160}
N 40 9610 80 9610 {
lab=word160}
N 10 9600 10 9650 {
lab=GND}
N 10 9650 10 9660 {
lab=GND}
N 70 9600 70 9650 {
lab=Y0}
N 70 9650 70 9660 {
lab=Y0}

N 90 9660 120 9660 {
lab=GND}
N 120 9650 120 9660 {
lab=GND}
N 80 9610 120 9610 {
lab=word160}
N 120 9610 160 9610 {
lab=word160}
N 90 9600 90 9650 {
lab=GND}
N 90 9650 90 9660 {
lab=GND}
N 150 9600 150 9650 {
lab=Y1}
N 150 9650 150 9660 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 9630 1 0 {name=M658
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 9660 200 9660 {
lab=GND}
N 200 9650 200 9660 {
lab=GND}
N 160 9610 200 9610 {
lab=word160}
N 200 9610 240 9610 {
lab=word160}
N 170 9600 170 9650 {
lab=GND}
N 170 9650 170 9660 {
lab=GND}
N 230 9600 230 9650 {
lab=Y2}
N 230 9650 230 9660 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 9630 1 0 {name=M659
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 9660 280 9660 {
lab=GND}
N 280 9650 280 9660 {
lab=GND}
N 240 9610 280 9610 {
lab=word160}
N 280 9610 320 9610 {
lab=word160}
N 250 9600 250 9650 {
lab=GND}
N 250 9650 250 9660 {
lab=GND}
N 310 9600 310 9650 {
lab=Y3}
N 310 9650 310 9660 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 9630 1 0 {name=M660
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 9660 360 9660 {
lab=GND}
N 360 9650 360 9660 {
lab=GND}
N 320 9610 360 9610 {
lab=word160}
N 360 9610 400 9610 {
lab=word160}
N 330 9600 330 9650 {
lab=GND}
N 330 9650 330 9660 {
lab=GND}
N 390 9600 390 9650 {
lab=Y4}
N 390 9650 390 9660 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 9630 1 0 {name=M661
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 9660 440 9660 {
lab=GND}
N 440 9650 440 9660 {
lab=GND}
N 400 9610 440 9610 {
lab=word160}
N 440 9610 480 9610 {
lab=word160}
N 410 9600 410 9650 {
lab=GND}
N 410 9650 410 9660 {
lab=GND}
N 470 9600 470 9650 {
lab=Y5}
N 470 9650 470 9660 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 9630 1 0 {name=M662
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 9660 520 9660 {
lab=GND}
N 520 9650 520 9660 {
lab=GND}
N 480 9610 520 9610 {
lab=word160}
N 520 9610 560 9610 {
lab=word160}
N 490 9600 490 9650 {
lab=GND}
N 490 9650 490 9660 {
lab=GND}
N 550 9600 550 9650 {
lab=Y6}
N 550 9650 550 9660 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9630 1 0 {name=M663
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9660 600 9660 {
lab=GND}
N 600 9650 600 9660 {
lab=GND}
N 560 9610 600 9610 {
lab=word160}
N 600 9610 640 9610 {
lab=word160}
N 570 9600 570 9650 {
lab=GND}
N 570 9650 570 9660 {
lab=GND}
N 630 9600 630 9650 {
lab=Y7}
N 630 9650 630 9660 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9630 1 0 {name=M664
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9670 0 0 {name=p184 lab=word161}

N 10 9720 40 9720 {
lab=GND}
N 40 9710 40 9720 {
lab=GND}
N 0 9670 40 9670 {
lab=word161}
N 40 9670 80 9670 {
lab=word161}
N 10 9660 10 9710 {
lab=GND}
N 10 9710 10 9720 {
lab=GND}
N 70 9660 70 9710 {
lab=Y0}
N 70 9710 70 9720 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 9690 1 0 {name=M665
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 9670 120 9670 {
lab=word161}
N 120 9670 160 9670 {
lab=word161}
N 90 9660 90 9710 {
lab=GND}
N 90 9710 90 9720 {
lab=GND}
N 150 9660 150 9710 {
lab=Y1}
N 150 9710 150 9720 {
lab=Y1}
N 160 9670 200 9670 {
lab=word161}
N 200 9670 240 9670 {
lab=word161}
N 170 9660 170 9710 {
lab=GND}
N 170 9710 170 9720 {
lab=GND}
N 230 9660 230 9710 {
lab=Y2}
N 230 9710 230 9720 {
lab=Y2}
N 240 9670 280 9670 {
lab=word161}
N 280 9670 320 9670 {
lab=word161}
N 250 9660 250 9710 {
lab=GND}
N 250 9710 250 9720 {
lab=GND}
N 310 9660 310 9710 {
lab=Y3}
N 310 9710 310 9720 {
lab=Y3}
N 320 9670 360 9670 {
lab=word161}
N 360 9670 400 9670 {
lab=word161}
N 330 9660 330 9710 {
lab=GND}
N 330 9710 330 9720 {
lab=GND}
N 390 9660 390 9710 {
lab=Y4}
N 390 9710 390 9720 {
lab=Y4}
N 400 9670 440 9670 {
lab=word161}
N 440 9670 480 9670 {
lab=word161}
N 410 9660 410 9710 {
lab=GND}
N 410 9710 410 9720 {
lab=GND}
N 470 9660 470 9710 {
lab=Y5}
N 470 9710 470 9720 {
lab=Y5}

N 490 9720 520 9720 {
lab=GND}
N 520 9710 520 9720 {
lab=GND}
N 480 9670 520 9670 {
lab=word161}
N 520 9670 560 9670 {
lab=word161}
N 490 9660 490 9710 {
lab=GND}
N 490 9710 490 9720 {
lab=GND}
N 550 9660 550 9710 {
lab=Y6}
N 550 9710 550 9720 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9690 1 0 {name=M666
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9720 600 9720 {
lab=GND}
N 600 9710 600 9720 {
lab=GND}
N 560 9670 600 9670 {
lab=word161}
N 600 9670 640 9670 {
lab=word161}
N 570 9660 570 9710 {
lab=GND}
N 570 9710 570 9720 {
lab=GND}
N 630 9660 630 9710 {
lab=Y7}
N 630 9710 630 9720 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9690 1 0 {name=M667
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9730 0 0 {name=p185 lab=word162}

N 10 9780 40 9780 {
lab=GND}
N 40 9770 40 9780 {
lab=GND}
N 0 9730 40 9730 {
lab=word162}
N 40 9730 80 9730 {
lab=word162}
N 10 9720 10 9770 {
lab=GND}
N 10 9770 10 9780 {
lab=GND}
N 70 9720 70 9770 {
lab=Y0}
N 70 9770 70 9780 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 9750 1 0 {name=M668
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 9730 120 9730 {
lab=word162}
N 120 9730 160 9730 {
lab=word162}
N 90 9720 90 9770 {
lab=GND}
N 90 9770 90 9780 {
lab=GND}
N 150 9720 150 9770 {
lab=Y1}
N 150 9770 150 9780 {
lab=Y1}
N 160 9730 200 9730 {
lab=word162}
N 200 9730 240 9730 {
lab=word162}
N 170 9720 170 9770 {
lab=GND}
N 170 9770 170 9780 {
lab=GND}
N 230 9720 230 9770 {
lab=Y2}
N 230 9770 230 9780 {
lab=Y2}
N 240 9730 280 9730 {
lab=word162}
N 280 9730 320 9730 {
lab=word162}
N 250 9720 250 9770 {
lab=GND}
N 250 9770 250 9780 {
lab=GND}
N 310 9720 310 9770 {
lab=Y3}
N 310 9770 310 9780 {
lab=Y3}
N 320 9730 360 9730 {
lab=word162}
N 360 9730 400 9730 {
lab=word162}
N 330 9720 330 9770 {
lab=GND}
N 330 9770 330 9780 {
lab=GND}
N 390 9720 390 9770 {
lab=Y4}
N 390 9770 390 9780 {
lab=Y4}

N 410 9780 440 9780 {
lab=GND}
N 440 9770 440 9780 {
lab=GND}
N 400 9730 440 9730 {
lab=word162}
N 440 9730 480 9730 {
lab=word162}
N 410 9720 410 9770 {
lab=GND}
N 410 9770 410 9780 {
lab=GND}
N 470 9720 470 9770 {
lab=Y5}
N 470 9770 470 9780 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 9750 1 0 {name=M669
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 9780 520 9780 {
lab=GND}
N 520 9770 520 9780 {
lab=GND}
N 480 9730 520 9730 {
lab=word162}
N 520 9730 560 9730 {
lab=word162}
N 490 9720 490 9770 {
lab=GND}
N 490 9770 490 9780 {
lab=GND}
N 550 9720 550 9770 {
lab=Y6}
N 550 9770 550 9780 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9750 1 0 {name=M670
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9780 600 9780 {
lab=GND}
N 600 9770 600 9780 {
lab=GND}
N 560 9730 600 9730 {
lab=word162}
N 600 9730 640 9730 {
lab=word162}
N 570 9720 570 9770 {
lab=GND}
N 570 9770 570 9780 {
lab=GND}
N 630 9720 630 9770 {
lab=Y7}
N 630 9770 630 9780 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9750 1 0 {name=M671
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9790 0 0 {name=p186 lab=word163}

N 10 9840 40 9840 {
lab=GND}
N 40 9830 40 9840 {
lab=GND}
N 0 9790 40 9790 {
lab=word163}
N 40 9790 80 9790 {
lab=word163}
N 10 9780 10 9830 {
lab=GND}
N 10 9830 10 9840 {
lab=GND}
N 70 9780 70 9830 {
lab=Y0}
N 70 9830 70 9840 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 9810 1 0 {name=M672
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 9790 120 9790 {
lab=word163}
N 120 9790 160 9790 {
lab=word163}
N 90 9780 90 9830 {
lab=GND}
N 90 9830 90 9840 {
lab=GND}
N 150 9780 150 9830 {
lab=Y1}
N 150 9830 150 9840 {
lab=Y1}
N 160 9790 200 9790 {
lab=word163}
N 200 9790 240 9790 {
lab=word163}
N 170 9780 170 9830 {
lab=GND}
N 170 9830 170 9840 {
lab=GND}
N 230 9780 230 9830 {
lab=Y2}
N 230 9830 230 9840 {
lab=Y2}
N 240 9790 280 9790 {
lab=word163}
N 280 9790 320 9790 {
lab=word163}
N 250 9780 250 9830 {
lab=GND}
N 250 9830 250 9840 {
lab=GND}
N 310 9780 310 9830 {
lab=Y3}
N 310 9830 310 9840 {
lab=Y3}

N 330 9840 360 9840 {
lab=GND}
N 360 9830 360 9840 {
lab=GND}
N 320 9790 360 9790 {
lab=word163}
N 360 9790 400 9790 {
lab=word163}
N 330 9780 330 9830 {
lab=GND}
N 330 9830 330 9840 {
lab=GND}
N 390 9780 390 9830 {
lab=Y4}
N 390 9830 390 9840 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 9810 1 0 {name=M673
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 9790 440 9790 {
lab=word163}
N 440 9790 480 9790 {
lab=word163}
N 410 9780 410 9830 {
lab=GND}
N 410 9830 410 9840 {
lab=GND}
N 470 9780 470 9830 {
lab=Y5}
N 470 9830 470 9840 {
lab=Y5}

N 490 9840 520 9840 {
lab=GND}
N 520 9830 520 9840 {
lab=GND}
N 480 9790 520 9790 {
lab=word163}
N 520 9790 560 9790 {
lab=word163}
N 490 9780 490 9830 {
lab=GND}
N 490 9830 490 9840 {
lab=GND}
N 550 9780 550 9830 {
lab=Y6}
N 550 9830 550 9840 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9810 1 0 {name=M674
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9840 600 9840 {
lab=GND}
N 600 9830 600 9840 {
lab=GND}
N 560 9790 600 9790 {
lab=word163}
N 600 9790 640 9790 {
lab=word163}
N 570 9780 570 9830 {
lab=GND}
N 570 9830 570 9840 {
lab=GND}
N 630 9780 630 9830 {
lab=Y7}
N 630 9830 630 9840 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9810 1 0 {name=M675
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9850 0 0 {name=p187 lab=word164}

N 10 9900 40 9900 {
lab=GND}
N 40 9890 40 9900 {
lab=GND}
N 0 9850 40 9850 {
lab=word164}
N 40 9850 80 9850 {
lab=word164}
N 10 9840 10 9890 {
lab=GND}
N 10 9890 10 9900 {
lab=GND}
N 70 9840 70 9890 {
lab=Y0}
N 70 9890 70 9900 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 9870 1 0 {name=M676
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 9850 120 9850 {
lab=word164}
N 120 9850 160 9850 {
lab=word164}
N 90 9840 90 9890 {
lab=GND}
N 90 9890 90 9900 {
lab=GND}
N 150 9840 150 9890 {
lab=Y1}
N 150 9890 150 9900 {
lab=Y1}
N 160 9850 200 9850 {
lab=word164}
N 200 9850 240 9850 {
lab=word164}
N 170 9840 170 9890 {
lab=GND}
N 170 9890 170 9900 {
lab=GND}
N 230 9840 230 9890 {
lab=Y2}
N 230 9890 230 9900 {
lab=Y2}
N 240 9850 280 9850 {
lab=word164}
N 280 9850 320 9850 {
lab=word164}
N 250 9840 250 9890 {
lab=GND}
N 250 9890 250 9900 {
lab=GND}
N 310 9840 310 9890 {
lab=Y3}
N 310 9890 310 9900 {
lab=Y3}

N 330 9900 360 9900 {
lab=GND}
N 360 9890 360 9900 {
lab=GND}
N 320 9850 360 9850 {
lab=word164}
N 360 9850 400 9850 {
lab=word164}
N 330 9840 330 9890 {
lab=GND}
N 330 9890 330 9900 {
lab=GND}
N 390 9840 390 9890 {
lab=Y4}
N 390 9890 390 9900 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 9870 1 0 {name=M677
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 9900 440 9900 {
lab=GND}
N 440 9890 440 9900 {
lab=GND}
N 400 9850 440 9850 {
lab=word164}
N 440 9850 480 9850 {
lab=word164}
N 410 9840 410 9890 {
lab=GND}
N 410 9890 410 9900 {
lab=GND}
N 470 9840 470 9890 {
lab=Y5}
N 470 9890 470 9900 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 9870 1 0 {name=M678
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 9900 520 9900 {
lab=GND}
N 520 9890 520 9900 {
lab=GND}
N 480 9850 520 9850 {
lab=word164}
N 520 9850 560 9850 {
lab=word164}
N 490 9840 490 9890 {
lab=GND}
N 490 9890 490 9900 {
lab=GND}
N 550 9840 550 9890 {
lab=Y6}
N 550 9890 550 9900 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9870 1 0 {name=M679
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9900 600 9900 {
lab=GND}
N 600 9890 600 9900 {
lab=GND}
N 560 9850 600 9850 {
lab=word164}
N 600 9850 640 9850 {
lab=word164}
N 570 9840 570 9890 {
lab=GND}
N 570 9890 570 9900 {
lab=GND}
N 630 9840 630 9890 {
lab=Y7}
N 630 9890 630 9900 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9870 1 0 {name=M680
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9910 0 0 {name=p188 lab=word165}

N 10 9960 40 9960 {
lab=GND}
N 40 9950 40 9960 {
lab=GND}
N 0 9910 40 9910 {
lab=word165}
N 40 9910 80 9910 {
lab=word165}
N 10 9900 10 9950 {
lab=GND}
N 10 9950 10 9960 {
lab=GND}
N 70 9900 70 9950 {
lab=Y0}
N 70 9950 70 9960 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 9930 1 0 {name=M681
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 9910 120 9910 {
lab=word165}
N 120 9910 160 9910 {
lab=word165}
N 90 9900 90 9950 {
lab=GND}
N 90 9950 90 9960 {
lab=GND}
N 150 9900 150 9950 {
lab=Y1}
N 150 9950 150 9960 {
lab=Y1}
N 160 9910 200 9910 {
lab=word165}
N 200 9910 240 9910 {
lab=word165}
N 170 9900 170 9950 {
lab=GND}
N 170 9950 170 9960 {
lab=GND}
N 230 9900 230 9950 {
lab=Y2}
N 230 9950 230 9960 {
lab=Y2}

N 250 9960 280 9960 {
lab=GND}
N 280 9950 280 9960 {
lab=GND}
N 240 9910 280 9910 {
lab=word165}
N 280 9910 320 9910 {
lab=word165}
N 250 9900 250 9950 {
lab=GND}
N 250 9950 250 9960 {
lab=GND}
N 310 9900 310 9950 {
lab=Y3}
N 310 9950 310 9960 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 9930 1 0 {name=M682
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 9910 360 9910 {
lab=word165}
N 360 9910 400 9910 {
lab=word165}
N 330 9900 330 9950 {
lab=GND}
N 330 9950 330 9960 {
lab=GND}
N 390 9900 390 9950 {
lab=Y4}
N 390 9950 390 9960 {
lab=Y4}
N 400 9910 440 9910 {
lab=word165}
N 440 9910 480 9910 {
lab=word165}
N 410 9900 410 9950 {
lab=GND}
N 410 9950 410 9960 {
lab=GND}
N 470 9900 470 9950 {
lab=Y5}
N 470 9950 470 9960 {
lab=Y5}

N 490 9960 520 9960 {
lab=GND}
N 520 9950 520 9960 {
lab=GND}
N 480 9910 520 9910 {
lab=word165}
N 520 9910 560 9910 {
lab=word165}
N 490 9900 490 9950 {
lab=GND}
N 490 9950 490 9960 {
lab=GND}
N 550 9900 550 9950 {
lab=Y6}
N 550 9950 550 9960 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9930 1 0 {name=M683
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 9960 600 9960 {
lab=GND}
N 600 9950 600 9960 {
lab=GND}
N 560 9910 600 9910 {
lab=word165}
N 600 9910 640 9910 {
lab=word165}
N 570 9900 570 9950 {
lab=GND}
N 570 9950 570 9960 {
lab=GND}
N 630 9900 630 9950 {
lab=Y7}
N 630 9950 630 9960 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9930 1 0 {name=M684
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 9970 0 0 {name=p189 lab=word166}

N 10 10020 40 10020 {
lab=GND}
N 40 10010 40 10020 {
lab=GND}
N 0 9970 40 9970 {
lab=word166}
N 40 9970 80 9970 {
lab=word166}
N 10 9960 10 10010 {
lab=GND}
N 10 10010 10 10020 {
lab=GND}
N 70 9960 70 10010 {
lab=Y0}
N 70 10010 70 10020 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 9990 1 0 {name=M685
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 9970 120 9970 {
lab=word166}
N 120 9970 160 9970 {
lab=word166}
N 90 9960 90 10010 {
lab=GND}
N 90 10010 90 10020 {
lab=GND}
N 150 9960 150 10010 {
lab=Y1}
N 150 10010 150 10020 {
lab=Y1}
N 160 9970 200 9970 {
lab=word166}
N 200 9970 240 9970 {
lab=word166}
N 170 9960 170 10010 {
lab=GND}
N 170 10010 170 10020 {
lab=GND}
N 230 9960 230 10010 {
lab=Y2}
N 230 10010 230 10020 {
lab=Y2}

N 250 10020 280 10020 {
lab=GND}
N 280 10010 280 10020 {
lab=GND}
N 240 9970 280 9970 {
lab=word166}
N 280 9970 320 9970 {
lab=word166}
N 250 9960 250 10010 {
lab=GND}
N 250 10010 250 10020 {
lab=GND}
N 310 9960 310 10010 {
lab=Y3}
N 310 10010 310 10020 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 9990 1 0 {name=M686
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 9970 360 9970 {
lab=word166}
N 360 9970 400 9970 {
lab=word166}
N 330 9960 330 10010 {
lab=GND}
N 330 10010 330 10020 {
lab=GND}
N 390 9960 390 10010 {
lab=Y4}
N 390 10010 390 10020 {
lab=Y4}

N 410 10020 440 10020 {
lab=GND}
N 440 10010 440 10020 {
lab=GND}
N 400 9970 440 9970 {
lab=word166}
N 440 9970 480 9970 {
lab=word166}
N 410 9960 410 10010 {
lab=GND}
N 410 10010 410 10020 {
lab=GND}
N 470 9960 470 10010 {
lab=Y5}
N 470 10010 470 10020 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 9990 1 0 {name=M687
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 10020 520 10020 {
lab=GND}
N 520 10010 520 10020 {
lab=GND}
N 480 9970 520 9970 {
lab=word166}
N 520 9970 560 9970 {
lab=word166}
N 490 9960 490 10010 {
lab=GND}
N 490 10010 490 10020 {
lab=GND}
N 550 9960 550 10010 {
lab=Y6}
N 550 10010 550 10020 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 9990 1 0 {name=M688
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10020 600 10020 {
lab=GND}
N 600 10010 600 10020 {
lab=GND}
N 560 9970 600 9970 {
lab=word166}
N 600 9970 640 9970 {
lab=word166}
N 570 9960 570 10010 {
lab=GND}
N 570 10010 570 10020 {
lab=GND}
N 630 9960 630 10010 {
lab=Y7}
N 630 10010 630 10020 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 9990 1 0 {name=M689
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10030 0 0 {name=p190 lab=word167}

N 10 10080 40 10080 {
lab=GND}
N 40 10070 40 10080 {
lab=GND}
N 0 10030 40 10030 {
lab=word167}
N 40 10030 80 10030 {
lab=word167}
N 10 10020 10 10070 {
lab=GND}
N 10 10070 10 10080 {
lab=GND}
N 70 10020 70 10070 {
lab=Y0}
N 70 10070 70 10080 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10050 1 0 {name=M690
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 10030 120 10030 {
lab=word167}
N 120 10030 160 10030 {
lab=word167}
N 90 10020 90 10070 {
lab=GND}
N 90 10070 90 10080 {
lab=GND}
N 150 10020 150 10070 {
lab=Y1}
N 150 10070 150 10080 {
lab=Y1}
N 160 10030 200 10030 {
lab=word167}
N 200 10030 240 10030 {
lab=word167}
N 170 10020 170 10070 {
lab=GND}
N 170 10070 170 10080 {
lab=GND}
N 230 10020 230 10070 {
lab=Y2}
N 230 10070 230 10080 {
lab=Y2}

N 250 10080 280 10080 {
lab=GND}
N 280 10070 280 10080 {
lab=GND}
N 240 10030 280 10030 {
lab=word167}
N 280 10030 320 10030 {
lab=word167}
N 250 10020 250 10070 {
lab=GND}
N 250 10070 250 10080 {
lab=GND}
N 310 10020 310 10070 {
lab=Y3}
N 310 10070 310 10080 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 10050 1 0 {name=M691
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 10080 360 10080 {
lab=GND}
N 360 10070 360 10080 {
lab=GND}
N 320 10030 360 10030 {
lab=word167}
N 360 10030 400 10030 {
lab=word167}
N 330 10020 330 10070 {
lab=GND}
N 330 10070 330 10080 {
lab=GND}
N 390 10020 390 10070 {
lab=Y4}
N 390 10070 390 10080 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 10050 1 0 {name=M692
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 10030 440 10030 {
lab=word167}
N 440 10030 480 10030 {
lab=word167}
N 410 10020 410 10070 {
lab=GND}
N 410 10070 410 10080 {
lab=GND}
N 470 10020 470 10070 {
lab=Y5}
N 470 10070 470 10080 {
lab=Y5}

N 490 10080 520 10080 {
lab=GND}
N 520 10070 520 10080 {
lab=GND}
N 480 10030 520 10030 {
lab=word167}
N 520 10030 560 10030 {
lab=word167}
N 490 10020 490 10070 {
lab=GND}
N 490 10070 490 10080 {
lab=GND}
N 550 10020 550 10070 {
lab=Y6}
N 550 10070 550 10080 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10050 1 0 {name=M693
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10080 600 10080 {
lab=GND}
N 600 10070 600 10080 {
lab=GND}
N 560 10030 600 10030 {
lab=word167}
N 600 10030 640 10030 {
lab=word167}
N 570 10020 570 10070 {
lab=GND}
N 570 10070 570 10080 {
lab=GND}
N 630 10020 630 10070 {
lab=Y7}
N 630 10070 630 10080 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10050 1 0 {name=M694
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10090 0 0 {name=p191 lab=word168}

N 10 10140 40 10140 {
lab=GND}
N 40 10130 40 10140 {
lab=GND}
N 0 10090 40 10090 {
lab=word168}
N 40 10090 80 10090 {
lab=word168}
N 10 10080 10 10130 {
lab=GND}
N 10 10130 10 10140 {
lab=GND}
N 70 10080 70 10130 {
lab=Y0}
N 70 10130 70 10140 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10110 1 0 {name=M695
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 10090 120 10090 {
lab=word168}
N 120 10090 160 10090 {
lab=word168}
N 90 10080 90 10130 {
lab=GND}
N 90 10130 90 10140 {
lab=GND}
N 150 10080 150 10130 {
lab=Y1}
N 150 10130 150 10140 {
lab=Y1}
N 160 10090 200 10090 {
lab=word168}
N 200 10090 240 10090 {
lab=word168}
N 170 10080 170 10130 {
lab=GND}
N 170 10130 170 10140 {
lab=GND}
N 230 10080 230 10130 {
lab=Y2}
N 230 10130 230 10140 {
lab=Y2}

N 250 10140 280 10140 {
lab=GND}
N 280 10130 280 10140 {
lab=GND}
N 240 10090 280 10090 {
lab=word168}
N 280 10090 320 10090 {
lab=word168}
N 250 10080 250 10130 {
lab=GND}
N 250 10130 250 10140 {
lab=GND}
N 310 10080 310 10130 {
lab=Y3}
N 310 10130 310 10140 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 10110 1 0 {name=M696
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 10140 360 10140 {
lab=GND}
N 360 10130 360 10140 {
lab=GND}
N 320 10090 360 10090 {
lab=word168}
N 360 10090 400 10090 {
lab=word168}
N 330 10080 330 10130 {
lab=GND}
N 330 10130 330 10140 {
lab=GND}
N 390 10080 390 10130 {
lab=Y4}
N 390 10130 390 10140 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 10110 1 0 {name=M697
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 10140 440 10140 {
lab=GND}
N 440 10130 440 10140 {
lab=GND}
N 400 10090 440 10090 {
lab=word168}
N 440 10090 480 10090 {
lab=word168}
N 410 10080 410 10130 {
lab=GND}
N 410 10130 410 10140 {
lab=GND}
N 470 10080 470 10130 {
lab=Y5}
N 470 10130 470 10140 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 10110 1 0 {name=M698
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 10140 520 10140 {
lab=GND}
N 520 10130 520 10140 {
lab=GND}
N 480 10090 520 10090 {
lab=word168}
N 520 10090 560 10090 {
lab=word168}
N 490 10080 490 10130 {
lab=GND}
N 490 10130 490 10140 {
lab=GND}
N 550 10080 550 10130 {
lab=Y6}
N 550 10130 550 10140 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10110 1 0 {name=M699
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10140 600 10140 {
lab=GND}
N 600 10130 600 10140 {
lab=GND}
N 560 10090 600 10090 {
lab=word168}
N 600 10090 640 10090 {
lab=word168}
N 570 10080 570 10130 {
lab=GND}
N 570 10130 570 10140 {
lab=GND}
N 630 10080 630 10130 {
lab=Y7}
N 630 10130 630 10140 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10110 1 0 {name=M700
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10150 0 0 {name=p192 lab=word169}

N 10 10200 40 10200 {
lab=GND}
N 40 10190 40 10200 {
lab=GND}
N 0 10150 40 10150 {
lab=word169}
N 40 10150 80 10150 {
lab=word169}
N 10 10140 10 10190 {
lab=GND}
N 10 10190 10 10200 {
lab=GND}
N 70 10140 70 10190 {
lab=Y0}
N 70 10190 70 10200 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10170 1 0 {name=M701
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 10150 120 10150 {
lab=word169}
N 120 10150 160 10150 {
lab=word169}
N 90 10140 90 10190 {
lab=GND}
N 90 10190 90 10200 {
lab=GND}
N 150 10140 150 10190 {
lab=Y1}
N 150 10190 150 10200 {
lab=Y1}

N 170 10200 200 10200 {
lab=GND}
N 200 10190 200 10200 {
lab=GND}
N 160 10150 200 10150 {
lab=word169}
N 200 10150 240 10150 {
lab=word169}
N 170 10140 170 10190 {
lab=GND}
N 170 10190 170 10200 {
lab=GND}
N 230 10140 230 10190 {
lab=Y2}
N 230 10190 230 10200 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 10170 1 0 {name=M702
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 10150 280 10150 {
lab=word169}
N 280 10150 320 10150 {
lab=word169}
N 250 10140 250 10190 {
lab=GND}
N 250 10190 250 10200 {
lab=GND}
N 310 10140 310 10190 {
lab=Y3}
N 310 10190 310 10200 {
lab=Y3}
N 320 10150 360 10150 {
lab=word169}
N 360 10150 400 10150 {
lab=word169}
N 330 10140 330 10190 {
lab=GND}
N 330 10190 330 10200 {
lab=GND}
N 390 10140 390 10190 {
lab=Y4}
N 390 10190 390 10200 {
lab=Y4}
N 400 10150 440 10150 {
lab=word169}
N 440 10150 480 10150 {
lab=word169}
N 410 10140 410 10190 {
lab=GND}
N 410 10190 410 10200 {
lab=GND}
N 470 10140 470 10190 {
lab=Y5}
N 470 10190 470 10200 {
lab=Y5}

N 490 10200 520 10200 {
lab=GND}
N 520 10190 520 10200 {
lab=GND}
N 480 10150 520 10150 {
lab=word169}
N 520 10150 560 10150 {
lab=word169}
N 490 10140 490 10190 {
lab=GND}
N 490 10190 490 10200 {
lab=GND}
N 550 10140 550 10190 {
lab=Y6}
N 550 10190 550 10200 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10170 1 0 {name=M703
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10200 600 10200 {
lab=GND}
N 600 10190 600 10200 {
lab=GND}
N 560 10150 600 10150 {
lab=word169}
N 600 10150 640 10150 {
lab=word169}
N 570 10140 570 10190 {
lab=GND}
N 570 10190 570 10200 {
lab=GND}
N 630 10140 630 10190 {
lab=Y7}
N 630 10190 630 10200 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10170 1 0 {name=M704
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10210 0 0 {name=p193 lab=word170}

N 10 10260 40 10260 {
lab=GND}
N 40 10250 40 10260 {
lab=GND}
N 0 10210 40 10210 {
lab=word170}
N 40 10210 80 10210 {
lab=word170}
N 10 10200 10 10250 {
lab=GND}
N 10 10250 10 10260 {
lab=GND}
N 70 10200 70 10250 {
lab=Y0}
N 70 10250 70 10260 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10230 1 0 {name=M705
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 10210 120 10210 {
lab=word170}
N 120 10210 160 10210 {
lab=word170}
N 90 10200 90 10250 {
lab=GND}
N 90 10250 90 10260 {
lab=GND}
N 150 10200 150 10250 {
lab=Y1}
N 150 10250 150 10260 {
lab=Y1}

N 170 10260 200 10260 {
lab=GND}
N 200 10250 200 10260 {
lab=GND}
N 160 10210 200 10210 {
lab=word170}
N 200 10210 240 10210 {
lab=word170}
N 170 10200 170 10250 {
lab=GND}
N 170 10250 170 10260 {
lab=GND}
N 230 10200 230 10250 {
lab=Y2}
N 230 10250 230 10260 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 10230 1 0 {name=M706
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 10210 280 10210 {
lab=word170}
N 280 10210 320 10210 {
lab=word170}
N 250 10200 250 10250 {
lab=GND}
N 250 10250 250 10260 {
lab=GND}
N 310 10200 310 10250 {
lab=Y3}
N 310 10250 310 10260 {
lab=Y3}
N 320 10210 360 10210 {
lab=word170}
N 360 10210 400 10210 {
lab=word170}
N 330 10200 330 10250 {
lab=GND}
N 330 10250 330 10260 {
lab=GND}
N 390 10200 390 10250 {
lab=Y4}
N 390 10250 390 10260 {
lab=Y4}

N 410 10260 440 10260 {
lab=GND}
N 440 10250 440 10260 {
lab=GND}
N 400 10210 440 10210 {
lab=word170}
N 440 10210 480 10210 {
lab=word170}
N 410 10200 410 10250 {
lab=GND}
N 410 10250 410 10260 {
lab=GND}
N 470 10200 470 10250 {
lab=Y5}
N 470 10250 470 10260 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 10230 1 0 {name=M707
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 10260 520 10260 {
lab=GND}
N 520 10250 520 10260 {
lab=GND}
N 480 10210 520 10210 {
lab=word170}
N 520 10210 560 10210 {
lab=word170}
N 490 10200 490 10250 {
lab=GND}
N 490 10250 490 10260 {
lab=GND}
N 550 10200 550 10250 {
lab=Y6}
N 550 10250 550 10260 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10230 1 0 {name=M708
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10260 600 10260 {
lab=GND}
N 600 10250 600 10260 {
lab=GND}
N 560 10210 600 10210 {
lab=word170}
N 600 10210 640 10210 {
lab=word170}
N 570 10200 570 10250 {
lab=GND}
N 570 10250 570 10260 {
lab=GND}
N 630 10200 630 10250 {
lab=Y7}
N 630 10250 630 10260 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10230 1 0 {name=M709
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10270 0 0 {name=p194 lab=word171}

N 10 10320 40 10320 {
lab=GND}
N 40 10310 40 10320 {
lab=GND}
N 0 10270 40 10270 {
lab=word171}
N 40 10270 80 10270 {
lab=word171}
N 10 10260 10 10310 {
lab=GND}
N 10 10310 10 10320 {
lab=GND}
N 70 10260 70 10310 {
lab=Y0}
N 70 10310 70 10320 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10290 1 0 {name=M710
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 10270 120 10270 {
lab=word171}
N 120 10270 160 10270 {
lab=word171}
N 90 10260 90 10310 {
lab=GND}
N 90 10310 90 10320 {
lab=GND}
N 150 10260 150 10310 {
lab=Y1}
N 150 10310 150 10320 {
lab=Y1}

N 170 10320 200 10320 {
lab=GND}
N 200 10310 200 10320 {
lab=GND}
N 160 10270 200 10270 {
lab=word171}
N 200 10270 240 10270 {
lab=word171}
N 170 10260 170 10310 {
lab=GND}
N 170 10310 170 10320 {
lab=GND}
N 230 10260 230 10310 {
lab=Y2}
N 230 10310 230 10320 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 10290 1 0 {name=M711
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 10270 280 10270 {
lab=word171}
N 280 10270 320 10270 {
lab=word171}
N 250 10260 250 10310 {
lab=GND}
N 250 10310 250 10320 {
lab=GND}
N 310 10260 310 10310 {
lab=Y3}
N 310 10310 310 10320 {
lab=Y3}

N 330 10320 360 10320 {
lab=GND}
N 360 10310 360 10320 {
lab=GND}
N 320 10270 360 10270 {
lab=word171}
N 360 10270 400 10270 {
lab=word171}
N 330 10260 330 10310 {
lab=GND}
N 330 10310 330 10320 {
lab=GND}
N 390 10260 390 10310 {
lab=Y4}
N 390 10310 390 10320 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 10290 1 0 {name=M712
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 10270 440 10270 {
lab=word171}
N 440 10270 480 10270 {
lab=word171}
N 410 10260 410 10310 {
lab=GND}
N 410 10310 410 10320 {
lab=GND}
N 470 10260 470 10310 {
lab=Y5}
N 470 10310 470 10320 {
lab=Y5}

N 490 10320 520 10320 {
lab=GND}
N 520 10310 520 10320 {
lab=GND}
N 480 10270 520 10270 {
lab=word171}
N 520 10270 560 10270 {
lab=word171}
N 490 10260 490 10310 {
lab=GND}
N 490 10310 490 10320 {
lab=GND}
N 550 10260 550 10310 {
lab=Y6}
N 550 10310 550 10320 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10290 1 0 {name=M713
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10320 600 10320 {
lab=GND}
N 600 10310 600 10320 {
lab=GND}
N 560 10270 600 10270 {
lab=word171}
N 600 10270 640 10270 {
lab=word171}
N 570 10260 570 10310 {
lab=GND}
N 570 10310 570 10320 {
lab=GND}
N 630 10260 630 10310 {
lab=Y7}
N 630 10310 630 10320 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10290 1 0 {name=M714
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10330 0 0 {name=p195 lab=word172}

N 10 10380 40 10380 {
lab=GND}
N 40 10370 40 10380 {
lab=GND}
N 0 10330 40 10330 {
lab=word172}
N 40 10330 80 10330 {
lab=word172}
N 10 10320 10 10370 {
lab=GND}
N 10 10370 10 10380 {
lab=GND}
N 70 10320 70 10370 {
lab=Y0}
N 70 10370 70 10380 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10350 1 0 {name=M715
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 10330 120 10330 {
lab=word172}
N 120 10330 160 10330 {
lab=word172}
N 90 10320 90 10370 {
lab=GND}
N 90 10370 90 10380 {
lab=GND}
N 150 10320 150 10370 {
lab=Y1}
N 150 10370 150 10380 {
lab=Y1}

N 170 10380 200 10380 {
lab=GND}
N 200 10370 200 10380 {
lab=GND}
N 160 10330 200 10330 {
lab=word172}
N 200 10330 240 10330 {
lab=word172}
N 170 10320 170 10370 {
lab=GND}
N 170 10370 170 10380 {
lab=GND}
N 230 10320 230 10370 {
lab=Y2}
N 230 10370 230 10380 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 10350 1 0 {name=M716
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 10330 280 10330 {
lab=word172}
N 280 10330 320 10330 {
lab=word172}
N 250 10320 250 10370 {
lab=GND}
N 250 10370 250 10380 {
lab=GND}
N 310 10320 310 10370 {
lab=Y3}
N 310 10370 310 10380 {
lab=Y3}

N 330 10380 360 10380 {
lab=GND}
N 360 10370 360 10380 {
lab=GND}
N 320 10330 360 10330 {
lab=word172}
N 360 10330 400 10330 {
lab=word172}
N 330 10320 330 10370 {
lab=GND}
N 330 10370 330 10380 {
lab=GND}
N 390 10320 390 10370 {
lab=Y4}
N 390 10370 390 10380 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 10350 1 0 {name=M717
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 10380 440 10380 {
lab=GND}
N 440 10370 440 10380 {
lab=GND}
N 400 10330 440 10330 {
lab=word172}
N 440 10330 480 10330 {
lab=word172}
N 410 10320 410 10370 {
lab=GND}
N 410 10370 410 10380 {
lab=GND}
N 470 10320 470 10370 {
lab=Y5}
N 470 10370 470 10380 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 10350 1 0 {name=M718
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 10380 520 10380 {
lab=GND}
N 520 10370 520 10380 {
lab=GND}
N 480 10330 520 10330 {
lab=word172}
N 520 10330 560 10330 {
lab=word172}
N 490 10320 490 10370 {
lab=GND}
N 490 10370 490 10380 {
lab=GND}
N 550 10320 550 10370 {
lab=Y6}
N 550 10370 550 10380 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10350 1 0 {name=M719
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10380 600 10380 {
lab=GND}
N 600 10370 600 10380 {
lab=GND}
N 560 10330 600 10330 {
lab=word172}
N 600 10330 640 10330 {
lab=word172}
N 570 10320 570 10370 {
lab=GND}
N 570 10370 570 10380 {
lab=GND}
N 630 10320 630 10370 {
lab=Y7}
N 630 10370 630 10380 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10350 1 0 {name=M720
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10390 0 0 {name=p196 lab=word173}

N 10 10440 40 10440 {
lab=GND}
N 40 10430 40 10440 {
lab=GND}
N 0 10390 40 10390 {
lab=word173}
N 40 10390 80 10390 {
lab=word173}
N 10 10380 10 10430 {
lab=GND}
N 10 10430 10 10440 {
lab=GND}
N 70 10380 70 10430 {
lab=Y0}
N 70 10430 70 10440 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10410 1 0 {name=M721
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 10390 120 10390 {
lab=word173}
N 120 10390 160 10390 {
lab=word173}
N 90 10380 90 10430 {
lab=GND}
N 90 10430 90 10440 {
lab=GND}
N 150 10380 150 10430 {
lab=Y1}
N 150 10430 150 10440 {
lab=Y1}

N 170 10440 200 10440 {
lab=GND}
N 200 10430 200 10440 {
lab=GND}
N 160 10390 200 10390 {
lab=word173}
N 200 10390 240 10390 {
lab=word173}
N 170 10380 170 10430 {
lab=GND}
N 170 10430 170 10440 {
lab=GND}
N 230 10380 230 10430 {
lab=Y2}
N 230 10430 230 10440 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 10410 1 0 {name=M722
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 10440 280 10440 {
lab=GND}
N 280 10430 280 10440 {
lab=GND}
N 240 10390 280 10390 {
lab=word173}
N 280 10390 320 10390 {
lab=word173}
N 250 10380 250 10430 {
lab=GND}
N 250 10430 250 10440 {
lab=GND}
N 310 10380 310 10430 {
lab=Y3}
N 310 10430 310 10440 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 10410 1 0 {name=M723
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 10390 360 10390 {
lab=word173}
N 360 10390 400 10390 {
lab=word173}
N 330 10380 330 10430 {
lab=GND}
N 330 10430 330 10440 {
lab=GND}
N 390 10380 390 10430 {
lab=Y4}
N 390 10430 390 10440 {
lab=Y4}
N 400 10390 440 10390 {
lab=word173}
N 440 10390 480 10390 {
lab=word173}
N 410 10380 410 10430 {
lab=GND}
N 410 10430 410 10440 {
lab=GND}
N 470 10380 470 10430 {
lab=Y5}
N 470 10430 470 10440 {
lab=Y5}

N 490 10440 520 10440 {
lab=GND}
N 520 10430 520 10440 {
lab=GND}
N 480 10390 520 10390 {
lab=word173}
N 520 10390 560 10390 {
lab=word173}
N 490 10380 490 10430 {
lab=GND}
N 490 10430 490 10440 {
lab=GND}
N 550 10380 550 10430 {
lab=Y6}
N 550 10430 550 10440 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10410 1 0 {name=M724
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10440 600 10440 {
lab=GND}
N 600 10430 600 10440 {
lab=GND}
N 560 10390 600 10390 {
lab=word173}
N 600 10390 640 10390 {
lab=word173}
N 570 10380 570 10430 {
lab=GND}
N 570 10430 570 10440 {
lab=GND}
N 630 10380 630 10430 {
lab=Y7}
N 630 10430 630 10440 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10410 1 0 {name=M725
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10450 0 0 {name=p197 lab=word174}

N 10 10500 40 10500 {
lab=GND}
N 40 10490 40 10500 {
lab=GND}
N 0 10450 40 10450 {
lab=word174}
N 40 10450 80 10450 {
lab=word174}
N 10 10440 10 10490 {
lab=GND}
N 10 10490 10 10500 {
lab=GND}
N 70 10440 70 10490 {
lab=Y0}
N 70 10490 70 10500 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10470 1 0 {name=M726
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 10450 120 10450 {
lab=word174}
N 120 10450 160 10450 {
lab=word174}
N 90 10440 90 10490 {
lab=GND}
N 90 10490 90 10500 {
lab=GND}
N 150 10440 150 10490 {
lab=Y1}
N 150 10490 150 10500 {
lab=Y1}

N 170 10500 200 10500 {
lab=GND}
N 200 10490 200 10500 {
lab=GND}
N 160 10450 200 10450 {
lab=word174}
N 200 10450 240 10450 {
lab=word174}
N 170 10440 170 10490 {
lab=GND}
N 170 10490 170 10500 {
lab=GND}
N 230 10440 230 10490 {
lab=Y2}
N 230 10490 230 10500 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 10470 1 0 {name=M727
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 10500 280 10500 {
lab=GND}
N 280 10490 280 10500 {
lab=GND}
N 240 10450 280 10450 {
lab=word174}
N 280 10450 320 10450 {
lab=word174}
N 250 10440 250 10490 {
lab=GND}
N 250 10490 250 10500 {
lab=GND}
N 310 10440 310 10490 {
lab=Y3}
N 310 10490 310 10500 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 10470 1 0 {name=M728
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 10450 360 10450 {
lab=word174}
N 360 10450 400 10450 {
lab=word174}
N 330 10440 330 10490 {
lab=GND}
N 330 10490 330 10500 {
lab=GND}
N 390 10440 390 10490 {
lab=Y4}
N 390 10490 390 10500 {
lab=Y4}

N 410 10500 440 10500 {
lab=GND}
N 440 10490 440 10500 {
lab=GND}
N 400 10450 440 10450 {
lab=word174}
N 440 10450 480 10450 {
lab=word174}
N 410 10440 410 10490 {
lab=GND}
N 410 10490 410 10500 {
lab=GND}
N 470 10440 470 10490 {
lab=Y5}
N 470 10490 470 10500 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 10470 1 0 {name=M729
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 10500 520 10500 {
lab=GND}
N 520 10490 520 10500 {
lab=GND}
N 480 10450 520 10450 {
lab=word174}
N 520 10450 560 10450 {
lab=word174}
N 490 10440 490 10490 {
lab=GND}
N 490 10490 490 10500 {
lab=GND}
N 550 10440 550 10490 {
lab=Y6}
N 550 10490 550 10500 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10470 1 0 {name=M730
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10500 600 10500 {
lab=GND}
N 600 10490 600 10500 {
lab=GND}
N 560 10450 600 10450 {
lab=word174}
N 600 10450 640 10450 {
lab=word174}
N 570 10440 570 10490 {
lab=GND}
N 570 10490 570 10500 {
lab=GND}
N 630 10440 630 10490 {
lab=Y7}
N 630 10490 630 10500 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10470 1 0 {name=M731
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10510 0 0 {name=p198 lab=word175}

N 10 10560 40 10560 {
lab=GND}
N 40 10550 40 10560 {
lab=GND}
N 0 10510 40 10510 {
lab=word175}
N 40 10510 80 10510 {
lab=word175}
N 10 10500 10 10550 {
lab=GND}
N 10 10550 10 10560 {
lab=GND}
N 70 10500 70 10550 {
lab=Y0}
N 70 10550 70 10560 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10530 1 0 {name=M732
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 10510 120 10510 {
lab=word175}
N 120 10510 160 10510 {
lab=word175}
N 90 10500 90 10550 {
lab=GND}
N 90 10550 90 10560 {
lab=GND}
N 150 10500 150 10550 {
lab=Y1}
N 150 10550 150 10560 {
lab=Y1}

N 170 10560 200 10560 {
lab=GND}
N 200 10550 200 10560 {
lab=GND}
N 160 10510 200 10510 {
lab=word175}
N 200 10510 240 10510 {
lab=word175}
N 170 10500 170 10550 {
lab=GND}
N 170 10550 170 10560 {
lab=GND}
N 230 10500 230 10550 {
lab=Y2}
N 230 10550 230 10560 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 10530 1 0 {name=M733
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 10560 280 10560 {
lab=GND}
N 280 10550 280 10560 {
lab=GND}
N 240 10510 280 10510 {
lab=word175}
N 280 10510 320 10510 {
lab=word175}
N 250 10500 250 10550 {
lab=GND}
N 250 10550 250 10560 {
lab=GND}
N 310 10500 310 10550 {
lab=Y3}
N 310 10550 310 10560 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 10530 1 0 {name=M734
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 10560 360 10560 {
lab=GND}
N 360 10550 360 10560 {
lab=GND}
N 320 10510 360 10510 {
lab=word175}
N 360 10510 400 10510 {
lab=word175}
N 330 10500 330 10550 {
lab=GND}
N 330 10550 330 10560 {
lab=GND}
N 390 10500 390 10550 {
lab=Y4}
N 390 10550 390 10560 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 10530 1 0 {name=M735
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 10510 440 10510 {
lab=word175}
N 440 10510 480 10510 {
lab=word175}
N 410 10500 410 10550 {
lab=GND}
N 410 10550 410 10560 {
lab=GND}
N 470 10500 470 10550 {
lab=Y5}
N 470 10550 470 10560 {
lab=Y5}

N 490 10560 520 10560 {
lab=GND}
N 520 10550 520 10560 {
lab=GND}
N 480 10510 520 10510 {
lab=word175}
N 520 10510 560 10510 {
lab=word175}
N 490 10500 490 10550 {
lab=GND}
N 490 10550 490 10560 {
lab=GND}
N 550 10500 550 10550 {
lab=Y6}
N 550 10550 550 10560 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10530 1 0 {name=M736
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10560 600 10560 {
lab=GND}
N 600 10550 600 10560 {
lab=GND}
N 560 10510 600 10510 {
lab=word175}
N 600 10510 640 10510 {
lab=word175}
N 570 10500 570 10550 {
lab=GND}
N 570 10550 570 10560 {
lab=GND}
N 630 10500 630 10550 {
lab=Y7}
N 630 10550 630 10560 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10530 1 0 {name=M737
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10570 0 0 {name=p199 lab=word176}

N 10 10620 40 10620 {
lab=GND}
N 40 10610 40 10620 {
lab=GND}
N 0 10570 40 10570 {
lab=word176}
N 40 10570 80 10570 {
lab=word176}
N 10 10560 10 10610 {
lab=GND}
N 10 10610 10 10620 {
lab=GND}
N 70 10560 70 10610 {
lab=Y0}
N 70 10610 70 10620 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10590 1 0 {name=M738
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 10570 120 10570 {
lab=word176}
N 120 10570 160 10570 {
lab=word176}
N 90 10560 90 10610 {
lab=GND}
N 90 10610 90 10620 {
lab=GND}
N 150 10560 150 10610 {
lab=Y1}
N 150 10610 150 10620 {
lab=Y1}

N 170 10620 200 10620 {
lab=GND}
N 200 10610 200 10620 {
lab=GND}
N 160 10570 200 10570 {
lab=word176}
N 200 10570 240 10570 {
lab=word176}
N 170 10560 170 10610 {
lab=GND}
N 170 10610 170 10620 {
lab=GND}
N 230 10560 230 10610 {
lab=Y2}
N 230 10610 230 10620 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 10590 1 0 {name=M739
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 10620 280 10620 {
lab=GND}
N 280 10610 280 10620 {
lab=GND}
N 240 10570 280 10570 {
lab=word176}
N 280 10570 320 10570 {
lab=word176}
N 250 10560 250 10610 {
lab=GND}
N 250 10610 250 10620 {
lab=GND}
N 310 10560 310 10610 {
lab=Y3}
N 310 10610 310 10620 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 10590 1 0 {name=M740
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 10620 360 10620 {
lab=GND}
N 360 10610 360 10620 {
lab=GND}
N 320 10570 360 10570 {
lab=word176}
N 360 10570 400 10570 {
lab=word176}
N 330 10560 330 10610 {
lab=GND}
N 330 10610 330 10620 {
lab=GND}
N 390 10560 390 10610 {
lab=Y4}
N 390 10610 390 10620 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 10590 1 0 {name=M741
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 10620 440 10620 {
lab=GND}
N 440 10610 440 10620 {
lab=GND}
N 400 10570 440 10570 {
lab=word176}
N 440 10570 480 10570 {
lab=word176}
N 410 10560 410 10610 {
lab=GND}
N 410 10610 410 10620 {
lab=GND}
N 470 10560 470 10610 {
lab=Y5}
N 470 10610 470 10620 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 10590 1 0 {name=M742
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 10620 520 10620 {
lab=GND}
N 520 10610 520 10620 {
lab=GND}
N 480 10570 520 10570 {
lab=word176}
N 520 10570 560 10570 {
lab=word176}
N 490 10560 490 10610 {
lab=GND}
N 490 10610 490 10620 {
lab=GND}
N 550 10560 550 10610 {
lab=Y6}
N 550 10610 550 10620 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10590 1 0 {name=M743
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10620 600 10620 {
lab=GND}
N 600 10610 600 10620 {
lab=GND}
N 560 10570 600 10570 {
lab=word176}
N 600 10570 640 10570 {
lab=word176}
N 570 10560 570 10610 {
lab=GND}
N 570 10610 570 10620 {
lab=GND}
N 630 10560 630 10610 {
lab=Y7}
N 630 10610 630 10620 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10590 1 0 {name=M744
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10630 0 0 {name=p200 lab=word177}

N 10 10680 40 10680 {
lab=GND}
N 40 10670 40 10680 {
lab=GND}
N 0 10630 40 10630 {
lab=word177}
N 40 10630 80 10630 {
lab=word177}
N 10 10620 10 10670 {
lab=GND}
N 10 10670 10 10680 {
lab=GND}
N 70 10620 70 10670 {
lab=Y0}
N 70 10670 70 10680 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10650 1 0 {name=M745
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 10680 120 10680 {
lab=GND}
N 120 10670 120 10680 {
lab=GND}
N 80 10630 120 10630 {
lab=word177}
N 120 10630 160 10630 {
lab=word177}
N 90 10620 90 10670 {
lab=GND}
N 90 10670 90 10680 {
lab=GND}
N 150 10620 150 10670 {
lab=Y1}
N 150 10670 150 10680 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 10650 1 0 {name=M746
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 10630 200 10630 {
lab=word177}
N 200 10630 240 10630 {
lab=word177}
N 170 10620 170 10670 {
lab=GND}
N 170 10670 170 10680 {
lab=GND}
N 230 10620 230 10670 {
lab=Y2}
N 230 10670 230 10680 {
lab=Y2}
N 240 10630 280 10630 {
lab=word177}
N 280 10630 320 10630 {
lab=word177}
N 250 10620 250 10670 {
lab=GND}
N 250 10670 250 10680 {
lab=GND}
N 310 10620 310 10670 {
lab=Y3}
N 310 10670 310 10680 {
lab=Y3}
N 320 10630 360 10630 {
lab=word177}
N 360 10630 400 10630 {
lab=word177}
N 330 10620 330 10670 {
lab=GND}
N 330 10670 330 10680 {
lab=GND}
N 390 10620 390 10670 {
lab=Y4}
N 390 10670 390 10680 {
lab=Y4}
N 400 10630 440 10630 {
lab=word177}
N 440 10630 480 10630 {
lab=word177}
N 410 10620 410 10670 {
lab=GND}
N 410 10670 410 10680 {
lab=GND}
N 470 10620 470 10670 {
lab=Y5}
N 470 10670 470 10680 {
lab=Y5}

N 490 10680 520 10680 {
lab=GND}
N 520 10670 520 10680 {
lab=GND}
N 480 10630 520 10630 {
lab=word177}
N 520 10630 560 10630 {
lab=word177}
N 490 10620 490 10670 {
lab=GND}
N 490 10670 490 10680 {
lab=GND}
N 550 10620 550 10670 {
lab=Y6}
N 550 10670 550 10680 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10650 1 0 {name=M747
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10680 600 10680 {
lab=GND}
N 600 10670 600 10680 {
lab=GND}
N 560 10630 600 10630 {
lab=word177}
N 600 10630 640 10630 {
lab=word177}
N 570 10620 570 10670 {
lab=GND}
N 570 10670 570 10680 {
lab=GND}
N 630 10620 630 10670 {
lab=Y7}
N 630 10670 630 10680 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10650 1 0 {name=M748
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10690 0 0 {name=p201 lab=word178}

N 10 10740 40 10740 {
lab=GND}
N 40 10730 40 10740 {
lab=GND}
N 0 10690 40 10690 {
lab=word178}
N 40 10690 80 10690 {
lab=word178}
N 10 10680 10 10730 {
lab=GND}
N 10 10730 10 10740 {
lab=GND}
N 70 10680 70 10730 {
lab=Y0}
N 70 10730 70 10740 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10710 1 0 {name=M749
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 10740 120 10740 {
lab=GND}
N 120 10730 120 10740 {
lab=GND}
N 80 10690 120 10690 {
lab=word178}
N 120 10690 160 10690 {
lab=word178}
N 90 10680 90 10730 {
lab=GND}
N 90 10730 90 10740 {
lab=GND}
N 150 10680 150 10730 {
lab=Y1}
N 150 10730 150 10740 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 10710 1 0 {name=M750
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 10690 200 10690 {
lab=word178}
N 200 10690 240 10690 {
lab=word178}
N 170 10680 170 10730 {
lab=GND}
N 170 10730 170 10740 {
lab=GND}
N 230 10680 230 10730 {
lab=Y2}
N 230 10730 230 10740 {
lab=Y2}
N 240 10690 280 10690 {
lab=word178}
N 280 10690 320 10690 {
lab=word178}
N 250 10680 250 10730 {
lab=GND}
N 250 10730 250 10740 {
lab=GND}
N 310 10680 310 10730 {
lab=Y3}
N 310 10730 310 10740 {
lab=Y3}
N 320 10690 360 10690 {
lab=word178}
N 360 10690 400 10690 {
lab=word178}
N 330 10680 330 10730 {
lab=GND}
N 330 10730 330 10740 {
lab=GND}
N 390 10680 390 10730 {
lab=Y4}
N 390 10730 390 10740 {
lab=Y4}

N 410 10740 440 10740 {
lab=GND}
N 440 10730 440 10740 {
lab=GND}
N 400 10690 440 10690 {
lab=word178}
N 440 10690 480 10690 {
lab=word178}
N 410 10680 410 10730 {
lab=GND}
N 410 10730 410 10740 {
lab=GND}
N 470 10680 470 10730 {
lab=Y5}
N 470 10730 470 10740 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 10710 1 0 {name=M751
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 10740 520 10740 {
lab=GND}
N 520 10730 520 10740 {
lab=GND}
N 480 10690 520 10690 {
lab=word178}
N 520 10690 560 10690 {
lab=word178}
N 490 10680 490 10730 {
lab=GND}
N 490 10730 490 10740 {
lab=GND}
N 550 10680 550 10730 {
lab=Y6}
N 550 10730 550 10740 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10710 1 0 {name=M752
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10740 600 10740 {
lab=GND}
N 600 10730 600 10740 {
lab=GND}
N 560 10690 600 10690 {
lab=word178}
N 600 10690 640 10690 {
lab=word178}
N 570 10680 570 10730 {
lab=GND}
N 570 10730 570 10740 {
lab=GND}
N 630 10680 630 10730 {
lab=Y7}
N 630 10730 630 10740 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10710 1 0 {name=M753
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10750 0 0 {name=p202 lab=word179}

N 10 10800 40 10800 {
lab=GND}
N 40 10790 40 10800 {
lab=GND}
N 0 10750 40 10750 {
lab=word179}
N 40 10750 80 10750 {
lab=word179}
N 10 10740 10 10790 {
lab=GND}
N 10 10790 10 10800 {
lab=GND}
N 70 10740 70 10790 {
lab=Y0}
N 70 10790 70 10800 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10770 1 0 {name=M754
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 10800 120 10800 {
lab=GND}
N 120 10790 120 10800 {
lab=GND}
N 80 10750 120 10750 {
lab=word179}
N 120 10750 160 10750 {
lab=word179}
N 90 10740 90 10790 {
lab=GND}
N 90 10790 90 10800 {
lab=GND}
N 150 10740 150 10790 {
lab=Y1}
N 150 10790 150 10800 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 10770 1 0 {name=M755
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 10750 200 10750 {
lab=word179}
N 200 10750 240 10750 {
lab=word179}
N 170 10740 170 10790 {
lab=GND}
N 170 10790 170 10800 {
lab=GND}
N 230 10740 230 10790 {
lab=Y2}
N 230 10790 230 10800 {
lab=Y2}
N 240 10750 280 10750 {
lab=word179}
N 280 10750 320 10750 {
lab=word179}
N 250 10740 250 10790 {
lab=GND}
N 250 10790 250 10800 {
lab=GND}
N 310 10740 310 10790 {
lab=Y3}
N 310 10790 310 10800 {
lab=Y3}

N 330 10800 360 10800 {
lab=GND}
N 360 10790 360 10800 {
lab=GND}
N 320 10750 360 10750 {
lab=word179}
N 360 10750 400 10750 {
lab=word179}
N 330 10740 330 10790 {
lab=GND}
N 330 10790 330 10800 {
lab=GND}
N 390 10740 390 10790 {
lab=Y4}
N 390 10790 390 10800 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 10770 1 0 {name=M756
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 10750 440 10750 {
lab=word179}
N 440 10750 480 10750 {
lab=word179}
N 410 10740 410 10790 {
lab=GND}
N 410 10790 410 10800 {
lab=GND}
N 470 10740 470 10790 {
lab=Y5}
N 470 10790 470 10800 {
lab=Y5}

N 490 10800 520 10800 {
lab=GND}
N 520 10790 520 10800 {
lab=GND}
N 480 10750 520 10750 {
lab=word179}
N 520 10750 560 10750 {
lab=word179}
N 490 10740 490 10790 {
lab=GND}
N 490 10790 490 10800 {
lab=GND}
N 550 10740 550 10790 {
lab=Y6}
N 550 10790 550 10800 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10770 1 0 {name=M757
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10800 600 10800 {
lab=GND}
N 600 10790 600 10800 {
lab=GND}
N 560 10750 600 10750 {
lab=word179}
N 600 10750 640 10750 {
lab=word179}
N 570 10740 570 10790 {
lab=GND}
N 570 10790 570 10800 {
lab=GND}
N 630 10740 630 10790 {
lab=Y7}
N 630 10790 630 10800 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10770 1 0 {name=M758
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10810 0 0 {name=p203 lab=word180}

N 10 10860 40 10860 {
lab=GND}
N 40 10850 40 10860 {
lab=GND}
N 0 10810 40 10810 {
lab=word180}
N 40 10810 80 10810 {
lab=word180}
N 10 10800 10 10850 {
lab=GND}
N 10 10850 10 10860 {
lab=GND}
N 70 10800 70 10850 {
lab=Y0}
N 70 10850 70 10860 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10830 1 0 {name=M759
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 10860 120 10860 {
lab=GND}
N 120 10850 120 10860 {
lab=GND}
N 80 10810 120 10810 {
lab=word180}
N 120 10810 160 10810 {
lab=word180}
N 90 10800 90 10850 {
lab=GND}
N 90 10850 90 10860 {
lab=GND}
N 150 10800 150 10850 {
lab=Y1}
N 150 10850 150 10860 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 10830 1 0 {name=M760
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 10810 200 10810 {
lab=word180}
N 200 10810 240 10810 {
lab=word180}
N 170 10800 170 10850 {
lab=GND}
N 170 10850 170 10860 {
lab=GND}
N 230 10800 230 10850 {
lab=Y2}
N 230 10850 230 10860 {
lab=Y2}
N 240 10810 280 10810 {
lab=word180}
N 280 10810 320 10810 {
lab=word180}
N 250 10800 250 10850 {
lab=GND}
N 250 10850 250 10860 {
lab=GND}
N 310 10800 310 10850 {
lab=Y3}
N 310 10850 310 10860 {
lab=Y3}

N 330 10860 360 10860 {
lab=GND}
N 360 10850 360 10860 {
lab=GND}
N 320 10810 360 10810 {
lab=word180}
N 360 10810 400 10810 {
lab=word180}
N 330 10800 330 10850 {
lab=GND}
N 330 10850 330 10860 {
lab=GND}
N 390 10800 390 10850 {
lab=Y4}
N 390 10850 390 10860 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 10830 1 0 {name=M761
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 10860 440 10860 {
lab=GND}
N 440 10850 440 10860 {
lab=GND}
N 400 10810 440 10810 {
lab=word180}
N 440 10810 480 10810 {
lab=word180}
N 410 10800 410 10850 {
lab=GND}
N 410 10850 410 10860 {
lab=GND}
N 470 10800 470 10850 {
lab=Y5}
N 470 10850 470 10860 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 10830 1 0 {name=M762
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 10860 520 10860 {
lab=GND}
N 520 10850 520 10860 {
lab=GND}
N 480 10810 520 10810 {
lab=word180}
N 520 10810 560 10810 {
lab=word180}
N 490 10800 490 10850 {
lab=GND}
N 490 10850 490 10860 {
lab=GND}
N 550 10800 550 10850 {
lab=Y6}
N 550 10850 550 10860 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10830 1 0 {name=M763
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10860 600 10860 {
lab=GND}
N 600 10850 600 10860 {
lab=GND}
N 560 10810 600 10810 {
lab=word180}
N 600 10810 640 10810 {
lab=word180}
N 570 10800 570 10850 {
lab=GND}
N 570 10850 570 10860 {
lab=GND}
N 630 10800 630 10850 {
lab=Y7}
N 630 10850 630 10860 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10830 1 0 {name=M764
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10870 0 0 {name=p204 lab=word181}

N 10 10920 40 10920 {
lab=GND}
N 40 10910 40 10920 {
lab=GND}
N 0 10870 40 10870 {
lab=word181}
N 40 10870 80 10870 {
lab=word181}
N 10 10860 10 10910 {
lab=GND}
N 10 10910 10 10920 {
lab=GND}
N 70 10860 70 10910 {
lab=Y0}
N 70 10910 70 10920 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10890 1 0 {name=M765
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 10920 120 10920 {
lab=GND}
N 120 10910 120 10920 {
lab=GND}
N 80 10870 120 10870 {
lab=word181}
N 120 10870 160 10870 {
lab=word181}
N 90 10860 90 10910 {
lab=GND}
N 90 10910 90 10920 {
lab=GND}
N 150 10860 150 10910 {
lab=Y1}
N 150 10910 150 10920 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 10890 1 0 {name=M766
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 10870 200 10870 {
lab=word181}
N 200 10870 240 10870 {
lab=word181}
N 170 10860 170 10910 {
lab=GND}
N 170 10910 170 10920 {
lab=GND}
N 230 10860 230 10910 {
lab=Y2}
N 230 10910 230 10920 {
lab=Y2}

N 250 10920 280 10920 {
lab=GND}
N 280 10910 280 10920 {
lab=GND}
N 240 10870 280 10870 {
lab=word181}
N 280 10870 320 10870 {
lab=word181}
N 250 10860 250 10910 {
lab=GND}
N 250 10910 250 10920 {
lab=GND}
N 310 10860 310 10910 {
lab=Y3}
N 310 10910 310 10920 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 10890 1 0 {name=M767
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 10870 360 10870 {
lab=word181}
N 360 10870 400 10870 {
lab=word181}
N 330 10860 330 10910 {
lab=GND}
N 330 10910 330 10920 {
lab=GND}
N 390 10860 390 10910 {
lab=Y4}
N 390 10910 390 10920 {
lab=Y4}
N 400 10870 440 10870 {
lab=word181}
N 440 10870 480 10870 {
lab=word181}
N 410 10860 410 10910 {
lab=GND}
N 410 10910 410 10920 {
lab=GND}
N 470 10860 470 10910 {
lab=Y5}
N 470 10910 470 10920 {
lab=Y5}

N 490 10920 520 10920 {
lab=GND}
N 520 10910 520 10920 {
lab=GND}
N 480 10870 520 10870 {
lab=word181}
N 520 10870 560 10870 {
lab=word181}
N 490 10860 490 10910 {
lab=GND}
N 490 10910 490 10920 {
lab=GND}
N 550 10860 550 10910 {
lab=Y6}
N 550 10910 550 10920 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10890 1 0 {name=M768
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10920 600 10920 {
lab=GND}
N 600 10910 600 10920 {
lab=GND}
N 560 10870 600 10870 {
lab=word181}
N 600 10870 640 10870 {
lab=word181}
N 570 10860 570 10910 {
lab=GND}
N 570 10910 570 10920 {
lab=GND}
N 630 10860 630 10910 {
lab=Y7}
N 630 10910 630 10920 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10890 1 0 {name=M769
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10930 0 0 {name=p205 lab=word182}

N 10 10980 40 10980 {
lab=GND}
N 40 10970 40 10980 {
lab=GND}
N 0 10930 40 10930 {
lab=word182}
N 40 10930 80 10930 {
lab=word182}
N 10 10920 10 10970 {
lab=GND}
N 10 10970 10 10980 {
lab=GND}
N 70 10920 70 10970 {
lab=Y0}
N 70 10970 70 10980 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 10950 1 0 {name=M770
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 10980 120 10980 {
lab=GND}
N 120 10970 120 10980 {
lab=GND}
N 80 10930 120 10930 {
lab=word182}
N 120 10930 160 10930 {
lab=word182}
N 90 10920 90 10970 {
lab=GND}
N 90 10970 90 10980 {
lab=GND}
N 150 10920 150 10970 {
lab=Y1}
N 150 10970 150 10980 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 10950 1 0 {name=M771
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 10930 200 10930 {
lab=word182}
N 200 10930 240 10930 {
lab=word182}
N 170 10920 170 10970 {
lab=GND}
N 170 10970 170 10980 {
lab=GND}
N 230 10920 230 10970 {
lab=Y2}
N 230 10970 230 10980 {
lab=Y2}

N 250 10980 280 10980 {
lab=GND}
N 280 10970 280 10980 {
lab=GND}
N 240 10930 280 10930 {
lab=word182}
N 280 10930 320 10930 {
lab=word182}
N 250 10920 250 10970 {
lab=GND}
N 250 10970 250 10980 {
lab=GND}
N 310 10920 310 10970 {
lab=Y3}
N 310 10970 310 10980 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 10950 1 0 {name=M772
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 10930 360 10930 {
lab=word182}
N 360 10930 400 10930 {
lab=word182}
N 330 10920 330 10970 {
lab=GND}
N 330 10970 330 10980 {
lab=GND}
N 390 10920 390 10970 {
lab=Y4}
N 390 10970 390 10980 {
lab=Y4}

N 410 10980 440 10980 {
lab=GND}
N 440 10970 440 10980 {
lab=GND}
N 400 10930 440 10930 {
lab=word182}
N 440 10930 480 10930 {
lab=word182}
N 410 10920 410 10970 {
lab=GND}
N 410 10970 410 10980 {
lab=GND}
N 470 10920 470 10970 {
lab=Y5}
N 470 10970 470 10980 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 10950 1 0 {name=M773
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 10980 520 10980 {
lab=GND}
N 520 10970 520 10980 {
lab=GND}
N 480 10930 520 10930 {
lab=word182}
N 520 10930 560 10930 {
lab=word182}
N 490 10920 490 10970 {
lab=GND}
N 490 10970 490 10980 {
lab=GND}
N 550 10920 550 10970 {
lab=Y6}
N 550 10970 550 10980 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 10950 1 0 {name=M774
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 10980 600 10980 {
lab=GND}
N 600 10970 600 10980 {
lab=GND}
N 560 10930 600 10930 {
lab=word182}
N 600 10930 640 10930 {
lab=word182}
N 570 10920 570 10970 {
lab=GND}
N 570 10970 570 10980 {
lab=GND}
N 630 10920 630 10970 {
lab=Y7}
N 630 10970 630 10980 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 10950 1 0 {name=M775
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 10990 0 0 {name=p206 lab=word183}

N 10 11040 40 11040 {
lab=GND}
N 40 11030 40 11040 {
lab=GND}
N 0 10990 40 10990 {
lab=word183}
N 40 10990 80 10990 {
lab=word183}
N 10 10980 10 11030 {
lab=GND}
N 10 11030 10 11040 {
lab=GND}
N 70 10980 70 11030 {
lab=Y0}
N 70 11030 70 11040 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11010 1 0 {name=M776
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11040 120 11040 {
lab=GND}
N 120 11030 120 11040 {
lab=GND}
N 80 10990 120 10990 {
lab=word183}
N 120 10990 160 10990 {
lab=word183}
N 90 10980 90 11030 {
lab=GND}
N 90 11030 90 11040 {
lab=GND}
N 150 10980 150 11030 {
lab=Y1}
N 150 11030 150 11040 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11010 1 0 {name=M777
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 10990 200 10990 {
lab=word183}
N 200 10990 240 10990 {
lab=word183}
N 170 10980 170 11030 {
lab=GND}
N 170 11030 170 11040 {
lab=GND}
N 230 10980 230 11030 {
lab=Y2}
N 230 11030 230 11040 {
lab=Y2}

N 250 11040 280 11040 {
lab=GND}
N 280 11030 280 11040 {
lab=GND}
N 240 10990 280 10990 {
lab=word183}
N 280 10990 320 10990 {
lab=word183}
N 250 10980 250 11030 {
lab=GND}
N 250 11030 250 11040 {
lab=GND}
N 310 10980 310 11030 {
lab=Y3}
N 310 11030 310 11040 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 11010 1 0 {name=M778
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 11040 360 11040 {
lab=GND}
N 360 11030 360 11040 {
lab=GND}
N 320 10990 360 10990 {
lab=word183}
N 360 10990 400 10990 {
lab=word183}
N 330 10980 330 11030 {
lab=GND}
N 330 11030 330 11040 {
lab=GND}
N 390 10980 390 11030 {
lab=Y4}
N 390 11030 390 11040 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 11010 1 0 {name=M779
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 10990 440 10990 {
lab=word183}
N 440 10990 480 10990 {
lab=word183}
N 410 10980 410 11030 {
lab=GND}
N 410 11030 410 11040 {
lab=GND}
N 470 10980 470 11030 {
lab=Y5}
N 470 11030 470 11040 {
lab=Y5}

N 490 11040 520 11040 {
lab=GND}
N 520 11030 520 11040 {
lab=GND}
N 480 10990 520 10990 {
lab=word183}
N 520 10990 560 10990 {
lab=word183}
N 490 10980 490 11030 {
lab=GND}
N 490 11030 490 11040 {
lab=GND}
N 550 10980 550 11030 {
lab=Y6}
N 550 11030 550 11040 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11010 1 0 {name=M780
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11040 600 11040 {
lab=GND}
N 600 11030 600 11040 {
lab=GND}
N 560 10990 600 10990 {
lab=word183}
N 600 10990 640 10990 {
lab=word183}
N 570 10980 570 11030 {
lab=GND}
N 570 11030 570 11040 {
lab=GND}
N 630 10980 630 11030 {
lab=Y7}
N 630 11030 630 11040 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11010 1 0 {name=M781
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11050 0 0 {name=p207 lab=word184}

N 10 11100 40 11100 {
lab=GND}
N 40 11090 40 11100 {
lab=GND}
N 0 11050 40 11050 {
lab=word184}
N 40 11050 80 11050 {
lab=word184}
N 10 11040 10 11090 {
lab=GND}
N 10 11090 10 11100 {
lab=GND}
N 70 11040 70 11090 {
lab=Y0}
N 70 11090 70 11100 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11070 1 0 {name=M782
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11100 120 11100 {
lab=GND}
N 120 11090 120 11100 {
lab=GND}
N 80 11050 120 11050 {
lab=word184}
N 120 11050 160 11050 {
lab=word184}
N 90 11040 90 11090 {
lab=GND}
N 90 11090 90 11100 {
lab=GND}
N 150 11040 150 11090 {
lab=Y1}
N 150 11090 150 11100 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11070 1 0 {name=M783
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 11050 200 11050 {
lab=word184}
N 200 11050 240 11050 {
lab=word184}
N 170 11040 170 11090 {
lab=GND}
N 170 11090 170 11100 {
lab=GND}
N 230 11040 230 11090 {
lab=Y2}
N 230 11090 230 11100 {
lab=Y2}

N 250 11100 280 11100 {
lab=GND}
N 280 11090 280 11100 {
lab=GND}
N 240 11050 280 11050 {
lab=word184}
N 280 11050 320 11050 {
lab=word184}
N 250 11040 250 11090 {
lab=GND}
N 250 11090 250 11100 {
lab=GND}
N 310 11040 310 11090 {
lab=Y3}
N 310 11090 310 11100 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 11070 1 0 {name=M784
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 11100 360 11100 {
lab=GND}
N 360 11090 360 11100 {
lab=GND}
N 320 11050 360 11050 {
lab=word184}
N 360 11050 400 11050 {
lab=word184}
N 330 11040 330 11090 {
lab=GND}
N 330 11090 330 11100 {
lab=GND}
N 390 11040 390 11090 {
lab=Y4}
N 390 11090 390 11100 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 11070 1 0 {name=M785
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 11100 440 11100 {
lab=GND}
N 440 11090 440 11100 {
lab=GND}
N 400 11050 440 11050 {
lab=word184}
N 440 11050 480 11050 {
lab=word184}
N 410 11040 410 11090 {
lab=GND}
N 410 11090 410 11100 {
lab=GND}
N 470 11040 470 11090 {
lab=Y5}
N 470 11090 470 11100 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 11070 1 0 {name=M786
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 11100 520 11100 {
lab=GND}
N 520 11090 520 11100 {
lab=GND}
N 480 11050 520 11050 {
lab=word184}
N 520 11050 560 11050 {
lab=word184}
N 490 11040 490 11090 {
lab=GND}
N 490 11090 490 11100 {
lab=GND}
N 550 11040 550 11090 {
lab=Y6}
N 550 11090 550 11100 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11070 1 0 {name=M787
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11100 600 11100 {
lab=GND}
N 600 11090 600 11100 {
lab=GND}
N 560 11050 600 11050 {
lab=word184}
N 600 11050 640 11050 {
lab=word184}
N 570 11040 570 11090 {
lab=GND}
N 570 11090 570 11100 {
lab=GND}
N 630 11040 630 11090 {
lab=Y7}
N 630 11090 630 11100 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11070 1 0 {name=M788
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11110 0 0 {name=p208 lab=word185}

N 10 11160 40 11160 {
lab=GND}
N 40 11150 40 11160 {
lab=GND}
N 0 11110 40 11110 {
lab=word185}
N 40 11110 80 11110 {
lab=word185}
N 10 11100 10 11150 {
lab=GND}
N 10 11150 10 11160 {
lab=GND}
N 70 11100 70 11150 {
lab=Y0}
N 70 11150 70 11160 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11130 1 0 {name=M789
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11160 120 11160 {
lab=GND}
N 120 11150 120 11160 {
lab=GND}
N 80 11110 120 11110 {
lab=word185}
N 120 11110 160 11110 {
lab=word185}
N 90 11100 90 11150 {
lab=GND}
N 90 11150 90 11160 {
lab=GND}
N 150 11100 150 11150 {
lab=Y1}
N 150 11150 150 11160 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11130 1 0 {name=M790
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11160 200 11160 {
lab=GND}
N 200 11150 200 11160 {
lab=GND}
N 160 11110 200 11110 {
lab=word185}
N 200 11110 240 11110 {
lab=word185}
N 170 11100 170 11150 {
lab=GND}
N 170 11150 170 11160 {
lab=GND}
N 230 11100 230 11150 {
lab=Y2}
N 230 11150 230 11160 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11130 1 0 {name=M791
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 11110 280 11110 {
lab=word185}
N 280 11110 320 11110 {
lab=word185}
N 250 11100 250 11150 {
lab=GND}
N 250 11150 250 11160 {
lab=GND}
N 310 11100 310 11150 {
lab=Y3}
N 310 11150 310 11160 {
lab=Y3}
N 320 11110 360 11110 {
lab=word185}
N 360 11110 400 11110 {
lab=word185}
N 330 11100 330 11150 {
lab=GND}
N 330 11150 330 11160 {
lab=GND}
N 390 11100 390 11150 {
lab=Y4}
N 390 11150 390 11160 {
lab=Y4}
N 400 11110 440 11110 {
lab=word185}
N 440 11110 480 11110 {
lab=word185}
N 410 11100 410 11150 {
lab=GND}
N 410 11150 410 11160 {
lab=GND}
N 470 11100 470 11150 {
lab=Y5}
N 470 11150 470 11160 {
lab=Y5}

N 490 11160 520 11160 {
lab=GND}
N 520 11150 520 11160 {
lab=GND}
N 480 11110 520 11110 {
lab=word185}
N 520 11110 560 11110 {
lab=word185}
N 490 11100 490 11150 {
lab=GND}
N 490 11150 490 11160 {
lab=GND}
N 550 11100 550 11150 {
lab=Y6}
N 550 11150 550 11160 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11130 1 0 {name=M792
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11160 600 11160 {
lab=GND}
N 600 11150 600 11160 {
lab=GND}
N 560 11110 600 11110 {
lab=word185}
N 600 11110 640 11110 {
lab=word185}
N 570 11100 570 11150 {
lab=GND}
N 570 11150 570 11160 {
lab=GND}
N 630 11100 630 11150 {
lab=Y7}
N 630 11150 630 11160 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11130 1 0 {name=M793
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11170 0 0 {name=p209 lab=word186}

N 10 11220 40 11220 {
lab=GND}
N 40 11210 40 11220 {
lab=GND}
N 0 11170 40 11170 {
lab=word186}
N 40 11170 80 11170 {
lab=word186}
N 10 11160 10 11210 {
lab=GND}
N 10 11210 10 11220 {
lab=GND}
N 70 11160 70 11210 {
lab=Y0}
N 70 11210 70 11220 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11190 1 0 {name=M794
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11220 120 11220 {
lab=GND}
N 120 11210 120 11220 {
lab=GND}
N 80 11170 120 11170 {
lab=word186}
N 120 11170 160 11170 {
lab=word186}
N 90 11160 90 11210 {
lab=GND}
N 90 11210 90 11220 {
lab=GND}
N 150 11160 150 11210 {
lab=Y1}
N 150 11210 150 11220 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11190 1 0 {name=M795
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11220 200 11220 {
lab=GND}
N 200 11210 200 11220 {
lab=GND}
N 160 11170 200 11170 {
lab=word186}
N 200 11170 240 11170 {
lab=word186}
N 170 11160 170 11210 {
lab=GND}
N 170 11210 170 11220 {
lab=GND}
N 230 11160 230 11210 {
lab=Y2}
N 230 11210 230 11220 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11190 1 0 {name=M796
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 11170 280 11170 {
lab=word186}
N 280 11170 320 11170 {
lab=word186}
N 250 11160 250 11210 {
lab=GND}
N 250 11210 250 11220 {
lab=GND}
N 310 11160 310 11210 {
lab=Y3}
N 310 11210 310 11220 {
lab=Y3}
N 320 11170 360 11170 {
lab=word186}
N 360 11170 400 11170 {
lab=word186}
N 330 11160 330 11210 {
lab=GND}
N 330 11210 330 11220 {
lab=GND}
N 390 11160 390 11210 {
lab=Y4}
N 390 11210 390 11220 {
lab=Y4}

N 410 11220 440 11220 {
lab=GND}
N 440 11210 440 11220 {
lab=GND}
N 400 11170 440 11170 {
lab=word186}
N 440 11170 480 11170 {
lab=word186}
N 410 11160 410 11210 {
lab=GND}
N 410 11210 410 11220 {
lab=GND}
N 470 11160 470 11210 {
lab=Y5}
N 470 11210 470 11220 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 11190 1 0 {name=M797
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 11220 520 11220 {
lab=GND}
N 520 11210 520 11220 {
lab=GND}
N 480 11170 520 11170 {
lab=word186}
N 520 11170 560 11170 {
lab=word186}
N 490 11160 490 11210 {
lab=GND}
N 490 11210 490 11220 {
lab=GND}
N 550 11160 550 11210 {
lab=Y6}
N 550 11210 550 11220 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11190 1 0 {name=M798
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11220 600 11220 {
lab=GND}
N 600 11210 600 11220 {
lab=GND}
N 560 11170 600 11170 {
lab=word186}
N 600 11170 640 11170 {
lab=word186}
N 570 11160 570 11210 {
lab=GND}
N 570 11210 570 11220 {
lab=GND}
N 630 11160 630 11210 {
lab=Y7}
N 630 11210 630 11220 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11190 1 0 {name=M799
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11230 0 0 {name=p210 lab=word187}

N 10 11280 40 11280 {
lab=GND}
N 40 11270 40 11280 {
lab=GND}
N 0 11230 40 11230 {
lab=word187}
N 40 11230 80 11230 {
lab=word187}
N 10 11220 10 11270 {
lab=GND}
N 10 11270 10 11280 {
lab=GND}
N 70 11220 70 11270 {
lab=Y0}
N 70 11270 70 11280 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11250 1 0 {name=M800
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11280 120 11280 {
lab=GND}
N 120 11270 120 11280 {
lab=GND}
N 80 11230 120 11230 {
lab=word187}
N 120 11230 160 11230 {
lab=word187}
N 90 11220 90 11270 {
lab=GND}
N 90 11270 90 11280 {
lab=GND}
N 150 11220 150 11270 {
lab=Y1}
N 150 11270 150 11280 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11250 1 0 {name=M801
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11280 200 11280 {
lab=GND}
N 200 11270 200 11280 {
lab=GND}
N 160 11230 200 11230 {
lab=word187}
N 200 11230 240 11230 {
lab=word187}
N 170 11220 170 11270 {
lab=GND}
N 170 11270 170 11280 {
lab=GND}
N 230 11220 230 11270 {
lab=Y2}
N 230 11270 230 11280 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11250 1 0 {name=M802
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 11230 280 11230 {
lab=word187}
N 280 11230 320 11230 {
lab=word187}
N 250 11220 250 11270 {
lab=GND}
N 250 11270 250 11280 {
lab=GND}
N 310 11220 310 11270 {
lab=Y3}
N 310 11270 310 11280 {
lab=Y3}

N 330 11280 360 11280 {
lab=GND}
N 360 11270 360 11280 {
lab=GND}
N 320 11230 360 11230 {
lab=word187}
N 360 11230 400 11230 {
lab=word187}
N 330 11220 330 11270 {
lab=GND}
N 330 11270 330 11280 {
lab=GND}
N 390 11220 390 11270 {
lab=Y4}
N 390 11270 390 11280 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 11250 1 0 {name=M803
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 11230 440 11230 {
lab=word187}
N 440 11230 480 11230 {
lab=word187}
N 410 11220 410 11270 {
lab=GND}
N 410 11270 410 11280 {
lab=GND}
N 470 11220 470 11270 {
lab=Y5}
N 470 11270 470 11280 {
lab=Y5}

N 490 11280 520 11280 {
lab=GND}
N 520 11270 520 11280 {
lab=GND}
N 480 11230 520 11230 {
lab=word187}
N 520 11230 560 11230 {
lab=word187}
N 490 11220 490 11270 {
lab=GND}
N 490 11270 490 11280 {
lab=GND}
N 550 11220 550 11270 {
lab=Y6}
N 550 11270 550 11280 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11250 1 0 {name=M804
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11280 600 11280 {
lab=GND}
N 600 11270 600 11280 {
lab=GND}
N 560 11230 600 11230 {
lab=word187}
N 600 11230 640 11230 {
lab=word187}
N 570 11220 570 11270 {
lab=GND}
N 570 11270 570 11280 {
lab=GND}
N 630 11220 630 11270 {
lab=Y7}
N 630 11270 630 11280 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11250 1 0 {name=M805
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11290 0 0 {name=p211 lab=word188}

N 10 11340 40 11340 {
lab=GND}
N 40 11330 40 11340 {
lab=GND}
N 0 11290 40 11290 {
lab=word188}
N 40 11290 80 11290 {
lab=word188}
N 10 11280 10 11330 {
lab=GND}
N 10 11330 10 11340 {
lab=GND}
N 70 11280 70 11330 {
lab=Y0}
N 70 11330 70 11340 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11310 1 0 {name=M806
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11340 120 11340 {
lab=GND}
N 120 11330 120 11340 {
lab=GND}
N 80 11290 120 11290 {
lab=word188}
N 120 11290 160 11290 {
lab=word188}
N 90 11280 90 11330 {
lab=GND}
N 90 11330 90 11340 {
lab=GND}
N 150 11280 150 11330 {
lab=Y1}
N 150 11330 150 11340 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11310 1 0 {name=M807
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11340 200 11340 {
lab=GND}
N 200 11330 200 11340 {
lab=GND}
N 160 11290 200 11290 {
lab=word188}
N 200 11290 240 11290 {
lab=word188}
N 170 11280 170 11330 {
lab=GND}
N 170 11330 170 11340 {
lab=GND}
N 230 11280 230 11330 {
lab=Y2}
N 230 11330 230 11340 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11310 1 0 {name=M808
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 11290 280 11290 {
lab=word188}
N 280 11290 320 11290 {
lab=word188}
N 250 11280 250 11330 {
lab=GND}
N 250 11330 250 11340 {
lab=GND}
N 310 11280 310 11330 {
lab=Y3}
N 310 11330 310 11340 {
lab=Y3}

N 330 11340 360 11340 {
lab=GND}
N 360 11330 360 11340 {
lab=GND}
N 320 11290 360 11290 {
lab=word188}
N 360 11290 400 11290 {
lab=word188}
N 330 11280 330 11330 {
lab=GND}
N 330 11330 330 11340 {
lab=GND}
N 390 11280 390 11330 {
lab=Y4}
N 390 11330 390 11340 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 11310 1 0 {name=M809
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 11340 440 11340 {
lab=GND}
N 440 11330 440 11340 {
lab=GND}
N 400 11290 440 11290 {
lab=word188}
N 440 11290 480 11290 {
lab=word188}
N 410 11280 410 11330 {
lab=GND}
N 410 11330 410 11340 {
lab=GND}
N 470 11280 470 11330 {
lab=Y5}
N 470 11330 470 11340 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 11310 1 0 {name=M810
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 11340 520 11340 {
lab=GND}
N 520 11330 520 11340 {
lab=GND}
N 480 11290 520 11290 {
lab=word188}
N 520 11290 560 11290 {
lab=word188}
N 490 11280 490 11330 {
lab=GND}
N 490 11330 490 11340 {
lab=GND}
N 550 11280 550 11330 {
lab=Y6}
N 550 11330 550 11340 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11310 1 0 {name=M811
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11340 600 11340 {
lab=GND}
N 600 11330 600 11340 {
lab=GND}
N 560 11290 600 11290 {
lab=word188}
N 600 11290 640 11290 {
lab=word188}
N 570 11280 570 11330 {
lab=GND}
N 570 11330 570 11340 {
lab=GND}
N 630 11280 630 11330 {
lab=Y7}
N 630 11330 630 11340 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11310 1 0 {name=M812
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11350 0 0 {name=p212 lab=word189}

N 10 11400 40 11400 {
lab=GND}
N 40 11390 40 11400 {
lab=GND}
N 0 11350 40 11350 {
lab=word189}
N 40 11350 80 11350 {
lab=word189}
N 10 11340 10 11390 {
lab=GND}
N 10 11390 10 11400 {
lab=GND}
N 70 11340 70 11390 {
lab=Y0}
N 70 11390 70 11400 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11370 1 0 {name=M813
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11400 120 11400 {
lab=GND}
N 120 11390 120 11400 {
lab=GND}
N 80 11350 120 11350 {
lab=word189}
N 120 11350 160 11350 {
lab=word189}
N 90 11340 90 11390 {
lab=GND}
N 90 11390 90 11400 {
lab=GND}
N 150 11340 150 11390 {
lab=Y1}
N 150 11390 150 11400 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11370 1 0 {name=M814
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11400 200 11400 {
lab=GND}
N 200 11390 200 11400 {
lab=GND}
N 160 11350 200 11350 {
lab=word189}
N 200 11350 240 11350 {
lab=word189}
N 170 11340 170 11390 {
lab=GND}
N 170 11390 170 11400 {
lab=GND}
N 230 11340 230 11390 {
lab=Y2}
N 230 11390 230 11400 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11370 1 0 {name=M815
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 11400 280 11400 {
lab=GND}
N 280 11390 280 11400 {
lab=GND}
N 240 11350 280 11350 {
lab=word189}
N 280 11350 320 11350 {
lab=word189}
N 250 11340 250 11390 {
lab=GND}
N 250 11390 250 11400 {
lab=GND}
N 310 11340 310 11390 {
lab=Y3}
N 310 11390 310 11400 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 11370 1 0 {name=M816
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 11350 360 11350 {
lab=word189}
N 360 11350 400 11350 {
lab=word189}
N 330 11340 330 11390 {
lab=GND}
N 330 11390 330 11400 {
lab=GND}
N 390 11340 390 11390 {
lab=Y4}
N 390 11390 390 11400 {
lab=Y4}
N 400 11350 440 11350 {
lab=word189}
N 440 11350 480 11350 {
lab=word189}
N 410 11340 410 11390 {
lab=GND}
N 410 11390 410 11400 {
lab=GND}
N 470 11340 470 11390 {
lab=Y5}
N 470 11390 470 11400 {
lab=Y5}

N 490 11400 520 11400 {
lab=GND}
N 520 11390 520 11400 {
lab=GND}
N 480 11350 520 11350 {
lab=word189}
N 520 11350 560 11350 {
lab=word189}
N 490 11340 490 11390 {
lab=GND}
N 490 11390 490 11400 {
lab=GND}
N 550 11340 550 11390 {
lab=Y6}
N 550 11390 550 11400 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11370 1 0 {name=M817
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11400 600 11400 {
lab=GND}
N 600 11390 600 11400 {
lab=GND}
N 560 11350 600 11350 {
lab=word189}
N 600 11350 640 11350 {
lab=word189}
N 570 11340 570 11390 {
lab=GND}
N 570 11390 570 11400 {
lab=GND}
N 630 11340 630 11390 {
lab=Y7}
N 630 11390 630 11400 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11370 1 0 {name=M818
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11410 0 0 {name=p213 lab=word190}

N 10 11460 40 11460 {
lab=GND}
N 40 11450 40 11460 {
lab=GND}
N 0 11410 40 11410 {
lab=word190}
N 40 11410 80 11410 {
lab=word190}
N 10 11400 10 11450 {
lab=GND}
N 10 11450 10 11460 {
lab=GND}
N 70 11400 70 11450 {
lab=Y0}
N 70 11450 70 11460 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11430 1 0 {name=M819
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11460 120 11460 {
lab=GND}
N 120 11450 120 11460 {
lab=GND}
N 80 11410 120 11410 {
lab=word190}
N 120 11410 160 11410 {
lab=word190}
N 90 11400 90 11450 {
lab=GND}
N 90 11450 90 11460 {
lab=GND}
N 150 11400 150 11450 {
lab=Y1}
N 150 11450 150 11460 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11430 1 0 {name=M820
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11460 200 11460 {
lab=GND}
N 200 11450 200 11460 {
lab=GND}
N 160 11410 200 11410 {
lab=word190}
N 200 11410 240 11410 {
lab=word190}
N 170 11400 170 11450 {
lab=GND}
N 170 11450 170 11460 {
lab=GND}
N 230 11400 230 11450 {
lab=Y2}
N 230 11450 230 11460 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11430 1 0 {name=M821
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 11460 280 11460 {
lab=GND}
N 280 11450 280 11460 {
lab=GND}
N 240 11410 280 11410 {
lab=word190}
N 280 11410 320 11410 {
lab=word190}
N 250 11400 250 11450 {
lab=GND}
N 250 11450 250 11460 {
lab=GND}
N 310 11400 310 11450 {
lab=Y3}
N 310 11450 310 11460 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 11430 1 0 {name=M822
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 11410 360 11410 {
lab=word190}
N 360 11410 400 11410 {
lab=word190}
N 330 11400 330 11450 {
lab=GND}
N 330 11450 330 11460 {
lab=GND}
N 390 11400 390 11450 {
lab=Y4}
N 390 11450 390 11460 {
lab=Y4}

N 410 11460 440 11460 {
lab=GND}
N 440 11450 440 11460 {
lab=GND}
N 400 11410 440 11410 {
lab=word190}
N 440 11410 480 11410 {
lab=word190}
N 410 11400 410 11450 {
lab=GND}
N 410 11450 410 11460 {
lab=GND}
N 470 11400 470 11450 {
lab=Y5}
N 470 11450 470 11460 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 11430 1 0 {name=M823
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 11460 520 11460 {
lab=GND}
N 520 11450 520 11460 {
lab=GND}
N 480 11410 520 11410 {
lab=word190}
N 520 11410 560 11410 {
lab=word190}
N 490 11400 490 11450 {
lab=GND}
N 490 11450 490 11460 {
lab=GND}
N 550 11400 550 11450 {
lab=Y6}
N 550 11450 550 11460 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11430 1 0 {name=M824
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11460 600 11460 {
lab=GND}
N 600 11450 600 11460 {
lab=GND}
N 560 11410 600 11410 {
lab=word190}
N 600 11410 640 11410 {
lab=word190}
N 570 11400 570 11450 {
lab=GND}
N 570 11450 570 11460 {
lab=GND}
N 630 11400 630 11450 {
lab=Y7}
N 630 11450 630 11460 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11430 1 0 {name=M825
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11470 0 0 {name=p214 lab=word191}

N 10 11520 40 11520 {
lab=GND}
N 40 11510 40 11520 {
lab=GND}
N 0 11470 40 11470 {
lab=word191}
N 40 11470 80 11470 {
lab=word191}
N 10 11460 10 11510 {
lab=GND}
N 10 11510 10 11520 {
lab=GND}
N 70 11460 70 11510 {
lab=Y0}
N 70 11510 70 11520 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11490 1 0 {name=M826
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11520 120 11520 {
lab=GND}
N 120 11510 120 11520 {
lab=GND}
N 80 11470 120 11470 {
lab=word191}
N 120 11470 160 11470 {
lab=word191}
N 90 11460 90 11510 {
lab=GND}
N 90 11510 90 11520 {
lab=GND}
N 150 11460 150 11510 {
lab=Y1}
N 150 11510 150 11520 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11490 1 0 {name=M827
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11520 200 11520 {
lab=GND}
N 200 11510 200 11520 {
lab=GND}
N 160 11470 200 11470 {
lab=word191}
N 200 11470 240 11470 {
lab=word191}
N 170 11460 170 11510 {
lab=GND}
N 170 11510 170 11520 {
lab=GND}
N 230 11460 230 11510 {
lab=Y2}
N 230 11510 230 11520 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11490 1 0 {name=M828
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 11520 280 11520 {
lab=GND}
N 280 11510 280 11520 {
lab=GND}
N 240 11470 280 11470 {
lab=word191}
N 280 11470 320 11470 {
lab=word191}
N 250 11460 250 11510 {
lab=GND}
N 250 11510 250 11520 {
lab=GND}
N 310 11460 310 11510 {
lab=Y3}
N 310 11510 310 11520 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 11490 1 0 {name=M829
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 11520 360 11520 {
lab=GND}
N 360 11510 360 11520 {
lab=GND}
N 320 11470 360 11470 {
lab=word191}
N 360 11470 400 11470 {
lab=word191}
N 330 11460 330 11510 {
lab=GND}
N 330 11510 330 11520 {
lab=GND}
N 390 11460 390 11510 {
lab=Y4}
N 390 11510 390 11520 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 11490 1 0 {name=M830
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 11470 440 11470 {
lab=word191}
N 440 11470 480 11470 {
lab=word191}
N 410 11460 410 11510 {
lab=GND}
N 410 11510 410 11520 {
lab=GND}
N 470 11460 470 11510 {
lab=Y5}
N 470 11510 470 11520 {
lab=Y5}

N 490 11520 520 11520 {
lab=GND}
N 520 11510 520 11520 {
lab=GND}
N 480 11470 520 11470 {
lab=word191}
N 520 11470 560 11470 {
lab=word191}
N 490 11460 490 11510 {
lab=GND}
N 490 11510 490 11520 {
lab=GND}
N 550 11460 550 11510 {
lab=Y6}
N 550 11510 550 11520 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11490 1 0 {name=M831
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11520 600 11520 {
lab=GND}
N 600 11510 600 11520 {
lab=GND}
N 560 11470 600 11470 {
lab=word191}
N 600 11470 640 11470 {
lab=word191}
N 570 11460 570 11510 {
lab=GND}
N 570 11510 570 11520 {
lab=GND}
N 630 11460 630 11510 {
lab=Y7}
N 630 11510 630 11520 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11490 1 0 {name=M832
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11530 0 0 {name=p215 lab=word192}

N 10 11580 40 11580 {
lab=GND}
N 40 11570 40 11580 {
lab=GND}
N 0 11530 40 11530 {
lab=word192}
N 40 11530 80 11530 {
lab=word192}
N 10 11520 10 11570 {
lab=GND}
N 10 11570 10 11580 {
lab=GND}
N 70 11520 70 11570 {
lab=Y0}
N 70 11570 70 11580 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11550 1 0 {name=M833
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11580 120 11580 {
lab=GND}
N 120 11570 120 11580 {
lab=GND}
N 80 11530 120 11530 {
lab=word192}
N 120 11530 160 11530 {
lab=word192}
N 90 11520 90 11570 {
lab=GND}
N 90 11570 90 11580 {
lab=GND}
N 150 11520 150 11570 {
lab=Y1}
N 150 11570 150 11580 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11550 1 0 {name=M834
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11580 200 11580 {
lab=GND}
N 200 11570 200 11580 {
lab=GND}
N 160 11530 200 11530 {
lab=word192}
N 200 11530 240 11530 {
lab=word192}
N 170 11520 170 11570 {
lab=GND}
N 170 11570 170 11580 {
lab=GND}
N 230 11520 230 11570 {
lab=Y2}
N 230 11570 230 11580 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11550 1 0 {name=M835
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 11580 280 11580 {
lab=GND}
N 280 11570 280 11580 {
lab=GND}
N 240 11530 280 11530 {
lab=word192}
N 280 11530 320 11530 {
lab=word192}
N 250 11520 250 11570 {
lab=GND}
N 250 11570 250 11580 {
lab=GND}
N 310 11520 310 11570 {
lab=Y3}
N 310 11570 310 11580 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 11550 1 0 {name=M836
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 11580 360 11580 {
lab=GND}
N 360 11570 360 11580 {
lab=GND}
N 320 11530 360 11530 {
lab=word192}
N 360 11530 400 11530 {
lab=word192}
N 330 11520 330 11570 {
lab=GND}
N 330 11570 330 11580 {
lab=GND}
N 390 11520 390 11570 {
lab=Y4}
N 390 11570 390 11580 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 11550 1 0 {name=M837
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 11580 440 11580 {
lab=GND}
N 440 11570 440 11580 {
lab=GND}
N 400 11530 440 11530 {
lab=word192}
N 440 11530 480 11530 {
lab=word192}
N 410 11520 410 11570 {
lab=GND}
N 410 11570 410 11580 {
lab=GND}
N 470 11520 470 11570 {
lab=Y5}
N 470 11570 470 11580 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 11550 1 0 {name=M838
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 11580 520 11580 {
lab=GND}
N 520 11570 520 11580 {
lab=GND}
N 480 11530 520 11530 {
lab=word192}
N 520 11530 560 11530 {
lab=word192}
N 490 11520 490 11570 {
lab=GND}
N 490 11570 490 11580 {
lab=GND}
N 550 11520 550 11570 {
lab=Y6}
N 550 11570 550 11580 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11550 1 0 {name=M839
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11580 600 11580 {
lab=GND}
N 600 11570 600 11580 {
lab=GND}
N 560 11530 600 11530 {
lab=word192}
N 600 11530 640 11530 {
lab=word192}
N 570 11520 570 11570 {
lab=GND}
N 570 11570 570 11580 {
lab=GND}
N 630 11520 630 11570 {
lab=Y7}
N 630 11570 630 11580 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11550 1 0 {name=M840
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11590 0 0 {name=p216 lab=word193}

N 10 11640 40 11640 {
lab=GND}
N 40 11630 40 11640 {
lab=GND}
N 0 11590 40 11590 {
lab=word193}
N 40 11590 80 11590 {
lab=word193}
N 10 11580 10 11630 {
lab=GND}
N 10 11630 10 11640 {
lab=GND}
N 70 11580 70 11630 {
lab=Y0}
N 70 11630 70 11640 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11610 1 0 {name=M841
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11640 120 11640 {
lab=GND}
N 120 11630 120 11640 {
lab=GND}
N 80 11590 120 11590 {
lab=word193}
N 120 11590 160 11590 {
lab=word193}
N 90 11580 90 11630 {
lab=GND}
N 90 11630 90 11640 {
lab=GND}
N 150 11580 150 11630 {
lab=Y1}
N 150 11630 150 11640 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11610 1 0 {name=M842
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11640 200 11640 {
lab=GND}
N 200 11630 200 11640 {
lab=GND}
N 160 11590 200 11590 {
lab=word193}
N 200 11590 240 11590 {
lab=word193}
N 170 11580 170 11630 {
lab=GND}
N 170 11630 170 11640 {
lab=GND}
N 230 11580 230 11630 {
lab=Y2}
N 230 11630 230 11640 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11610 1 0 {name=M843
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 11640 280 11640 {
lab=GND}
N 280 11630 280 11640 {
lab=GND}
N 240 11590 280 11590 {
lab=word193}
N 280 11590 320 11590 {
lab=word193}
N 250 11580 250 11630 {
lab=GND}
N 250 11630 250 11640 {
lab=GND}
N 310 11580 310 11630 {
lab=Y3}
N 310 11630 310 11640 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 11610 1 0 {name=M844
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 11640 360 11640 {
lab=GND}
N 360 11630 360 11640 {
lab=GND}
N 320 11590 360 11590 {
lab=word193}
N 360 11590 400 11590 {
lab=word193}
N 330 11580 330 11630 {
lab=GND}
N 330 11630 330 11640 {
lab=GND}
N 390 11580 390 11630 {
lab=Y4}
N 390 11630 390 11640 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 11610 1 0 {name=M845
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 11590 440 11590 {
lab=word193}
N 440 11590 480 11590 {
lab=word193}
N 410 11580 410 11630 {
lab=GND}
N 410 11630 410 11640 {
lab=GND}
N 470 11580 470 11630 {
lab=Y5}
N 470 11630 470 11640 {
lab=Y5}

N 490 11640 520 11640 {
lab=GND}
N 520 11630 520 11640 {
lab=GND}
N 480 11590 520 11590 {
lab=word193}
N 520 11590 560 11590 {
lab=word193}
N 490 11580 490 11630 {
lab=GND}
N 490 11630 490 11640 {
lab=GND}
N 550 11580 550 11630 {
lab=Y6}
N 550 11630 550 11640 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11610 1 0 {name=M846
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11640 600 11640 {
lab=GND}
N 600 11630 600 11640 {
lab=GND}
N 560 11590 600 11590 {
lab=word193}
N 600 11590 640 11590 {
lab=word193}
N 570 11580 570 11630 {
lab=GND}
N 570 11630 570 11640 {
lab=GND}
N 630 11580 630 11630 {
lab=Y7}
N 630 11630 630 11640 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11610 1 0 {name=M847
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11650 0 0 {name=p217 lab=word194}

N 10 11700 40 11700 {
lab=GND}
N 40 11690 40 11700 {
lab=GND}
N 0 11650 40 11650 {
lab=word194}
N 40 11650 80 11650 {
lab=word194}
N 10 11640 10 11690 {
lab=GND}
N 10 11690 10 11700 {
lab=GND}
N 70 11640 70 11690 {
lab=Y0}
N 70 11690 70 11700 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11670 1 0 {name=M848
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11700 120 11700 {
lab=GND}
N 120 11690 120 11700 {
lab=GND}
N 80 11650 120 11650 {
lab=word194}
N 120 11650 160 11650 {
lab=word194}
N 90 11640 90 11690 {
lab=GND}
N 90 11690 90 11700 {
lab=GND}
N 150 11640 150 11690 {
lab=Y1}
N 150 11690 150 11700 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11670 1 0 {name=M849
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11700 200 11700 {
lab=GND}
N 200 11690 200 11700 {
lab=GND}
N 160 11650 200 11650 {
lab=word194}
N 200 11650 240 11650 {
lab=word194}
N 170 11640 170 11690 {
lab=GND}
N 170 11690 170 11700 {
lab=GND}
N 230 11640 230 11690 {
lab=Y2}
N 230 11690 230 11700 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11670 1 0 {name=M850
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 11700 280 11700 {
lab=GND}
N 280 11690 280 11700 {
lab=GND}
N 240 11650 280 11650 {
lab=word194}
N 280 11650 320 11650 {
lab=word194}
N 250 11640 250 11690 {
lab=GND}
N 250 11690 250 11700 {
lab=GND}
N 310 11640 310 11690 {
lab=Y3}
N 310 11690 310 11700 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 11670 1 0 {name=M851
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 11650 360 11650 {
lab=word194}
N 360 11650 400 11650 {
lab=word194}
N 330 11640 330 11690 {
lab=GND}
N 330 11690 330 11700 {
lab=GND}
N 390 11640 390 11690 {
lab=Y4}
N 390 11690 390 11700 {
lab=Y4}

N 410 11700 440 11700 {
lab=GND}
N 440 11690 440 11700 {
lab=GND}
N 400 11650 440 11650 {
lab=word194}
N 440 11650 480 11650 {
lab=word194}
N 410 11640 410 11690 {
lab=GND}
N 410 11690 410 11700 {
lab=GND}
N 470 11640 470 11690 {
lab=Y5}
N 470 11690 470 11700 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 11670 1 0 {name=M852
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 11700 520 11700 {
lab=GND}
N 520 11690 520 11700 {
lab=GND}
N 480 11650 520 11650 {
lab=word194}
N 520 11650 560 11650 {
lab=word194}
N 490 11640 490 11690 {
lab=GND}
N 490 11690 490 11700 {
lab=GND}
N 550 11640 550 11690 {
lab=Y6}
N 550 11690 550 11700 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11670 1 0 {name=M853
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11700 600 11700 {
lab=GND}
N 600 11690 600 11700 {
lab=GND}
N 560 11650 600 11650 {
lab=word194}
N 600 11650 640 11650 {
lab=word194}
N 570 11640 570 11690 {
lab=GND}
N 570 11690 570 11700 {
lab=GND}
N 630 11640 630 11690 {
lab=Y7}
N 630 11690 630 11700 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11670 1 0 {name=M854
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11710 0 0 {name=p218 lab=word195}

N 10 11760 40 11760 {
lab=GND}
N 40 11750 40 11760 {
lab=GND}
N 0 11710 40 11710 {
lab=word195}
N 40 11710 80 11710 {
lab=word195}
N 10 11700 10 11750 {
lab=GND}
N 10 11750 10 11760 {
lab=GND}
N 70 11700 70 11750 {
lab=Y0}
N 70 11750 70 11760 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11730 1 0 {name=M855
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11760 120 11760 {
lab=GND}
N 120 11750 120 11760 {
lab=GND}
N 80 11710 120 11710 {
lab=word195}
N 120 11710 160 11710 {
lab=word195}
N 90 11700 90 11750 {
lab=GND}
N 90 11750 90 11760 {
lab=GND}
N 150 11700 150 11750 {
lab=Y1}
N 150 11750 150 11760 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11730 1 0 {name=M856
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11760 200 11760 {
lab=GND}
N 200 11750 200 11760 {
lab=GND}
N 160 11710 200 11710 {
lab=word195}
N 200 11710 240 11710 {
lab=word195}
N 170 11700 170 11750 {
lab=GND}
N 170 11750 170 11760 {
lab=GND}
N 230 11700 230 11750 {
lab=Y2}
N 230 11750 230 11760 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11730 1 0 {name=M857
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 11760 280 11760 {
lab=GND}
N 280 11750 280 11760 {
lab=GND}
N 240 11710 280 11710 {
lab=word195}
N 280 11710 320 11710 {
lab=word195}
N 250 11700 250 11750 {
lab=GND}
N 250 11750 250 11760 {
lab=GND}
N 310 11700 310 11750 {
lab=Y3}
N 310 11750 310 11760 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 11730 1 0 {name=M858
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 11710 360 11710 {
lab=word195}
N 360 11710 400 11710 {
lab=word195}
N 330 11700 330 11750 {
lab=GND}
N 330 11750 330 11760 {
lab=GND}
N 390 11700 390 11750 {
lab=Y4}
N 390 11750 390 11760 {
lab=Y4}
N 400 11710 440 11710 {
lab=word195}
N 440 11710 480 11710 {
lab=word195}
N 410 11700 410 11750 {
lab=GND}
N 410 11750 410 11760 {
lab=GND}
N 470 11700 470 11750 {
lab=Y5}
N 470 11750 470 11760 {
lab=Y5}

N 490 11760 520 11760 {
lab=GND}
N 520 11750 520 11760 {
lab=GND}
N 480 11710 520 11710 {
lab=word195}
N 520 11710 560 11710 {
lab=word195}
N 490 11700 490 11750 {
lab=GND}
N 490 11750 490 11760 {
lab=GND}
N 550 11700 550 11750 {
lab=Y6}
N 550 11750 550 11760 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11730 1 0 {name=M859
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11760 600 11760 {
lab=GND}
N 600 11750 600 11760 {
lab=GND}
N 560 11710 600 11710 {
lab=word195}
N 600 11710 640 11710 {
lab=word195}
N 570 11700 570 11750 {
lab=GND}
N 570 11750 570 11760 {
lab=GND}
N 630 11700 630 11750 {
lab=Y7}
N 630 11750 630 11760 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11730 1 0 {name=M860
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11770 0 0 {name=p219 lab=word196}

N 10 11820 40 11820 {
lab=GND}
N 40 11810 40 11820 {
lab=GND}
N 0 11770 40 11770 {
lab=word196}
N 40 11770 80 11770 {
lab=word196}
N 10 11760 10 11810 {
lab=GND}
N 10 11810 10 11820 {
lab=GND}
N 70 11760 70 11810 {
lab=Y0}
N 70 11810 70 11820 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11790 1 0 {name=M861
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11820 120 11820 {
lab=GND}
N 120 11810 120 11820 {
lab=GND}
N 80 11770 120 11770 {
lab=word196}
N 120 11770 160 11770 {
lab=word196}
N 90 11760 90 11810 {
lab=GND}
N 90 11810 90 11820 {
lab=GND}
N 150 11760 150 11810 {
lab=Y1}
N 150 11810 150 11820 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11790 1 0 {name=M862
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11820 200 11820 {
lab=GND}
N 200 11810 200 11820 {
lab=GND}
N 160 11770 200 11770 {
lab=word196}
N 200 11770 240 11770 {
lab=word196}
N 170 11760 170 11810 {
lab=GND}
N 170 11810 170 11820 {
lab=GND}
N 230 11760 230 11810 {
lab=Y2}
N 230 11810 230 11820 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11790 1 0 {name=M863
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 11770 280 11770 {
lab=word196}
N 280 11770 320 11770 {
lab=word196}
N 250 11760 250 11810 {
lab=GND}
N 250 11810 250 11820 {
lab=GND}
N 310 11760 310 11810 {
lab=Y3}
N 310 11810 310 11820 {
lab=Y3}

N 330 11820 360 11820 {
lab=GND}
N 360 11810 360 11820 {
lab=GND}
N 320 11770 360 11770 {
lab=word196}
N 360 11770 400 11770 {
lab=word196}
N 330 11760 330 11810 {
lab=GND}
N 330 11810 330 11820 {
lab=GND}
N 390 11760 390 11810 {
lab=Y4}
N 390 11810 390 11820 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 11790 1 0 {name=M864
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 11820 440 11820 {
lab=GND}
N 440 11810 440 11820 {
lab=GND}
N 400 11770 440 11770 {
lab=word196}
N 440 11770 480 11770 {
lab=word196}
N 410 11760 410 11810 {
lab=GND}
N 410 11810 410 11820 {
lab=GND}
N 470 11760 470 11810 {
lab=Y5}
N 470 11810 470 11820 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 11790 1 0 {name=M865
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 11820 520 11820 {
lab=GND}
N 520 11810 520 11820 {
lab=GND}
N 480 11770 520 11770 {
lab=word196}
N 520 11770 560 11770 {
lab=word196}
N 490 11760 490 11810 {
lab=GND}
N 490 11810 490 11820 {
lab=GND}
N 550 11760 550 11810 {
lab=Y6}
N 550 11810 550 11820 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11790 1 0 {name=M866
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11820 600 11820 {
lab=GND}
N 600 11810 600 11820 {
lab=GND}
N 560 11770 600 11770 {
lab=word196}
N 600 11770 640 11770 {
lab=word196}
N 570 11760 570 11810 {
lab=GND}
N 570 11810 570 11820 {
lab=GND}
N 630 11760 630 11810 {
lab=Y7}
N 630 11810 630 11820 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11790 1 0 {name=M867
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11830 0 0 {name=p220 lab=word197}

N 10 11880 40 11880 {
lab=GND}
N 40 11870 40 11880 {
lab=GND}
N 0 11830 40 11830 {
lab=word197}
N 40 11830 80 11830 {
lab=word197}
N 10 11820 10 11870 {
lab=GND}
N 10 11870 10 11880 {
lab=GND}
N 70 11820 70 11870 {
lab=Y0}
N 70 11870 70 11880 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11850 1 0 {name=M868
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11880 120 11880 {
lab=GND}
N 120 11870 120 11880 {
lab=GND}
N 80 11830 120 11830 {
lab=word197}
N 120 11830 160 11830 {
lab=word197}
N 90 11820 90 11870 {
lab=GND}
N 90 11870 90 11880 {
lab=GND}
N 150 11820 150 11870 {
lab=Y1}
N 150 11870 150 11880 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11850 1 0 {name=M869
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11880 200 11880 {
lab=GND}
N 200 11870 200 11880 {
lab=GND}
N 160 11830 200 11830 {
lab=word197}
N 200 11830 240 11830 {
lab=word197}
N 170 11820 170 11870 {
lab=GND}
N 170 11870 170 11880 {
lab=GND}
N 230 11820 230 11870 {
lab=Y2}
N 230 11870 230 11880 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11850 1 0 {name=M870
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 11830 280 11830 {
lab=word197}
N 280 11830 320 11830 {
lab=word197}
N 250 11820 250 11870 {
lab=GND}
N 250 11870 250 11880 {
lab=GND}
N 310 11820 310 11870 {
lab=Y3}
N 310 11870 310 11880 {
lab=Y3}

N 330 11880 360 11880 {
lab=GND}
N 360 11870 360 11880 {
lab=GND}
N 320 11830 360 11830 {
lab=word197}
N 360 11830 400 11830 {
lab=word197}
N 330 11820 330 11870 {
lab=GND}
N 330 11870 330 11880 {
lab=GND}
N 390 11820 390 11870 {
lab=Y4}
N 390 11870 390 11880 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 11850 1 0 {name=M871
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 11830 440 11830 {
lab=word197}
N 440 11830 480 11830 {
lab=word197}
N 410 11820 410 11870 {
lab=GND}
N 410 11870 410 11880 {
lab=GND}
N 470 11820 470 11870 {
lab=Y5}
N 470 11870 470 11880 {
lab=Y5}

N 490 11880 520 11880 {
lab=GND}
N 520 11870 520 11880 {
lab=GND}
N 480 11830 520 11830 {
lab=word197}
N 520 11830 560 11830 {
lab=word197}
N 490 11820 490 11870 {
lab=GND}
N 490 11870 490 11880 {
lab=GND}
N 550 11820 550 11870 {
lab=Y6}
N 550 11870 550 11880 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11850 1 0 {name=M872
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11880 600 11880 {
lab=GND}
N 600 11870 600 11880 {
lab=GND}
N 560 11830 600 11830 {
lab=word197}
N 600 11830 640 11830 {
lab=word197}
N 570 11820 570 11870 {
lab=GND}
N 570 11870 570 11880 {
lab=GND}
N 630 11820 630 11870 {
lab=Y7}
N 630 11870 630 11880 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11850 1 0 {name=M873
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11890 0 0 {name=p221 lab=word198}

N 10 11940 40 11940 {
lab=GND}
N 40 11930 40 11940 {
lab=GND}
N 0 11890 40 11890 {
lab=word198}
N 40 11890 80 11890 {
lab=word198}
N 10 11880 10 11930 {
lab=GND}
N 10 11930 10 11940 {
lab=GND}
N 70 11880 70 11930 {
lab=Y0}
N 70 11930 70 11940 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11910 1 0 {name=M874
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 11940 120 11940 {
lab=GND}
N 120 11930 120 11940 {
lab=GND}
N 80 11890 120 11890 {
lab=word198}
N 120 11890 160 11890 {
lab=word198}
N 90 11880 90 11930 {
lab=GND}
N 90 11930 90 11940 {
lab=GND}
N 150 11880 150 11930 {
lab=Y1}
N 150 11930 150 11940 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11910 1 0 {name=M875
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 11940 200 11940 {
lab=GND}
N 200 11930 200 11940 {
lab=GND}
N 160 11890 200 11890 {
lab=word198}
N 200 11890 240 11890 {
lab=word198}
N 170 11880 170 11930 {
lab=GND}
N 170 11930 170 11940 {
lab=GND}
N 230 11880 230 11930 {
lab=Y2}
N 230 11930 230 11940 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11910 1 0 {name=M876
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 11890 280 11890 {
lab=word198}
N 280 11890 320 11890 {
lab=word198}
N 250 11880 250 11930 {
lab=GND}
N 250 11930 250 11940 {
lab=GND}
N 310 11880 310 11930 {
lab=Y3}
N 310 11930 310 11940 {
lab=Y3}
N 320 11890 360 11890 {
lab=word198}
N 360 11890 400 11890 {
lab=word198}
N 330 11880 330 11930 {
lab=GND}
N 330 11930 330 11940 {
lab=GND}
N 390 11880 390 11930 {
lab=Y4}
N 390 11930 390 11940 {
lab=Y4}

N 410 11940 440 11940 {
lab=GND}
N 440 11930 440 11940 {
lab=GND}
N 400 11890 440 11890 {
lab=word198}
N 440 11890 480 11890 {
lab=word198}
N 410 11880 410 11930 {
lab=GND}
N 410 11930 410 11940 {
lab=GND}
N 470 11880 470 11930 {
lab=Y5}
N 470 11930 470 11940 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 11910 1 0 {name=M877
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 11940 520 11940 {
lab=GND}
N 520 11930 520 11940 {
lab=GND}
N 480 11890 520 11890 {
lab=word198}
N 520 11890 560 11890 {
lab=word198}
N 490 11880 490 11930 {
lab=GND}
N 490 11930 490 11940 {
lab=GND}
N 550 11880 550 11930 {
lab=Y6}
N 550 11930 550 11940 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11910 1 0 {name=M878
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 11940 600 11940 {
lab=GND}
N 600 11930 600 11940 {
lab=GND}
N 560 11890 600 11890 {
lab=word198}
N 600 11890 640 11890 {
lab=word198}
N 570 11880 570 11930 {
lab=GND}
N 570 11930 570 11940 {
lab=GND}
N 630 11880 630 11930 {
lab=Y7}
N 630 11930 630 11940 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11910 1 0 {name=M879
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 11950 0 0 {name=p222 lab=word199}

N 10 12000 40 12000 {
lab=GND}
N 40 11990 40 12000 {
lab=GND}
N 0 11950 40 11950 {
lab=word199}
N 40 11950 80 11950 {
lab=word199}
N 10 11940 10 11990 {
lab=GND}
N 10 11990 10 12000 {
lab=GND}
N 70 11940 70 11990 {
lab=Y0}
N 70 11990 70 12000 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 11970 1 0 {name=M880
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 12000 120 12000 {
lab=GND}
N 120 11990 120 12000 {
lab=GND}
N 80 11950 120 11950 {
lab=word199}
N 120 11950 160 11950 {
lab=word199}
N 90 11940 90 11990 {
lab=GND}
N 90 11990 90 12000 {
lab=GND}
N 150 11940 150 11990 {
lab=Y1}
N 150 11990 150 12000 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 11970 1 0 {name=M881
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 12000 200 12000 {
lab=GND}
N 200 11990 200 12000 {
lab=GND}
N 160 11950 200 11950 {
lab=word199}
N 200 11950 240 11950 {
lab=word199}
N 170 11940 170 11990 {
lab=GND}
N 170 11990 170 12000 {
lab=GND}
N 230 11940 230 11990 {
lab=Y2}
N 230 11990 230 12000 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 11970 1 0 {name=M882
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 11950 280 11950 {
lab=word199}
N 280 11950 320 11950 {
lab=word199}
N 250 11940 250 11990 {
lab=GND}
N 250 11990 250 12000 {
lab=GND}
N 310 11940 310 11990 {
lab=Y3}
N 310 11990 310 12000 {
lab=Y3}
N 320 11950 360 11950 {
lab=word199}
N 360 11950 400 11950 {
lab=word199}
N 330 11940 330 11990 {
lab=GND}
N 330 11990 330 12000 {
lab=GND}
N 390 11940 390 11990 {
lab=Y4}
N 390 11990 390 12000 {
lab=Y4}
N 400 11950 440 11950 {
lab=word199}
N 440 11950 480 11950 {
lab=word199}
N 410 11940 410 11990 {
lab=GND}
N 410 11990 410 12000 {
lab=GND}
N 470 11940 470 11990 {
lab=Y5}
N 470 11990 470 12000 {
lab=Y5}

N 490 12000 520 12000 {
lab=GND}
N 520 11990 520 12000 {
lab=GND}
N 480 11950 520 11950 {
lab=word199}
N 520 11950 560 11950 {
lab=word199}
N 490 11940 490 11990 {
lab=GND}
N 490 11990 490 12000 {
lab=GND}
N 550 11940 550 11990 {
lab=Y6}
N 550 11990 550 12000 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 11970 1 0 {name=M883
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12000 600 12000 {
lab=GND}
N 600 11990 600 12000 {
lab=GND}
N 560 11950 600 11950 {
lab=word199}
N 600 11950 640 11950 {
lab=word199}
N 570 11940 570 11990 {
lab=GND}
N 570 11990 570 12000 {
lab=GND}
N 630 11940 630 11990 {
lab=Y7}
N 630 11990 630 12000 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 11970 1 0 {name=M884
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12010 0 0 {name=p223 lab=word200}

N 10 12060 40 12060 {
lab=GND}
N 40 12050 40 12060 {
lab=GND}
N 0 12010 40 12010 {
lab=word200}
N 40 12010 80 12010 {
lab=word200}
N 10 12000 10 12050 {
lab=GND}
N 10 12050 10 12060 {
lab=GND}
N 70 12000 70 12050 {
lab=Y0}
N 70 12050 70 12060 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12030 1 0 {name=M885
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 12060 120 12060 {
lab=GND}
N 120 12050 120 12060 {
lab=GND}
N 80 12010 120 12010 {
lab=word200}
N 120 12010 160 12010 {
lab=word200}
N 90 12000 90 12050 {
lab=GND}
N 90 12050 90 12060 {
lab=GND}
N 150 12000 150 12050 {
lab=Y1}
N 150 12050 150 12060 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 12030 1 0 {name=M886
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 12010 200 12010 {
lab=word200}
N 200 12010 240 12010 {
lab=word200}
N 170 12000 170 12050 {
lab=GND}
N 170 12050 170 12060 {
lab=GND}
N 230 12000 230 12050 {
lab=Y2}
N 230 12050 230 12060 {
lab=Y2}

N 250 12060 280 12060 {
lab=GND}
N 280 12050 280 12060 {
lab=GND}
N 240 12010 280 12010 {
lab=word200}
N 280 12010 320 12010 {
lab=word200}
N 250 12000 250 12050 {
lab=GND}
N 250 12050 250 12060 {
lab=GND}
N 310 12000 310 12050 {
lab=Y3}
N 310 12050 310 12060 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 12030 1 0 {name=M887
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 12060 360 12060 {
lab=GND}
N 360 12050 360 12060 {
lab=GND}
N 320 12010 360 12010 {
lab=word200}
N 360 12010 400 12010 {
lab=word200}
N 330 12000 330 12050 {
lab=GND}
N 330 12050 330 12060 {
lab=GND}
N 390 12000 390 12050 {
lab=Y4}
N 390 12050 390 12060 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 12030 1 0 {name=M888
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 12060 440 12060 {
lab=GND}
N 440 12050 440 12060 {
lab=GND}
N 400 12010 440 12010 {
lab=word200}
N 440 12010 480 12010 {
lab=word200}
N 410 12000 410 12050 {
lab=GND}
N 410 12050 410 12060 {
lab=GND}
N 470 12000 470 12050 {
lab=Y5}
N 470 12050 470 12060 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 12030 1 0 {name=M889
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 12060 520 12060 {
lab=GND}
N 520 12050 520 12060 {
lab=GND}
N 480 12010 520 12010 {
lab=word200}
N 520 12010 560 12010 {
lab=word200}
N 490 12000 490 12050 {
lab=GND}
N 490 12050 490 12060 {
lab=GND}
N 550 12000 550 12050 {
lab=Y6}
N 550 12050 550 12060 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12030 1 0 {name=M890
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12060 600 12060 {
lab=GND}
N 600 12050 600 12060 {
lab=GND}
N 560 12010 600 12010 {
lab=word200}
N 600 12010 640 12010 {
lab=word200}
N 570 12000 570 12050 {
lab=GND}
N 570 12050 570 12060 {
lab=GND}
N 630 12000 630 12050 {
lab=Y7}
N 630 12050 630 12060 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12030 1 0 {name=M891
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12070 0 0 {name=p224 lab=word201}

N 10 12120 40 12120 {
lab=GND}
N 40 12110 40 12120 {
lab=GND}
N 0 12070 40 12070 {
lab=word201}
N 40 12070 80 12070 {
lab=word201}
N 10 12060 10 12110 {
lab=GND}
N 10 12110 10 12120 {
lab=GND}
N 70 12060 70 12110 {
lab=Y0}
N 70 12110 70 12120 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12090 1 0 {name=M892
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 12120 120 12120 {
lab=GND}
N 120 12110 120 12120 {
lab=GND}
N 80 12070 120 12070 {
lab=word201}
N 120 12070 160 12070 {
lab=word201}
N 90 12060 90 12110 {
lab=GND}
N 90 12110 90 12120 {
lab=GND}
N 150 12060 150 12110 {
lab=Y1}
N 150 12110 150 12120 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 12090 1 0 {name=M893
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 12070 200 12070 {
lab=word201}
N 200 12070 240 12070 {
lab=word201}
N 170 12060 170 12110 {
lab=GND}
N 170 12110 170 12120 {
lab=GND}
N 230 12060 230 12110 {
lab=Y2}
N 230 12110 230 12120 {
lab=Y2}

N 250 12120 280 12120 {
lab=GND}
N 280 12110 280 12120 {
lab=GND}
N 240 12070 280 12070 {
lab=word201}
N 280 12070 320 12070 {
lab=word201}
N 250 12060 250 12110 {
lab=GND}
N 250 12110 250 12120 {
lab=GND}
N 310 12060 310 12110 {
lab=Y3}
N 310 12110 310 12120 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 12090 1 0 {name=M894
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 12120 360 12120 {
lab=GND}
N 360 12110 360 12120 {
lab=GND}
N 320 12070 360 12070 {
lab=word201}
N 360 12070 400 12070 {
lab=word201}
N 330 12060 330 12110 {
lab=GND}
N 330 12110 330 12120 {
lab=GND}
N 390 12060 390 12110 {
lab=Y4}
N 390 12110 390 12120 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 12090 1 0 {name=M895
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 12070 440 12070 {
lab=word201}
N 440 12070 480 12070 {
lab=word201}
N 410 12060 410 12110 {
lab=GND}
N 410 12110 410 12120 {
lab=GND}
N 470 12060 470 12110 {
lab=Y5}
N 470 12110 470 12120 {
lab=Y5}

N 490 12120 520 12120 {
lab=GND}
N 520 12110 520 12120 {
lab=GND}
N 480 12070 520 12070 {
lab=word201}
N 520 12070 560 12070 {
lab=word201}
N 490 12060 490 12110 {
lab=GND}
N 490 12110 490 12120 {
lab=GND}
N 550 12060 550 12110 {
lab=Y6}
N 550 12110 550 12120 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12090 1 0 {name=M896
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12120 600 12120 {
lab=GND}
N 600 12110 600 12120 {
lab=GND}
N 560 12070 600 12070 {
lab=word201}
N 600 12070 640 12070 {
lab=word201}
N 570 12060 570 12110 {
lab=GND}
N 570 12110 570 12120 {
lab=GND}
N 630 12060 630 12110 {
lab=Y7}
N 630 12110 630 12120 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12090 1 0 {name=M897
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12130 0 0 {name=p225 lab=word202}

N 10 12180 40 12180 {
lab=GND}
N 40 12170 40 12180 {
lab=GND}
N 0 12130 40 12130 {
lab=word202}
N 40 12130 80 12130 {
lab=word202}
N 10 12120 10 12170 {
lab=GND}
N 10 12170 10 12180 {
lab=GND}
N 70 12120 70 12170 {
lab=Y0}
N 70 12170 70 12180 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12150 1 0 {name=M898
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 12180 120 12180 {
lab=GND}
N 120 12170 120 12180 {
lab=GND}
N 80 12130 120 12130 {
lab=word202}
N 120 12130 160 12130 {
lab=word202}
N 90 12120 90 12170 {
lab=GND}
N 90 12170 90 12180 {
lab=GND}
N 150 12120 150 12170 {
lab=Y1}
N 150 12170 150 12180 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 12150 1 0 {name=M899
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 12130 200 12130 {
lab=word202}
N 200 12130 240 12130 {
lab=word202}
N 170 12120 170 12170 {
lab=GND}
N 170 12170 170 12180 {
lab=GND}
N 230 12120 230 12170 {
lab=Y2}
N 230 12170 230 12180 {
lab=Y2}

N 250 12180 280 12180 {
lab=GND}
N 280 12170 280 12180 {
lab=GND}
N 240 12130 280 12130 {
lab=word202}
N 280 12130 320 12130 {
lab=word202}
N 250 12120 250 12170 {
lab=GND}
N 250 12170 250 12180 {
lab=GND}
N 310 12120 310 12170 {
lab=Y3}
N 310 12170 310 12180 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 12150 1 0 {name=M900
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 12130 360 12130 {
lab=word202}
N 360 12130 400 12130 {
lab=word202}
N 330 12120 330 12170 {
lab=GND}
N 330 12170 330 12180 {
lab=GND}
N 390 12120 390 12170 {
lab=Y4}
N 390 12170 390 12180 {
lab=Y4}

N 410 12180 440 12180 {
lab=GND}
N 440 12170 440 12180 {
lab=GND}
N 400 12130 440 12130 {
lab=word202}
N 440 12130 480 12130 {
lab=word202}
N 410 12120 410 12170 {
lab=GND}
N 410 12170 410 12180 {
lab=GND}
N 470 12120 470 12170 {
lab=Y5}
N 470 12170 470 12180 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 12150 1 0 {name=M901
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 12180 520 12180 {
lab=GND}
N 520 12170 520 12180 {
lab=GND}
N 480 12130 520 12130 {
lab=word202}
N 520 12130 560 12130 {
lab=word202}
N 490 12120 490 12170 {
lab=GND}
N 490 12170 490 12180 {
lab=GND}
N 550 12120 550 12170 {
lab=Y6}
N 550 12170 550 12180 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12150 1 0 {name=M902
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12180 600 12180 {
lab=GND}
N 600 12170 600 12180 {
lab=GND}
N 560 12130 600 12130 {
lab=word202}
N 600 12130 640 12130 {
lab=word202}
N 570 12120 570 12170 {
lab=GND}
N 570 12170 570 12180 {
lab=GND}
N 630 12120 630 12170 {
lab=Y7}
N 630 12170 630 12180 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12150 1 0 {name=M903
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12190 0 0 {name=p226 lab=word203}

N 10 12240 40 12240 {
lab=GND}
N 40 12230 40 12240 {
lab=GND}
N 0 12190 40 12190 {
lab=word203}
N 40 12190 80 12190 {
lab=word203}
N 10 12180 10 12230 {
lab=GND}
N 10 12230 10 12240 {
lab=GND}
N 70 12180 70 12230 {
lab=Y0}
N 70 12230 70 12240 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12210 1 0 {name=M904
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 12240 120 12240 {
lab=GND}
N 120 12230 120 12240 {
lab=GND}
N 80 12190 120 12190 {
lab=word203}
N 120 12190 160 12190 {
lab=word203}
N 90 12180 90 12230 {
lab=GND}
N 90 12230 90 12240 {
lab=GND}
N 150 12180 150 12230 {
lab=Y1}
N 150 12230 150 12240 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 12210 1 0 {name=M905
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 12190 200 12190 {
lab=word203}
N 200 12190 240 12190 {
lab=word203}
N 170 12180 170 12230 {
lab=GND}
N 170 12230 170 12240 {
lab=GND}
N 230 12180 230 12230 {
lab=Y2}
N 230 12230 230 12240 {
lab=Y2}

N 250 12240 280 12240 {
lab=GND}
N 280 12230 280 12240 {
lab=GND}
N 240 12190 280 12190 {
lab=word203}
N 280 12190 320 12190 {
lab=word203}
N 250 12180 250 12230 {
lab=GND}
N 250 12230 250 12240 {
lab=GND}
N 310 12180 310 12230 {
lab=Y3}
N 310 12230 310 12240 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 12210 1 0 {name=M906
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 12190 360 12190 {
lab=word203}
N 360 12190 400 12190 {
lab=word203}
N 330 12180 330 12230 {
lab=GND}
N 330 12230 330 12240 {
lab=GND}
N 390 12180 390 12230 {
lab=Y4}
N 390 12230 390 12240 {
lab=Y4}
N 400 12190 440 12190 {
lab=word203}
N 440 12190 480 12190 {
lab=word203}
N 410 12180 410 12230 {
lab=GND}
N 410 12230 410 12240 {
lab=GND}
N 470 12180 470 12230 {
lab=Y5}
N 470 12230 470 12240 {
lab=Y5}

N 490 12240 520 12240 {
lab=GND}
N 520 12230 520 12240 {
lab=GND}
N 480 12190 520 12190 {
lab=word203}
N 520 12190 560 12190 {
lab=word203}
N 490 12180 490 12230 {
lab=GND}
N 490 12230 490 12240 {
lab=GND}
N 550 12180 550 12230 {
lab=Y6}
N 550 12230 550 12240 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12210 1 0 {name=M907
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12240 600 12240 {
lab=GND}
N 600 12230 600 12240 {
lab=GND}
N 560 12190 600 12190 {
lab=word203}
N 600 12190 640 12190 {
lab=word203}
N 570 12180 570 12230 {
lab=GND}
N 570 12230 570 12240 {
lab=GND}
N 630 12180 630 12230 {
lab=Y7}
N 630 12230 630 12240 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12210 1 0 {name=M908
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12250 0 0 {name=p227 lab=word204}

N 10 12300 40 12300 {
lab=GND}
N 40 12290 40 12300 {
lab=GND}
N 0 12250 40 12250 {
lab=word204}
N 40 12250 80 12250 {
lab=word204}
N 10 12240 10 12290 {
lab=GND}
N 10 12290 10 12300 {
lab=GND}
N 70 12240 70 12290 {
lab=Y0}
N 70 12290 70 12300 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12270 1 0 {name=M909
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 12300 120 12300 {
lab=GND}
N 120 12290 120 12300 {
lab=GND}
N 80 12250 120 12250 {
lab=word204}
N 120 12250 160 12250 {
lab=word204}
N 90 12240 90 12290 {
lab=GND}
N 90 12290 90 12300 {
lab=GND}
N 150 12240 150 12290 {
lab=Y1}
N 150 12290 150 12300 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 12270 1 0 {name=M910
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 12250 200 12250 {
lab=word204}
N 200 12250 240 12250 {
lab=word204}
N 170 12240 170 12290 {
lab=GND}
N 170 12290 170 12300 {
lab=GND}
N 230 12240 230 12290 {
lab=Y2}
N 230 12290 230 12300 {
lab=Y2}
N 240 12250 280 12250 {
lab=word204}
N 280 12250 320 12250 {
lab=word204}
N 250 12240 250 12290 {
lab=GND}
N 250 12290 250 12300 {
lab=GND}
N 310 12240 310 12290 {
lab=Y3}
N 310 12290 310 12300 {
lab=Y3}

N 330 12300 360 12300 {
lab=GND}
N 360 12290 360 12300 {
lab=GND}
N 320 12250 360 12250 {
lab=word204}
N 360 12250 400 12250 {
lab=word204}
N 330 12240 330 12290 {
lab=GND}
N 330 12290 330 12300 {
lab=GND}
N 390 12240 390 12290 {
lab=Y4}
N 390 12290 390 12300 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 12270 1 0 {name=M911
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 12300 440 12300 {
lab=GND}
N 440 12290 440 12300 {
lab=GND}
N 400 12250 440 12250 {
lab=word204}
N 440 12250 480 12250 {
lab=word204}
N 410 12240 410 12290 {
lab=GND}
N 410 12290 410 12300 {
lab=GND}
N 470 12240 470 12290 {
lab=Y5}
N 470 12290 470 12300 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 12270 1 0 {name=M912
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 12300 520 12300 {
lab=GND}
N 520 12290 520 12300 {
lab=GND}
N 480 12250 520 12250 {
lab=word204}
N 520 12250 560 12250 {
lab=word204}
N 490 12240 490 12290 {
lab=GND}
N 490 12290 490 12300 {
lab=GND}
N 550 12240 550 12290 {
lab=Y6}
N 550 12290 550 12300 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12270 1 0 {name=M913
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12300 600 12300 {
lab=GND}
N 600 12290 600 12300 {
lab=GND}
N 560 12250 600 12250 {
lab=word204}
N 600 12250 640 12250 {
lab=word204}
N 570 12240 570 12290 {
lab=GND}
N 570 12290 570 12300 {
lab=GND}
N 630 12240 630 12290 {
lab=Y7}
N 630 12290 630 12300 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12270 1 0 {name=M914
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12310 0 0 {name=p228 lab=word205}

N 10 12360 40 12360 {
lab=GND}
N 40 12350 40 12360 {
lab=GND}
N 0 12310 40 12310 {
lab=word205}
N 40 12310 80 12310 {
lab=word205}
N 10 12300 10 12350 {
lab=GND}
N 10 12350 10 12360 {
lab=GND}
N 70 12300 70 12350 {
lab=Y0}
N 70 12350 70 12360 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12330 1 0 {name=M915
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 12360 120 12360 {
lab=GND}
N 120 12350 120 12360 {
lab=GND}
N 80 12310 120 12310 {
lab=word205}
N 120 12310 160 12310 {
lab=word205}
N 90 12300 90 12350 {
lab=GND}
N 90 12350 90 12360 {
lab=GND}
N 150 12300 150 12350 {
lab=Y1}
N 150 12350 150 12360 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 12330 1 0 {name=M916
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 12310 200 12310 {
lab=word205}
N 200 12310 240 12310 {
lab=word205}
N 170 12300 170 12350 {
lab=GND}
N 170 12350 170 12360 {
lab=GND}
N 230 12300 230 12350 {
lab=Y2}
N 230 12350 230 12360 {
lab=Y2}
N 240 12310 280 12310 {
lab=word205}
N 280 12310 320 12310 {
lab=word205}
N 250 12300 250 12350 {
lab=GND}
N 250 12350 250 12360 {
lab=GND}
N 310 12300 310 12350 {
lab=Y3}
N 310 12350 310 12360 {
lab=Y3}

N 330 12360 360 12360 {
lab=GND}
N 360 12350 360 12360 {
lab=GND}
N 320 12310 360 12310 {
lab=word205}
N 360 12310 400 12310 {
lab=word205}
N 330 12300 330 12350 {
lab=GND}
N 330 12350 330 12360 {
lab=GND}
N 390 12300 390 12350 {
lab=Y4}
N 390 12350 390 12360 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 12330 1 0 {name=M917
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 12310 440 12310 {
lab=word205}
N 440 12310 480 12310 {
lab=word205}
N 410 12300 410 12350 {
lab=GND}
N 410 12350 410 12360 {
lab=GND}
N 470 12300 470 12350 {
lab=Y5}
N 470 12350 470 12360 {
lab=Y5}

N 490 12360 520 12360 {
lab=GND}
N 520 12350 520 12360 {
lab=GND}
N 480 12310 520 12310 {
lab=word205}
N 520 12310 560 12310 {
lab=word205}
N 490 12300 490 12350 {
lab=GND}
N 490 12350 490 12360 {
lab=GND}
N 550 12300 550 12350 {
lab=Y6}
N 550 12350 550 12360 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12330 1 0 {name=M918
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12360 600 12360 {
lab=GND}
N 600 12350 600 12360 {
lab=GND}
N 560 12310 600 12310 {
lab=word205}
N 600 12310 640 12310 {
lab=word205}
N 570 12300 570 12350 {
lab=GND}
N 570 12350 570 12360 {
lab=GND}
N 630 12300 630 12350 {
lab=Y7}
N 630 12350 630 12360 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12330 1 0 {name=M919
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12370 0 0 {name=p229 lab=word206}

N 10 12420 40 12420 {
lab=GND}
N 40 12410 40 12420 {
lab=GND}
N 0 12370 40 12370 {
lab=word206}
N 40 12370 80 12370 {
lab=word206}
N 10 12360 10 12410 {
lab=GND}
N 10 12410 10 12420 {
lab=GND}
N 70 12360 70 12410 {
lab=Y0}
N 70 12410 70 12420 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12390 1 0 {name=M920
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 12420 120 12420 {
lab=GND}
N 120 12410 120 12420 {
lab=GND}
N 80 12370 120 12370 {
lab=word206}
N 120 12370 160 12370 {
lab=word206}
N 90 12360 90 12410 {
lab=GND}
N 90 12410 90 12420 {
lab=GND}
N 150 12360 150 12410 {
lab=Y1}
N 150 12410 150 12420 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 12390 1 0 {name=M921
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 12370 200 12370 {
lab=word206}
N 200 12370 240 12370 {
lab=word206}
N 170 12360 170 12410 {
lab=GND}
N 170 12410 170 12420 {
lab=GND}
N 230 12360 230 12410 {
lab=Y2}
N 230 12410 230 12420 {
lab=Y2}
N 240 12370 280 12370 {
lab=word206}
N 280 12370 320 12370 {
lab=word206}
N 250 12360 250 12410 {
lab=GND}
N 250 12410 250 12420 {
lab=GND}
N 310 12360 310 12410 {
lab=Y3}
N 310 12410 310 12420 {
lab=Y3}
N 320 12370 360 12370 {
lab=word206}
N 360 12370 400 12370 {
lab=word206}
N 330 12360 330 12410 {
lab=GND}
N 330 12410 330 12420 {
lab=GND}
N 390 12360 390 12410 {
lab=Y4}
N 390 12410 390 12420 {
lab=Y4}

N 410 12420 440 12420 {
lab=GND}
N 440 12410 440 12420 {
lab=GND}
N 400 12370 440 12370 {
lab=word206}
N 440 12370 480 12370 {
lab=word206}
N 410 12360 410 12410 {
lab=GND}
N 410 12410 410 12420 {
lab=GND}
N 470 12360 470 12410 {
lab=Y5}
N 470 12410 470 12420 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 12390 1 0 {name=M922
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 12420 520 12420 {
lab=GND}
N 520 12410 520 12420 {
lab=GND}
N 480 12370 520 12370 {
lab=word206}
N 520 12370 560 12370 {
lab=word206}
N 490 12360 490 12410 {
lab=GND}
N 490 12410 490 12420 {
lab=GND}
N 550 12360 550 12410 {
lab=Y6}
N 550 12410 550 12420 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12390 1 0 {name=M923
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12420 600 12420 {
lab=GND}
N 600 12410 600 12420 {
lab=GND}
N 560 12370 600 12370 {
lab=word206}
N 600 12370 640 12370 {
lab=word206}
N 570 12360 570 12410 {
lab=GND}
N 570 12410 570 12420 {
lab=GND}
N 630 12360 630 12410 {
lab=Y7}
N 630 12410 630 12420 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12390 1 0 {name=M924
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12430 0 0 {name=p230 lab=word207}

N 10 12480 40 12480 {
lab=GND}
N 40 12470 40 12480 {
lab=GND}
N 0 12430 40 12430 {
lab=word207}
N 40 12430 80 12430 {
lab=word207}
N 10 12420 10 12470 {
lab=GND}
N 10 12470 10 12480 {
lab=GND}
N 70 12420 70 12470 {
lab=Y0}
N 70 12470 70 12480 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12450 1 0 {name=M925
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 12480 120 12480 {
lab=GND}
N 120 12470 120 12480 {
lab=GND}
N 80 12430 120 12430 {
lab=word207}
N 120 12430 160 12430 {
lab=word207}
N 90 12420 90 12470 {
lab=GND}
N 90 12470 90 12480 {
lab=GND}
N 150 12420 150 12470 {
lab=Y1}
N 150 12470 150 12480 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 12450 1 0 {name=M926
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 12430 200 12430 {
lab=word207}
N 200 12430 240 12430 {
lab=word207}
N 170 12420 170 12470 {
lab=GND}
N 170 12470 170 12480 {
lab=GND}
N 230 12420 230 12470 {
lab=Y2}
N 230 12470 230 12480 {
lab=Y2}
N 240 12430 280 12430 {
lab=word207}
N 280 12430 320 12430 {
lab=word207}
N 250 12420 250 12470 {
lab=GND}
N 250 12470 250 12480 {
lab=GND}
N 310 12420 310 12470 {
lab=Y3}
N 310 12470 310 12480 {
lab=Y3}
N 320 12430 360 12430 {
lab=word207}
N 360 12430 400 12430 {
lab=word207}
N 330 12420 330 12470 {
lab=GND}
N 330 12470 330 12480 {
lab=GND}
N 390 12420 390 12470 {
lab=Y4}
N 390 12470 390 12480 {
lab=Y4}
N 400 12430 440 12430 {
lab=word207}
N 440 12430 480 12430 {
lab=word207}
N 410 12420 410 12470 {
lab=GND}
N 410 12470 410 12480 {
lab=GND}
N 470 12420 470 12470 {
lab=Y5}
N 470 12470 470 12480 {
lab=Y5}

N 490 12480 520 12480 {
lab=GND}
N 520 12470 520 12480 {
lab=GND}
N 480 12430 520 12430 {
lab=word207}
N 520 12430 560 12430 {
lab=word207}
N 490 12420 490 12470 {
lab=GND}
N 490 12470 490 12480 {
lab=GND}
N 550 12420 550 12470 {
lab=Y6}
N 550 12470 550 12480 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12450 1 0 {name=M927
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12480 600 12480 {
lab=GND}
N 600 12470 600 12480 {
lab=GND}
N 560 12430 600 12430 {
lab=word207}
N 600 12430 640 12430 {
lab=word207}
N 570 12420 570 12470 {
lab=GND}
N 570 12470 570 12480 {
lab=GND}
N 630 12420 630 12470 {
lab=Y7}
N 630 12470 630 12480 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12450 1 0 {name=M928
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12490 0 0 {name=p231 lab=word208}

N 10 12540 40 12540 {
lab=GND}
N 40 12530 40 12540 {
lab=GND}
N 0 12490 40 12490 {
lab=word208}
N 40 12490 80 12490 {
lab=word208}
N 10 12480 10 12530 {
lab=GND}
N 10 12530 10 12540 {
lab=GND}
N 70 12480 70 12530 {
lab=Y0}
N 70 12530 70 12540 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12510 1 0 {name=M929
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 12490 120 12490 {
lab=word208}
N 120 12490 160 12490 {
lab=word208}
N 90 12480 90 12530 {
lab=GND}
N 90 12530 90 12540 {
lab=GND}
N 150 12480 150 12530 {
lab=Y1}
N 150 12530 150 12540 {
lab=Y1}

N 170 12540 200 12540 {
lab=GND}
N 200 12530 200 12540 {
lab=GND}
N 160 12490 200 12490 {
lab=word208}
N 200 12490 240 12490 {
lab=word208}
N 170 12480 170 12530 {
lab=GND}
N 170 12530 170 12540 {
lab=GND}
N 230 12480 230 12530 {
lab=Y2}
N 230 12530 230 12540 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 12510 1 0 {name=M930
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 12540 280 12540 {
lab=GND}
N 280 12530 280 12540 {
lab=GND}
N 240 12490 280 12490 {
lab=word208}
N 280 12490 320 12490 {
lab=word208}
N 250 12480 250 12530 {
lab=GND}
N 250 12530 250 12540 {
lab=GND}
N 310 12480 310 12530 {
lab=Y3}
N 310 12530 310 12540 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 12510 1 0 {name=M931
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 12540 360 12540 {
lab=GND}
N 360 12530 360 12540 {
lab=GND}
N 320 12490 360 12490 {
lab=word208}
N 360 12490 400 12490 {
lab=word208}
N 330 12480 330 12530 {
lab=GND}
N 330 12530 330 12540 {
lab=GND}
N 390 12480 390 12530 {
lab=Y4}
N 390 12530 390 12540 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 12510 1 0 {name=M932
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 12540 440 12540 {
lab=GND}
N 440 12530 440 12540 {
lab=GND}
N 400 12490 440 12490 {
lab=word208}
N 440 12490 480 12490 {
lab=word208}
N 410 12480 410 12530 {
lab=GND}
N 410 12530 410 12540 {
lab=GND}
N 470 12480 470 12530 {
lab=Y5}
N 470 12530 470 12540 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 12510 1 0 {name=M933
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 12540 520 12540 {
lab=GND}
N 520 12530 520 12540 {
lab=GND}
N 480 12490 520 12490 {
lab=word208}
N 520 12490 560 12490 {
lab=word208}
N 490 12480 490 12530 {
lab=GND}
N 490 12530 490 12540 {
lab=GND}
N 550 12480 550 12530 {
lab=Y6}
N 550 12530 550 12540 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12510 1 0 {name=M934
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12540 600 12540 {
lab=GND}
N 600 12530 600 12540 {
lab=GND}
N 560 12490 600 12490 {
lab=word208}
N 600 12490 640 12490 {
lab=word208}
N 570 12480 570 12530 {
lab=GND}
N 570 12530 570 12540 {
lab=GND}
N 630 12480 630 12530 {
lab=Y7}
N 630 12530 630 12540 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12510 1 0 {name=M935
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12550 0 0 {name=p232 lab=word209}

N 10 12600 40 12600 {
lab=GND}
N 40 12590 40 12600 {
lab=GND}
N 0 12550 40 12550 {
lab=word209}
N 40 12550 80 12550 {
lab=word209}
N 10 12540 10 12590 {
lab=GND}
N 10 12590 10 12600 {
lab=GND}
N 70 12540 70 12590 {
lab=Y0}
N 70 12590 70 12600 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12570 1 0 {name=M936
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 12550 120 12550 {
lab=word209}
N 120 12550 160 12550 {
lab=word209}
N 90 12540 90 12590 {
lab=GND}
N 90 12590 90 12600 {
lab=GND}
N 150 12540 150 12590 {
lab=Y1}
N 150 12590 150 12600 {
lab=Y1}

N 170 12600 200 12600 {
lab=GND}
N 200 12590 200 12600 {
lab=GND}
N 160 12550 200 12550 {
lab=word209}
N 200 12550 240 12550 {
lab=word209}
N 170 12540 170 12590 {
lab=GND}
N 170 12590 170 12600 {
lab=GND}
N 230 12540 230 12590 {
lab=Y2}
N 230 12590 230 12600 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 12570 1 0 {name=M937
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 12600 280 12600 {
lab=GND}
N 280 12590 280 12600 {
lab=GND}
N 240 12550 280 12550 {
lab=word209}
N 280 12550 320 12550 {
lab=word209}
N 250 12540 250 12590 {
lab=GND}
N 250 12590 250 12600 {
lab=GND}
N 310 12540 310 12590 {
lab=Y3}
N 310 12590 310 12600 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 12570 1 0 {name=M938
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 12600 360 12600 {
lab=GND}
N 360 12590 360 12600 {
lab=GND}
N 320 12550 360 12550 {
lab=word209}
N 360 12550 400 12550 {
lab=word209}
N 330 12540 330 12590 {
lab=GND}
N 330 12590 330 12600 {
lab=GND}
N 390 12540 390 12590 {
lab=Y4}
N 390 12590 390 12600 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 12570 1 0 {name=M939
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 12550 440 12550 {
lab=word209}
N 440 12550 480 12550 {
lab=word209}
N 410 12540 410 12590 {
lab=GND}
N 410 12590 410 12600 {
lab=GND}
N 470 12540 470 12590 {
lab=Y5}
N 470 12590 470 12600 {
lab=Y5}

N 490 12600 520 12600 {
lab=GND}
N 520 12590 520 12600 {
lab=GND}
N 480 12550 520 12550 {
lab=word209}
N 520 12550 560 12550 {
lab=word209}
N 490 12540 490 12590 {
lab=GND}
N 490 12590 490 12600 {
lab=GND}
N 550 12540 550 12590 {
lab=Y6}
N 550 12590 550 12600 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12570 1 0 {name=M940
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12600 600 12600 {
lab=GND}
N 600 12590 600 12600 {
lab=GND}
N 560 12550 600 12550 {
lab=word209}
N 600 12550 640 12550 {
lab=word209}
N 570 12540 570 12590 {
lab=GND}
N 570 12590 570 12600 {
lab=GND}
N 630 12540 630 12590 {
lab=Y7}
N 630 12590 630 12600 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12570 1 0 {name=M941
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12610 0 0 {name=p233 lab=word210}

N 10 12660 40 12660 {
lab=GND}
N 40 12650 40 12660 {
lab=GND}
N 0 12610 40 12610 {
lab=word210}
N 40 12610 80 12610 {
lab=word210}
N 10 12600 10 12650 {
lab=GND}
N 10 12650 10 12660 {
lab=GND}
N 70 12600 70 12650 {
lab=Y0}
N 70 12650 70 12660 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12630 1 0 {name=M942
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 12610 120 12610 {
lab=word210}
N 120 12610 160 12610 {
lab=word210}
N 90 12600 90 12650 {
lab=GND}
N 90 12650 90 12660 {
lab=GND}
N 150 12600 150 12650 {
lab=Y1}
N 150 12650 150 12660 {
lab=Y1}

N 170 12660 200 12660 {
lab=GND}
N 200 12650 200 12660 {
lab=GND}
N 160 12610 200 12610 {
lab=word210}
N 200 12610 240 12610 {
lab=word210}
N 170 12600 170 12650 {
lab=GND}
N 170 12650 170 12660 {
lab=GND}
N 230 12600 230 12650 {
lab=Y2}
N 230 12650 230 12660 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 12630 1 0 {name=M943
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 12660 280 12660 {
lab=GND}
N 280 12650 280 12660 {
lab=GND}
N 240 12610 280 12610 {
lab=word210}
N 280 12610 320 12610 {
lab=word210}
N 250 12600 250 12650 {
lab=GND}
N 250 12650 250 12660 {
lab=GND}
N 310 12600 310 12650 {
lab=Y3}
N 310 12650 310 12660 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 12630 1 0 {name=M944
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 12610 360 12610 {
lab=word210}
N 360 12610 400 12610 {
lab=word210}
N 330 12600 330 12650 {
lab=GND}
N 330 12650 330 12660 {
lab=GND}
N 390 12600 390 12650 {
lab=Y4}
N 390 12650 390 12660 {
lab=Y4}

N 410 12660 440 12660 {
lab=GND}
N 440 12650 440 12660 {
lab=GND}
N 400 12610 440 12610 {
lab=word210}
N 440 12610 480 12610 {
lab=word210}
N 410 12600 410 12650 {
lab=GND}
N 410 12650 410 12660 {
lab=GND}
N 470 12600 470 12650 {
lab=Y5}
N 470 12650 470 12660 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 12630 1 0 {name=M945
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 12660 520 12660 {
lab=GND}
N 520 12650 520 12660 {
lab=GND}
N 480 12610 520 12610 {
lab=word210}
N 520 12610 560 12610 {
lab=word210}
N 490 12600 490 12650 {
lab=GND}
N 490 12650 490 12660 {
lab=GND}
N 550 12600 550 12650 {
lab=Y6}
N 550 12650 550 12660 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12630 1 0 {name=M946
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12660 600 12660 {
lab=GND}
N 600 12650 600 12660 {
lab=GND}
N 560 12610 600 12610 {
lab=word210}
N 600 12610 640 12610 {
lab=word210}
N 570 12600 570 12650 {
lab=GND}
N 570 12650 570 12660 {
lab=GND}
N 630 12600 630 12650 {
lab=Y7}
N 630 12650 630 12660 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12630 1 0 {name=M947
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12670 0 0 {name=p234 lab=word211}

N 10 12720 40 12720 {
lab=GND}
N 40 12710 40 12720 {
lab=GND}
N 0 12670 40 12670 {
lab=word211}
N 40 12670 80 12670 {
lab=word211}
N 10 12660 10 12710 {
lab=GND}
N 10 12710 10 12720 {
lab=GND}
N 70 12660 70 12710 {
lab=Y0}
N 70 12710 70 12720 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12690 1 0 {name=M948
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 12670 120 12670 {
lab=word211}
N 120 12670 160 12670 {
lab=word211}
N 90 12660 90 12710 {
lab=GND}
N 90 12710 90 12720 {
lab=GND}
N 150 12660 150 12710 {
lab=Y1}
N 150 12710 150 12720 {
lab=Y1}

N 170 12720 200 12720 {
lab=GND}
N 200 12710 200 12720 {
lab=GND}
N 160 12670 200 12670 {
lab=word211}
N 200 12670 240 12670 {
lab=word211}
N 170 12660 170 12710 {
lab=GND}
N 170 12710 170 12720 {
lab=GND}
N 230 12660 230 12710 {
lab=Y2}
N 230 12710 230 12720 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 12690 1 0 {name=M949
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 12720 280 12720 {
lab=GND}
N 280 12710 280 12720 {
lab=GND}
N 240 12670 280 12670 {
lab=word211}
N 280 12670 320 12670 {
lab=word211}
N 250 12660 250 12710 {
lab=GND}
N 250 12710 250 12720 {
lab=GND}
N 310 12660 310 12710 {
lab=Y3}
N 310 12710 310 12720 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 12690 1 0 {name=M950
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 12670 360 12670 {
lab=word211}
N 360 12670 400 12670 {
lab=word211}
N 330 12660 330 12710 {
lab=GND}
N 330 12710 330 12720 {
lab=GND}
N 390 12660 390 12710 {
lab=Y4}
N 390 12710 390 12720 {
lab=Y4}
N 400 12670 440 12670 {
lab=word211}
N 440 12670 480 12670 {
lab=word211}
N 410 12660 410 12710 {
lab=GND}
N 410 12710 410 12720 {
lab=GND}
N 470 12660 470 12710 {
lab=Y5}
N 470 12710 470 12720 {
lab=Y5}

N 490 12720 520 12720 {
lab=GND}
N 520 12710 520 12720 {
lab=GND}
N 480 12670 520 12670 {
lab=word211}
N 520 12670 560 12670 {
lab=word211}
N 490 12660 490 12710 {
lab=GND}
N 490 12710 490 12720 {
lab=GND}
N 550 12660 550 12710 {
lab=Y6}
N 550 12710 550 12720 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12690 1 0 {name=M951
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12720 600 12720 {
lab=GND}
N 600 12710 600 12720 {
lab=GND}
N 560 12670 600 12670 {
lab=word211}
N 600 12670 640 12670 {
lab=word211}
N 570 12660 570 12710 {
lab=GND}
N 570 12710 570 12720 {
lab=GND}
N 630 12660 630 12710 {
lab=Y7}
N 630 12710 630 12720 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12690 1 0 {name=M952
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12730 0 0 {name=p235 lab=word212}

N 10 12780 40 12780 {
lab=GND}
N 40 12770 40 12780 {
lab=GND}
N 0 12730 40 12730 {
lab=word212}
N 40 12730 80 12730 {
lab=word212}
N 10 12720 10 12770 {
lab=GND}
N 10 12770 10 12780 {
lab=GND}
N 70 12720 70 12770 {
lab=Y0}
N 70 12770 70 12780 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12750 1 0 {name=M953
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 12730 120 12730 {
lab=word212}
N 120 12730 160 12730 {
lab=word212}
N 90 12720 90 12770 {
lab=GND}
N 90 12770 90 12780 {
lab=GND}
N 150 12720 150 12770 {
lab=Y1}
N 150 12770 150 12780 {
lab=Y1}

N 170 12780 200 12780 {
lab=GND}
N 200 12770 200 12780 {
lab=GND}
N 160 12730 200 12730 {
lab=word212}
N 200 12730 240 12730 {
lab=word212}
N 170 12720 170 12770 {
lab=GND}
N 170 12770 170 12780 {
lab=GND}
N 230 12720 230 12770 {
lab=Y2}
N 230 12770 230 12780 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 12750 1 0 {name=M954
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 12730 280 12730 {
lab=word212}
N 280 12730 320 12730 {
lab=word212}
N 250 12720 250 12770 {
lab=GND}
N 250 12770 250 12780 {
lab=GND}
N 310 12720 310 12770 {
lab=Y3}
N 310 12770 310 12780 {
lab=Y3}

N 330 12780 360 12780 {
lab=GND}
N 360 12770 360 12780 {
lab=GND}
N 320 12730 360 12730 {
lab=word212}
N 360 12730 400 12730 {
lab=word212}
N 330 12720 330 12770 {
lab=GND}
N 330 12770 330 12780 {
lab=GND}
N 390 12720 390 12770 {
lab=Y4}
N 390 12770 390 12780 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 12750 1 0 {name=M955
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 12780 440 12780 {
lab=GND}
N 440 12770 440 12780 {
lab=GND}
N 400 12730 440 12730 {
lab=word212}
N 440 12730 480 12730 {
lab=word212}
N 410 12720 410 12770 {
lab=GND}
N 410 12770 410 12780 {
lab=GND}
N 470 12720 470 12770 {
lab=Y5}
N 470 12770 470 12780 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 12750 1 0 {name=M956
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 12780 520 12780 {
lab=GND}
N 520 12770 520 12780 {
lab=GND}
N 480 12730 520 12730 {
lab=word212}
N 520 12730 560 12730 {
lab=word212}
N 490 12720 490 12770 {
lab=GND}
N 490 12770 490 12780 {
lab=GND}
N 550 12720 550 12770 {
lab=Y6}
N 550 12770 550 12780 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12750 1 0 {name=M957
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12780 600 12780 {
lab=GND}
N 600 12770 600 12780 {
lab=GND}
N 560 12730 600 12730 {
lab=word212}
N 600 12730 640 12730 {
lab=word212}
N 570 12720 570 12770 {
lab=GND}
N 570 12770 570 12780 {
lab=GND}
N 630 12720 630 12770 {
lab=Y7}
N 630 12770 630 12780 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12750 1 0 {name=M958
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12790 0 0 {name=p236 lab=word213}

N 10 12840 40 12840 {
lab=GND}
N 40 12830 40 12840 {
lab=GND}
N 0 12790 40 12790 {
lab=word213}
N 40 12790 80 12790 {
lab=word213}
N 10 12780 10 12830 {
lab=GND}
N 10 12830 10 12840 {
lab=GND}
N 70 12780 70 12830 {
lab=Y0}
N 70 12830 70 12840 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12810 1 0 {name=M959
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 12790 120 12790 {
lab=word213}
N 120 12790 160 12790 {
lab=word213}
N 90 12780 90 12830 {
lab=GND}
N 90 12830 90 12840 {
lab=GND}
N 150 12780 150 12830 {
lab=Y1}
N 150 12830 150 12840 {
lab=Y1}

N 170 12840 200 12840 {
lab=GND}
N 200 12830 200 12840 {
lab=GND}
N 160 12790 200 12790 {
lab=word213}
N 200 12790 240 12790 {
lab=word213}
N 170 12780 170 12830 {
lab=GND}
N 170 12830 170 12840 {
lab=GND}
N 230 12780 230 12830 {
lab=Y2}
N 230 12830 230 12840 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 12810 1 0 {name=M960
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 12790 280 12790 {
lab=word213}
N 280 12790 320 12790 {
lab=word213}
N 250 12780 250 12830 {
lab=GND}
N 250 12830 250 12840 {
lab=GND}
N 310 12780 310 12830 {
lab=Y3}
N 310 12830 310 12840 {
lab=Y3}

N 330 12840 360 12840 {
lab=GND}
N 360 12830 360 12840 {
lab=GND}
N 320 12790 360 12790 {
lab=word213}
N 360 12790 400 12790 {
lab=word213}
N 330 12780 330 12830 {
lab=GND}
N 330 12830 330 12840 {
lab=GND}
N 390 12780 390 12830 {
lab=Y4}
N 390 12830 390 12840 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 12810 1 0 {name=M961
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 12790 440 12790 {
lab=word213}
N 440 12790 480 12790 {
lab=word213}
N 410 12780 410 12830 {
lab=GND}
N 410 12830 410 12840 {
lab=GND}
N 470 12780 470 12830 {
lab=Y5}
N 470 12830 470 12840 {
lab=Y5}

N 490 12840 520 12840 {
lab=GND}
N 520 12830 520 12840 {
lab=GND}
N 480 12790 520 12790 {
lab=word213}
N 520 12790 560 12790 {
lab=word213}
N 490 12780 490 12830 {
lab=GND}
N 490 12830 490 12840 {
lab=GND}
N 550 12780 550 12830 {
lab=Y6}
N 550 12830 550 12840 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12810 1 0 {name=M962
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12840 600 12840 {
lab=GND}
N 600 12830 600 12840 {
lab=GND}
N 560 12790 600 12790 {
lab=word213}
N 600 12790 640 12790 {
lab=word213}
N 570 12780 570 12830 {
lab=GND}
N 570 12830 570 12840 {
lab=GND}
N 630 12780 630 12830 {
lab=Y7}
N 630 12830 630 12840 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12810 1 0 {name=M963
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12850 0 0 {name=p237 lab=word214}

N 10 12900 40 12900 {
lab=GND}
N 40 12890 40 12900 {
lab=GND}
N 0 12850 40 12850 {
lab=word214}
N 40 12850 80 12850 {
lab=word214}
N 10 12840 10 12890 {
lab=GND}
N 10 12890 10 12900 {
lab=GND}
N 70 12840 70 12890 {
lab=Y0}
N 70 12890 70 12900 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12870 1 0 {name=M964
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 12850 120 12850 {
lab=word214}
N 120 12850 160 12850 {
lab=word214}
N 90 12840 90 12890 {
lab=GND}
N 90 12890 90 12900 {
lab=GND}
N 150 12840 150 12890 {
lab=Y1}
N 150 12890 150 12900 {
lab=Y1}

N 170 12900 200 12900 {
lab=GND}
N 200 12890 200 12900 {
lab=GND}
N 160 12850 200 12850 {
lab=word214}
N 200 12850 240 12850 {
lab=word214}
N 170 12840 170 12890 {
lab=GND}
N 170 12890 170 12900 {
lab=GND}
N 230 12840 230 12890 {
lab=Y2}
N 230 12890 230 12900 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 12870 1 0 {name=M965
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 12850 280 12850 {
lab=word214}
N 280 12850 320 12850 {
lab=word214}
N 250 12840 250 12890 {
lab=GND}
N 250 12890 250 12900 {
lab=GND}
N 310 12840 310 12890 {
lab=Y3}
N 310 12890 310 12900 {
lab=Y3}
N 320 12850 360 12850 {
lab=word214}
N 360 12850 400 12850 {
lab=word214}
N 330 12840 330 12890 {
lab=GND}
N 330 12890 330 12900 {
lab=GND}
N 390 12840 390 12890 {
lab=Y4}
N 390 12890 390 12900 {
lab=Y4}

N 410 12900 440 12900 {
lab=GND}
N 440 12890 440 12900 {
lab=GND}
N 400 12850 440 12850 {
lab=word214}
N 440 12850 480 12850 {
lab=word214}
N 410 12840 410 12890 {
lab=GND}
N 410 12890 410 12900 {
lab=GND}
N 470 12840 470 12890 {
lab=Y5}
N 470 12890 470 12900 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 12870 1 0 {name=M966
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 12900 520 12900 {
lab=GND}
N 520 12890 520 12900 {
lab=GND}
N 480 12850 520 12850 {
lab=word214}
N 520 12850 560 12850 {
lab=word214}
N 490 12840 490 12890 {
lab=GND}
N 490 12890 490 12900 {
lab=GND}
N 550 12840 550 12890 {
lab=Y6}
N 550 12890 550 12900 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12870 1 0 {name=M967
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12900 600 12900 {
lab=GND}
N 600 12890 600 12900 {
lab=GND}
N 560 12850 600 12850 {
lab=word214}
N 600 12850 640 12850 {
lab=word214}
N 570 12840 570 12890 {
lab=GND}
N 570 12890 570 12900 {
lab=GND}
N 630 12840 630 12890 {
lab=Y7}
N 630 12890 630 12900 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12870 1 0 {name=M968
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12910 0 0 {name=p238 lab=word215}

N 10 12960 40 12960 {
lab=GND}
N 40 12950 40 12960 {
lab=GND}
N 0 12910 40 12910 {
lab=word215}
N 40 12910 80 12910 {
lab=word215}
N 10 12900 10 12950 {
lab=GND}
N 10 12950 10 12960 {
lab=GND}
N 70 12900 70 12950 {
lab=Y0}
N 70 12950 70 12960 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12930 1 0 {name=M969
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 12910 120 12910 {
lab=word215}
N 120 12910 160 12910 {
lab=word215}
N 90 12900 90 12950 {
lab=GND}
N 90 12950 90 12960 {
lab=GND}
N 150 12900 150 12950 {
lab=Y1}
N 150 12950 150 12960 {
lab=Y1}

N 170 12960 200 12960 {
lab=GND}
N 200 12950 200 12960 {
lab=GND}
N 160 12910 200 12910 {
lab=word215}
N 200 12910 240 12910 {
lab=word215}
N 170 12900 170 12950 {
lab=GND}
N 170 12950 170 12960 {
lab=GND}
N 230 12900 230 12950 {
lab=Y2}
N 230 12950 230 12960 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 12930 1 0 {name=M970
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 12910 280 12910 {
lab=word215}
N 280 12910 320 12910 {
lab=word215}
N 250 12900 250 12950 {
lab=GND}
N 250 12950 250 12960 {
lab=GND}
N 310 12900 310 12950 {
lab=Y3}
N 310 12950 310 12960 {
lab=Y3}
N 320 12910 360 12910 {
lab=word215}
N 360 12910 400 12910 {
lab=word215}
N 330 12900 330 12950 {
lab=GND}
N 330 12950 330 12960 {
lab=GND}
N 390 12900 390 12950 {
lab=Y4}
N 390 12950 390 12960 {
lab=Y4}
N 400 12910 440 12910 {
lab=word215}
N 440 12910 480 12910 {
lab=word215}
N 410 12900 410 12950 {
lab=GND}
N 410 12950 410 12960 {
lab=GND}
N 470 12900 470 12950 {
lab=Y5}
N 470 12950 470 12960 {
lab=Y5}

N 490 12960 520 12960 {
lab=GND}
N 520 12950 520 12960 {
lab=GND}
N 480 12910 520 12910 {
lab=word215}
N 520 12910 560 12910 {
lab=word215}
N 490 12900 490 12950 {
lab=GND}
N 490 12950 490 12960 {
lab=GND}
N 550 12900 550 12950 {
lab=Y6}
N 550 12950 550 12960 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12930 1 0 {name=M971
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 12960 600 12960 {
lab=GND}
N 600 12950 600 12960 {
lab=GND}
N 560 12910 600 12910 {
lab=word215}
N 600 12910 640 12910 {
lab=word215}
N 570 12900 570 12950 {
lab=GND}
N 570 12950 570 12960 {
lab=GND}
N 630 12900 630 12950 {
lab=Y7}
N 630 12950 630 12960 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12930 1 0 {name=M972
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 12970 0 0 {name=p239 lab=word216}

N 10 13020 40 13020 {
lab=GND}
N 40 13010 40 13020 {
lab=GND}
N 0 12970 40 12970 {
lab=word216}
N 40 12970 80 12970 {
lab=word216}
N 10 12960 10 13010 {
lab=GND}
N 10 13010 10 13020 {
lab=GND}
N 70 12960 70 13010 {
lab=Y0}
N 70 13010 70 13020 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 12990 1 0 {name=M973
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 12970 120 12970 {
lab=word216}
N 120 12970 160 12970 {
lab=word216}
N 90 12960 90 13010 {
lab=GND}
N 90 13010 90 13020 {
lab=GND}
N 150 12960 150 13010 {
lab=Y1}
N 150 13010 150 13020 {
lab=Y1}
N 160 12970 200 12970 {
lab=word216}
N 200 12970 240 12970 {
lab=word216}
N 170 12960 170 13010 {
lab=GND}
N 170 13010 170 13020 {
lab=GND}
N 230 12960 230 13010 {
lab=Y2}
N 230 13010 230 13020 {
lab=Y2}

N 250 13020 280 13020 {
lab=GND}
N 280 13010 280 13020 {
lab=GND}
N 240 12970 280 12970 {
lab=word216}
N 280 12970 320 12970 {
lab=word216}
N 250 12960 250 13010 {
lab=GND}
N 250 13010 250 13020 {
lab=GND}
N 310 12960 310 13010 {
lab=Y3}
N 310 13010 310 13020 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 12990 1 0 {name=M974
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 13020 360 13020 {
lab=GND}
N 360 13010 360 13020 {
lab=GND}
N 320 12970 360 12970 {
lab=word216}
N 360 12970 400 12970 {
lab=word216}
N 330 12960 330 13010 {
lab=GND}
N 330 13010 330 13020 {
lab=GND}
N 390 12960 390 13010 {
lab=Y4}
N 390 13010 390 13020 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 12990 1 0 {name=M975
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 13020 440 13020 {
lab=GND}
N 440 13010 440 13020 {
lab=GND}
N 400 12970 440 12970 {
lab=word216}
N 440 12970 480 12970 {
lab=word216}
N 410 12960 410 13010 {
lab=GND}
N 410 13010 410 13020 {
lab=GND}
N 470 12960 470 13010 {
lab=Y5}
N 470 13010 470 13020 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 12990 1 0 {name=M976
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 13020 520 13020 {
lab=GND}
N 520 13010 520 13020 {
lab=GND}
N 480 12970 520 12970 {
lab=word216}
N 520 12970 560 12970 {
lab=word216}
N 490 12960 490 13010 {
lab=GND}
N 490 13010 490 13020 {
lab=GND}
N 550 12960 550 13010 {
lab=Y6}
N 550 13010 550 13020 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 12990 1 0 {name=M977
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13020 600 13020 {
lab=GND}
N 600 13010 600 13020 {
lab=GND}
N 560 12970 600 12970 {
lab=word216}
N 600 12970 640 12970 {
lab=word216}
N 570 12960 570 13010 {
lab=GND}
N 570 13010 570 13020 {
lab=GND}
N 630 12960 630 13010 {
lab=Y7}
N 630 13010 630 13020 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 12990 1 0 {name=M978
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13030 0 0 {name=p240 lab=word217}

N 10 13080 40 13080 {
lab=GND}
N 40 13070 40 13080 {
lab=GND}
N 0 13030 40 13030 {
lab=word217}
N 40 13030 80 13030 {
lab=word217}
N 10 13020 10 13070 {
lab=GND}
N 10 13070 10 13080 {
lab=GND}
N 70 13020 70 13070 {
lab=Y0}
N 70 13070 70 13080 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 13050 1 0 {name=M979
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 13030 120 13030 {
lab=word217}
N 120 13030 160 13030 {
lab=word217}
N 90 13020 90 13070 {
lab=GND}
N 90 13070 90 13080 {
lab=GND}
N 150 13020 150 13070 {
lab=Y1}
N 150 13070 150 13080 {
lab=Y1}
N 160 13030 200 13030 {
lab=word217}
N 200 13030 240 13030 {
lab=word217}
N 170 13020 170 13070 {
lab=GND}
N 170 13070 170 13080 {
lab=GND}
N 230 13020 230 13070 {
lab=Y2}
N 230 13070 230 13080 {
lab=Y2}

N 250 13080 280 13080 {
lab=GND}
N 280 13070 280 13080 {
lab=GND}
N 240 13030 280 13030 {
lab=word217}
N 280 13030 320 13030 {
lab=word217}
N 250 13020 250 13070 {
lab=GND}
N 250 13070 250 13080 {
lab=GND}
N 310 13020 310 13070 {
lab=Y3}
N 310 13070 310 13080 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 13050 1 0 {name=M980
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 13080 360 13080 {
lab=GND}
N 360 13070 360 13080 {
lab=GND}
N 320 13030 360 13030 {
lab=word217}
N 360 13030 400 13030 {
lab=word217}
N 330 13020 330 13070 {
lab=GND}
N 330 13070 330 13080 {
lab=GND}
N 390 13020 390 13070 {
lab=Y4}
N 390 13070 390 13080 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 13050 1 0 {name=M981
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 13030 440 13030 {
lab=word217}
N 440 13030 480 13030 {
lab=word217}
N 410 13020 410 13070 {
lab=GND}
N 410 13070 410 13080 {
lab=GND}
N 470 13020 470 13070 {
lab=Y5}
N 470 13070 470 13080 {
lab=Y5}

N 490 13080 520 13080 {
lab=GND}
N 520 13070 520 13080 {
lab=GND}
N 480 13030 520 13030 {
lab=word217}
N 520 13030 560 13030 {
lab=word217}
N 490 13020 490 13070 {
lab=GND}
N 490 13070 490 13080 {
lab=GND}
N 550 13020 550 13070 {
lab=Y6}
N 550 13070 550 13080 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13050 1 0 {name=M982
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13080 600 13080 {
lab=GND}
N 600 13070 600 13080 {
lab=GND}
N 560 13030 600 13030 {
lab=word217}
N 600 13030 640 13030 {
lab=word217}
N 570 13020 570 13070 {
lab=GND}
N 570 13070 570 13080 {
lab=GND}
N 630 13020 630 13070 {
lab=Y7}
N 630 13070 630 13080 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13050 1 0 {name=M983
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13090 0 0 {name=p241 lab=word218}

N 10 13140 40 13140 {
lab=GND}
N 40 13130 40 13140 {
lab=GND}
N 0 13090 40 13090 {
lab=word218}
N 40 13090 80 13090 {
lab=word218}
N 10 13080 10 13130 {
lab=GND}
N 10 13130 10 13140 {
lab=GND}
N 70 13080 70 13130 {
lab=Y0}
N 70 13130 70 13140 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 13110 1 0 {name=M984
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 13090 120 13090 {
lab=word218}
N 120 13090 160 13090 {
lab=word218}
N 90 13080 90 13130 {
lab=GND}
N 90 13130 90 13140 {
lab=GND}
N 150 13080 150 13130 {
lab=Y1}
N 150 13130 150 13140 {
lab=Y1}
N 160 13090 200 13090 {
lab=word218}
N 200 13090 240 13090 {
lab=word218}
N 170 13080 170 13130 {
lab=GND}
N 170 13130 170 13140 {
lab=GND}
N 230 13080 230 13130 {
lab=Y2}
N 230 13130 230 13140 {
lab=Y2}

N 250 13140 280 13140 {
lab=GND}
N 280 13130 280 13140 {
lab=GND}
N 240 13090 280 13090 {
lab=word218}
N 280 13090 320 13090 {
lab=word218}
N 250 13080 250 13130 {
lab=GND}
N 250 13130 250 13140 {
lab=GND}
N 310 13080 310 13130 {
lab=Y3}
N 310 13130 310 13140 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 13110 1 0 {name=M985
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 13090 360 13090 {
lab=word218}
N 360 13090 400 13090 {
lab=word218}
N 330 13080 330 13130 {
lab=GND}
N 330 13130 330 13140 {
lab=GND}
N 390 13080 390 13130 {
lab=Y4}
N 390 13130 390 13140 {
lab=Y4}

N 410 13140 440 13140 {
lab=GND}
N 440 13130 440 13140 {
lab=GND}
N 400 13090 440 13090 {
lab=word218}
N 440 13090 480 13090 {
lab=word218}
N 410 13080 410 13130 {
lab=GND}
N 410 13130 410 13140 {
lab=GND}
N 470 13080 470 13130 {
lab=Y5}
N 470 13130 470 13140 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 13110 1 0 {name=M986
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 13140 520 13140 {
lab=GND}
N 520 13130 520 13140 {
lab=GND}
N 480 13090 520 13090 {
lab=word218}
N 520 13090 560 13090 {
lab=word218}
N 490 13080 490 13130 {
lab=GND}
N 490 13130 490 13140 {
lab=GND}
N 550 13080 550 13130 {
lab=Y6}
N 550 13130 550 13140 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13110 1 0 {name=M987
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13140 600 13140 {
lab=GND}
N 600 13130 600 13140 {
lab=GND}
N 560 13090 600 13090 {
lab=word218}
N 600 13090 640 13090 {
lab=word218}
N 570 13080 570 13130 {
lab=GND}
N 570 13130 570 13140 {
lab=GND}
N 630 13080 630 13130 {
lab=Y7}
N 630 13130 630 13140 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13110 1 0 {name=M988
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13150 0 0 {name=p242 lab=word219}

N 10 13200 40 13200 {
lab=GND}
N 40 13190 40 13200 {
lab=GND}
N 0 13150 40 13150 {
lab=word219}
N 40 13150 80 13150 {
lab=word219}
N 10 13140 10 13190 {
lab=GND}
N 10 13190 10 13200 {
lab=GND}
N 70 13140 70 13190 {
lab=Y0}
N 70 13190 70 13200 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 13170 1 0 {name=M989
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 13150 120 13150 {
lab=word219}
N 120 13150 160 13150 {
lab=word219}
N 90 13140 90 13190 {
lab=GND}
N 90 13190 90 13200 {
lab=GND}
N 150 13140 150 13190 {
lab=Y1}
N 150 13190 150 13200 {
lab=Y1}
N 160 13150 200 13150 {
lab=word219}
N 200 13150 240 13150 {
lab=word219}
N 170 13140 170 13190 {
lab=GND}
N 170 13190 170 13200 {
lab=GND}
N 230 13140 230 13190 {
lab=Y2}
N 230 13190 230 13200 {
lab=Y2}

N 250 13200 280 13200 {
lab=GND}
N 280 13190 280 13200 {
lab=GND}
N 240 13150 280 13150 {
lab=word219}
N 280 13150 320 13150 {
lab=word219}
N 250 13140 250 13190 {
lab=GND}
N 250 13190 250 13200 {
lab=GND}
N 310 13140 310 13190 {
lab=Y3}
N 310 13190 310 13200 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 13170 1 0 {name=M990
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 13150 360 13150 {
lab=word219}
N 360 13150 400 13150 {
lab=word219}
N 330 13140 330 13190 {
lab=GND}
N 330 13190 330 13200 {
lab=GND}
N 390 13140 390 13190 {
lab=Y4}
N 390 13190 390 13200 {
lab=Y4}
N 400 13150 440 13150 {
lab=word219}
N 440 13150 480 13150 {
lab=word219}
N 410 13140 410 13190 {
lab=GND}
N 410 13190 410 13200 {
lab=GND}
N 470 13140 470 13190 {
lab=Y5}
N 470 13190 470 13200 {
lab=Y5}

N 490 13200 520 13200 {
lab=GND}
N 520 13190 520 13200 {
lab=GND}
N 480 13150 520 13150 {
lab=word219}
N 520 13150 560 13150 {
lab=word219}
N 490 13140 490 13190 {
lab=GND}
N 490 13190 490 13200 {
lab=GND}
N 550 13140 550 13190 {
lab=Y6}
N 550 13190 550 13200 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13170 1 0 {name=M991
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13200 600 13200 {
lab=GND}
N 600 13190 600 13200 {
lab=GND}
N 560 13150 600 13150 {
lab=word219}
N 600 13150 640 13150 {
lab=word219}
N 570 13140 570 13190 {
lab=GND}
N 570 13190 570 13200 {
lab=GND}
N 630 13140 630 13190 {
lab=Y7}
N 630 13190 630 13200 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13170 1 0 {name=M992
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13210 0 0 {name=p243 lab=word220}

N 10 13260 40 13260 {
lab=GND}
N 40 13250 40 13260 {
lab=GND}
N 0 13210 40 13210 {
lab=word220}
N 40 13210 80 13210 {
lab=word220}
N 10 13200 10 13250 {
lab=GND}
N 10 13250 10 13260 {
lab=GND}
N 70 13200 70 13250 {
lab=Y0}
N 70 13250 70 13260 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 13230 1 0 {name=M993
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 13210 120 13210 {
lab=word220}
N 120 13210 160 13210 {
lab=word220}
N 90 13200 90 13250 {
lab=GND}
N 90 13250 90 13260 {
lab=GND}
N 150 13200 150 13250 {
lab=Y1}
N 150 13250 150 13260 {
lab=Y1}
N 160 13210 200 13210 {
lab=word220}
N 200 13210 240 13210 {
lab=word220}
N 170 13200 170 13250 {
lab=GND}
N 170 13250 170 13260 {
lab=GND}
N 230 13200 230 13250 {
lab=Y2}
N 230 13250 230 13260 {
lab=Y2}
N 240 13210 280 13210 {
lab=word220}
N 280 13210 320 13210 {
lab=word220}
N 250 13200 250 13250 {
lab=GND}
N 250 13250 250 13260 {
lab=GND}
N 310 13200 310 13250 {
lab=Y3}
N 310 13250 310 13260 {
lab=Y3}

N 330 13260 360 13260 {
lab=GND}
N 360 13250 360 13260 {
lab=GND}
N 320 13210 360 13210 {
lab=word220}
N 360 13210 400 13210 {
lab=word220}
N 330 13200 330 13250 {
lab=GND}
N 330 13250 330 13260 {
lab=GND}
N 390 13200 390 13250 {
lab=Y4}
N 390 13250 390 13260 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 13230 1 0 {name=M994
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 13260 440 13260 {
lab=GND}
N 440 13250 440 13260 {
lab=GND}
N 400 13210 440 13210 {
lab=word220}
N 440 13210 480 13210 {
lab=word220}
N 410 13200 410 13250 {
lab=GND}
N 410 13250 410 13260 {
lab=GND}
N 470 13200 470 13250 {
lab=Y5}
N 470 13250 470 13260 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 13230 1 0 {name=M995
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 13260 520 13260 {
lab=GND}
N 520 13250 520 13260 {
lab=GND}
N 480 13210 520 13210 {
lab=word220}
N 520 13210 560 13210 {
lab=word220}
N 490 13200 490 13250 {
lab=GND}
N 490 13250 490 13260 {
lab=GND}
N 550 13200 550 13250 {
lab=Y6}
N 550 13250 550 13260 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13230 1 0 {name=M996
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13260 600 13260 {
lab=GND}
N 600 13250 600 13260 {
lab=GND}
N 560 13210 600 13210 {
lab=word220}
N 600 13210 640 13210 {
lab=word220}
N 570 13200 570 13250 {
lab=GND}
N 570 13250 570 13260 {
lab=GND}
N 630 13200 630 13250 {
lab=Y7}
N 630 13250 630 13260 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13230 1 0 {name=M997
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13270 0 0 {name=p244 lab=word221}

N 10 13320 40 13320 {
lab=GND}
N 40 13310 40 13320 {
lab=GND}
N 0 13270 40 13270 {
lab=word221}
N 40 13270 80 13270 {
lab=word221}
N 10 13260 10 13310 {
lab=GND}
N 10 13310 10 13320 {
lab=GND}
N 70 13260 70 13310 {
lab=Y0}
N 70 13310 70 13320 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 13290 1 0 {name=M998
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 13270 120 13270 {
lab=word221}
N 120 13270 160 13270 {
lab=word221}
N 90 13260 90 13310 {
lab=GND}
N 90 13310 90 13320 {
lab=GND}
N 150 13260 150 13310 {
lab=Y1}
N 150 13310 150 13320 {
lab=Y1}
N 160 13270 200 13270 {
lab=word221}
N 200 13270 240 13270 {
lab=word221}
N 170 13260 170 13310 {
lab=GND}
N 170 13310 170 13320 {
lab=GND}
N 230 13260 230 13310 {
lab=Y2}
N 230 13310 230 13320 {
lab=Y2}
N 240 13270 280 13270 {
lab=word221}
N 280 13270 320 13270 {
lab=word221}
N 250 13260 250 13310 {
lab=GND}
N 250 13310 250 13320 {
lab=GND}
N 310 13260 310 13310 {
lab=Y3}
N 310 13310 310 13320 {
lab=Y3}

N 330 13320 360 13320 {
lab=GND}
N 360 13310 360 13320 {
lab=GND}
N 320 13270 360 13270 {
lab=word221}
N 360 13270 400 13270 {
lab=word221}
N 330 13260 330 13310 {
lab=GND}
N 330 13310 330 13320 {
lab=GND}
N 390 13260 390 13310 {
lab=Y4}
N 390 13310 390 13320 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 13290 1 0 {name=M999
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 13270 440 13270 {
lab=word221}
N 440 13270 480 13270 {
lab=word221}
N 410 13260 410 13310 {
lab=GND}
N 410 13310 410 13320 {
lab=GND}
N 470 13260 470 13310 {
lab=Y5}
N 470 13310 470 13320 {
lab=Y5}

N 490 13320 520 13320 {
lab=GND}
N 520 13310 520 13320 {
lab=GND}
N 480 13270 520 13270 {
lab=word221}
N 520 13270 560 13270 {
lab=word221}
N 490 13260 490 13310 {
lab=GND}
N 490 13310 490 13320 {
lab=GND}
N 550 13260 550 13310 {
lab=Y6}
N 550 13310 550 13320 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13290 1 0 {name=M1000
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13320 600 13320 {
lab=GND}
N 600 13310 600 13320 {
lab=GND}
N 560 13270 600 13270 {
lab=word221}
N 600 13270 640 13270 {
lab=word221}
N 570 13260 570 13310 {
lab=GND}
N 570 13310 570 13320 {
lab=GND}
N 630 13260 630 13310 {
lab=Y7}
N 630 13310 630 13320 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13290 1 0 {name=M1001
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13330 0 0 {name=p245 lab=word222}

N 10 13380 40 13380 {
lab=GND}
N 40 13370 40 13380 {
lab=GND}
N 0 13330 40 13330 {
lab=word222}
N 40 13330 80 13330 {
lab=word222}
N 10 13320 10 13370 {
lab=GND}
N 10 13370 10 13380 {
lab=GND}
N 70 13320 70 13370 {
lab=Y0}
N 70 13370 70 13380 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 13350 1 0 {name=M1002
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 13330 120 13330 {
lab=word222}
N 120 13330 160 13330 {
lab=word222}
N 90 13320 90 13370 {
lab=GND}
N 90 13370 90 13380 {
lab=GND}
N 150 13320 150 13370 {
lab=Y1}
N 150 13370 150 13380 {
lab=Y1}
N 160 13330 200 13330 {
lab=word222}
N 200 13330 240 13330 {
lab=word222}
N 170 13320 170 13370 {
lab=GND}
N 170 13370 170 13380 {
lab=GND}
N 230 13320 230 13370 {
lab=Y2}
N 230 13370 230 13380 {
lab=Y2}
N 240 13330 280 13330 {
lab=word222}
N 280 13330 320 13330 {
lab=word222}
N 250 13320 250 13370 {
lab=GND}
N 250 13370 250 13380 {
lab=GND}
N 310 13320 310 13370 {
lab=Y3}
N 310 13370 310 13380 {
lab=Y3}
N 320 13330 360 13330 {
lab=word222}
N 360 13330 400 13330 {
lab=word222}
N 330 13320 330 13370 {
lab=GND}
N 330 13370 330 13380 {
lab=GND}
N 390 13320 390 13370 {
lab=Y4}
N 390 13370 390 13380 {
lab=Y4}

N 410 13380 440 13380 {
lab=GND}
N 440 13370 440 13380 {
lab=GND}
N 400 13330 440 13330 {
lab=word222}
N 440 13330 480 13330 {
lab=word222}
N 410 13320 410 13370 {
lab=GND}
N 410 13370 410 13380 {
lab=GND}
N 470 13320 470 13370 {
lab=Y5}
N 470 13370 470 13380 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 13350 1 0 {name=M1003
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 13380 520 13380 {
lab=GND}
N 520 13370 520 13380 {
lab=GND}
N 480 13330 520 13330 {
lab=word222}
N 520 13330 560 13330 {
lab=word222}
N 490 13320 490 13370 {
lab=GND}
N 490 13370 490 13380 {
lab=GND}
N 550 13320 550 13370 {
lab=Y6}
N 550 13370 550 13380 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13350 1 0 {name=M1004
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13380 600 13380 {
lab=GND}
N 600 13370 600 13380 {
lab=GND}
N 560 13330 600 13330 {
lab=word222}
N 600 13330 640 13330 {
lab=word222}
N 570 13320 570 13370 {
lab=GND}
N 570 13370 570 13380 {
lab=GND}
N 630 13320 630 13370 {
lab=Y7}
N 630 13370 630 13380 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13350 1 0 {name=M1005
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13390 0 0 {name=p246 lab=word223}

N 10 13440 40 13440 {
lab=GND}
N 40 13430 40 13440 {
lab=GND}
N 0 13390 40 13390 {
lab=word223}
N 40 13390 80 13390 {
lab=word223}
N 10 13380 10 13430 {
lab=GND}
N 10 13430 10 13440 {
lab=GND}
N 70 13380 70 13430 {
lab=Y0}
N 70 13430 70 13440 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 13410 1 0 {name=M1006
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 13390 120 13390 {
lab=word223}
N 120 13390 160 13390 {
lab=word223}
N 90 13380 90 13430 {
lab=GND}
N 90 13430 90 13440 {
lab=GND}
N 150 13380 150 13430 {
lab=Y1}
N 150 13430 150 13440 {
lab=Y1}
N 160 13390 200 13390 {
lab=word223}
N 200 13390 240 13390 {
lab=word223}
N 170 13380 170 13430 {
lab=GND}
N 170 13430 170 13440 {
lab=GND}
N 230 13380 230 13430 {
lab=Y2}
N 230 13430 230 13440 {
lab=Y2}
N 240 13390 280 13390 {
lab=word223}
N 280 13390 320 13390 {
lab=word223}
N 250 13380 250 13430 {
lab=GND}
N 250 13430 250 13440 {
lab=GND}
N 310 13380 310 13430 {
lab=Y3}
N 310 13430 310 13440 {
lab=Y3}
N 320 13390 360 13390 {
lab=word223}
N 360 13390 400 13390 {
lab=word223}
N 330 13380 330 13430 {
lab=GND}
N 330 13430 330 13440 {
lab=GND}
N 390 13380 390 13430 {
lab=Y4}
N 390 13430 390 13440 {
lab=Y4}
N 400 13390 440 13390 {
lab=word223}
N 440 13390 480 13390 {
lab=word223}
N 410 13380 410 13430 {
lab=GND}
N 410 13430 410 13440 {
lab=GND}
N 470 13380 470 13430 {
lab=Y5}
N 470 13430 470 13440 {
lab=Y5}

N 490 13440 520 13440 {
lab=GND}
N 520 13430 520 13440 {
lab=GND}
N 480 13390 520 13390 {
lab=word223}
N 520 13390 560 13390 {
lab=word223}
N 490 13380 490 13430 {
lab=GND}
N 490 13430 490 13440 {
lab=GND}
N 550 13380 550 13430 {
lab=Y6}
N 550 13430 550 13440 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13410 1 0 {name=M1007
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13440 600 13440 {
lab=GND}
N 600 13430 600 13440 {
lab=GND}
N 560 13390 600 13390 {
lab=word223}
N 600 13390 640 13390 {
lab=word223}
N 570 13380 570 13430 {
lab=GND}
N 570 13430 570 13440 {
lab=GND}
N 630 13380 630 13430 {
lab=Y7}
N 630 13430 630 13440 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13410 1 0 {name=M1008
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13450 0 0 {name=p247 lab=word224}
N 0 13450 40 13450 {
lab=word224}
N 40 13450 80 13450 {
lab=word224}
N 10 13440 10 13490 {
lab=GND}
N 10 13490 10 13500 {
lab=GND}
N 70 13440 70 13490 {
lab=Y0}
N 70 13490 70 13500 {
lab=Y0}

N 90 13500 120 13500 {
lab=GND}
N 120 13490 120 13500 {
lab=GND}
N 80 13450 120 13450 {
lab=word224}
N 120 13450 160 13450 {
lab=word224}
N 90 13440 90 13490 {
lab=GND}
N 90 13490 90 13500 {
lab=GND}
N 150 13440 150 13490 {
lab=Y1}
N 150 13490 150 13500 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 13470 1 0 {name=M1009
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 13500 200 13500 {
lab=GND}
N 200 13490 200 13500 {
lab=GND}
N 160 13450 200 13450 {
lab=word224}
N 200 13450 240 13450 {
lab=word224}
N 170 13440 170 13490 {
lab=GND}
N 170 13490 170 13500 {
lab=GND}
N 230 13440 230 13490 {
lab=Y2}
N 230 13490 230 13500 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 13470 1 0 {name=M1010
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 13500 280 13500 {
lab=GND}
N 280 13490 280 13500 {
lab=GND}
N 240 13450 280 13450 {
lab=word224}
N 280 13450 320 13450 {
lab=word224}
N 250 13440 250 13490 {
lab=GND}
N 250 13490 250 13500 {
lab=GND}
N 310 13440 310 13490 {
lab=Y3}
N 310 13490 310 13500 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 13470 1 0 {name=M1011
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 13500 360 13500 {
lab=GND}
N 360 13490 360 13500 {
lab=GND}
N 320 13450 360 13450 {
lab=word224}
N 360 13450 400 13450 {
lab=word224}
N 330 13440 330 13490 {
lab=GND}
N 330 13490 330 13500 {
lab=GND}
N 390 13440 390 13490 {
lab=Y4}
N 390 13490 390 13500 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 13470 1 0 {name=M1012
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 13500 440 13500 {
lab=GND}
N 440 13490 440 13500 {
lab=GND}
N 400 13450 440 13450 {
lab=word224}
N 440 13450 480 13450 {
lab=word224}
N 410 13440 410 13490 {
lab=GND}
N 410 13490 410 13500 {
lab=GND}
N 470 13440 470 13490 {
lab=Y5}
N 470 13490 470 13500 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 13470 1 0 {name=M1013
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 13500 520 13500 {
lab=GND}
N 520 13490 520 13500 {
lab=GND}
N 480 13450 520 13450 {
lab=word224}
N 520 13450 560 13450 {
lab=word224}
N 490 13440 490 13490 {
lab=GND}
N 490 13490 490 13500 {
lab=GND}
N 550 13440 550 13490 {
lab=Y6}
N 550 13490 550 13500 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13470 1 0 {name=M1014
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13500 600 13500 {
lab=GND}
N 600 13490 600 13500 {
lab=GND}
N 560 13450 600 13450 {
lab=word224}
N 600 13450 640 13450 {
lab=word224}
N 570 13440 570 13490 {
lab=GND}
N 570 13490 570 13500 {
lab=GND}
N 630 13440 630 13490 {
lab=Y7}
N 630 13490 630 13500 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13470 1 0 {name=M1015
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13510 0 0 {name=p248 lab=word225}
N 0 13510 40 13510 {
lab=word225}
N 40 13510 80 13510 {
lab=word225}
N 10 13500 10 13550 {
lab=GND}
N 10 13550 10 13560 {
lab=GND}
N 70 13500 70 13550 {
lab=Y0}
N 70 13550 70 13560 {
lab=Y0}

N 90 13560 120 13560 {
lab=GND}
N 120 13550 120 13560 {
lab=GND}
N 80 13510 120 13510 {
lab=word225}
N 120 13510 160 13510 {
lab=word225}
N 90 13500 90 13550 {
lab=GND}
N 90 13550 90 13560 {
lab=GND}
N 150 13500 150 13550 {
lab=Y1}
N 150 13550 150 13560 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 13530 1 0 {name=M1016
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 13560 200 13560 {
lab=GND}
N 200 13550 200 13560 {
lab=GND}
N 160 13510 200 13510 {
lab=word225}
N 200 13510 240 13510 {
lab=word225}
N 170 13500 170 13550 {
lab=GND}
N 170 13550 170 13560 {
lab=GND}
N 230 13500 230 13550 {
lab=Y2}
N 230 13550 230 13560 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 13530 1 0 {name=M1017
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 13560 280 13560 {
lab=GND}
N 280 13550 280 13560 {
lab=GND}
N 240 13510 280 13510 {
lab=word225}
N 280 13510 320 13510 {
lab=word225}
N 250 13500 250 13550 {
lab=GND}
N 250 13550 250 13560 {
lab=GND}
N 310 13500 310 13550 {
lab=Y3}
N 310 13550 310 13560 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 13530 1 0 {name=M1018
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 13560 360 13560 {
lab=GND}
N 360 13550 360 13560 {
lab=GND}
N 320 13510 360 13510 {
lab=word225}
N 360 13510 400 13510 {
lab=word225}
N 330 13500 330 13550 {
lab=GND}
N 330 13550 330 13560 {
lab=GND}
N 390 13500 390 13550 {
lab=Y4}
N 390 13550 390 13560 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 13530 1 0 {name=M1019
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 13510 440 13510 {
lab=word225}
N 440 13510 480 13510 {
lab=word225}
N 410 13500 410 13550 {
lab=GND}
N 410 13550 410 13560 {
lab=GND}
N 470 13500 470 13550 {
lab=Y5}
N 470 13550 470 13560 {
lab=Y5}

N 490 13560 520 13560 {
lab=GND}
N 520 13550 520 13560 {
lab=GND}
N 480 13510 520 13510 {
lab=word225}
N 520 13510 560 13510 {
lab=word225}
N 490 13500 490 13550 {
lab=GND}
N 490 13550 490 13560 {
lab=GND}
N 550 13500 550 13550 {
lab=Y6}
N 550 13550 550 13560 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13530 1 0 {name=M1020
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13560 600 13560 {
lab=GND}
N 600 13550 600 13560 {
lab=GND}
N 560 13510 600 13510 {
lab=word225}
N 600 13510 640 13510 {
lab=word225}
N 570 13500 570 13550 {
lab=GND}
N 570 13550 570 13560 {
lab=GND}
N 630 13500 630 13550 {
lab=Y7}
N 630 13550 630 13560 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13530 1 0 {name=M1021
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13570 0 0 {name=p249 lab=word226}
N 0 13570 40 13570 {
lab=word226}
N 40 13570 80 13570 {
lab=word226}
N 10 13560 10 13610 {
lab=GND}
N 10 13610 10 13620 {
lab=GND}
N 70 13560 70 13610 {
lab=Y0}
N 70 13610 70 13620 {
lab=Y0}

N 90 13620 120 13620 {
lab=GND}
N 120 13610 120 13620 {
lab=GND}
N 80 13570 120 13570 {
lab=word226}
N 120 13570 160 13570 {
lab=word226}
N 90 13560 90 13610 {
lab=GND}
N 90 13610 90 13620 {
lab=GND}
N 150 13560 150 13610 {
lab=Y1}
N 150 13610 150 13620 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 13590 1 0 {name=M1022
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 13620 200 13620 {
lab=GND}
N 200 13610 200 13620 {
lab=GND}
N 160 13570 200 13570 {
lab=word226}
N 200 13570 240 13570 {
lab=word226}
N 170 13560 170 13610 {
lab=GND}
N 170 13610 170 13620 {
lab=GND}
N 230 13560 230 13610 {
lab=Y2}
N 230 13610 230 13620 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 13590 1 0 {name=M1023
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 13620 280 13620 {
lab=GND}
N 280 13610 280 13620 {
lab=GND}
N 240 13570 280 13570 {
lab=word226}
N 280 13570 320 13570 {
lab=word226}
N 250 13560 250 13610 {
lab=GND}
N 250 13610 250 13620 {
lab=GND}
N 310 13560 310 13610 {
lab=Y3}
N 310 13610 310 13620 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 13590 1 0 {name=M1024
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 13570 360 13570 {
lab=word226}
N 360 13570 400 13570 {
lab=word226}
N 330 13560 330 13610 {
lab=GND}
N 330 13610 330 13620 {
lab=GND}
N 390 13560 390 13610 {
lab=Y4}
N 390 13610 390 13620 {
lab=Y4}

N 410 13620 440 13620 {
lab=GND}
N 440 13610 440 13620 {
lab=GND}
N 400 13570 440 13570 {
lab=word226}
N 440 13570 480 13570 {
lab=word226}
N 410 13560 410 13610 {
lab=GND}
N 410 13610 410 13620 {
lab=GND}
N 470 13560 470 13610 {
lab=Y5}
N 470 13610 470 13620 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 13590 1 0 {name=M1025
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 13620 520 13620 {
lab=GND}
N 520 13610 520 13620 {
lab=GND}
N 480 13570 520 13570 {
lab=word226}
N 520 13570 560 13570 {
lab=word226}
N 490 13560 490 13610 {
lab=GND}
N 490 13610 490 13620 {
lab=GND}
N 550 13560 550 13610 {
lab=Y6}
N 550 13610 550 13620 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13590 1 0 {name=M1026
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13620 600 13620 {
lab=GND}
N 600 13610 600 13620 {
lab=GND}
N 560 13570 600 13570 {
lab=word226}
N 600 13570 640 13570 {
lab=word226}
N 570 13560 570 13610 {
lab=GND}
N 570 13610 570 13620 {
lab=GND}
N 630 13560 630 13610 {
lab=Y7}
N 630 13610 630 13620 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13590 1 0 {name=M1027
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13630 0 0 {name=p250 lab=word227}
N 0 13630 40 13630 {
lab=word227}
N 40 13630 80 13630 {
lab=word227}
N 10 13620 10 13670 {
lab=GND}
N 10 13670 10 13680 {
lab=GND}
N 70 13620 70 13670 {
lab=Y0}
N 70 13670 70 13680 {
lab=Y0}

N 90 13680 120 13680 {
lab=GND}
N 120 13670 120 13680 {
lab=GND}
N 80 13630 120 13630 {
lab=word227}
N 120 13630 160 13630 {
lab=word227}
N 90 13620 90 13670 {
lab=GND}
N 90 13670 90 13680 {
lab=GND}
N 150 13620 150 13670 {
lab=Y1}
N 150 13670 150 13680 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 13650 1 0 {name=M1028
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 13680 200 13680 {
lab=GND}
N 200 13670 200 13680 {
lab=GND}
N 160 13630 200 13630 {
lab=word227}
N 200 13630 240 13630 {
lab=word227}
N 170 13620 170 13670 {
lab=GND}
N 170 13670 170 13680 {
lab=GND}
N 230 13620 230 13670 {
lab=Y2}
N 230 13670 230 13680 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 13650 1 0 {name=M1029
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 13680 280 13680 {
lab=GND}
N 280 13670 280 13680 {
lab=GND}
N 240 13630 280 13630 {
lab=word227}
N 280 13630 320 13630 {
lab=word227}
N 250 13620 250 13670 {
lab=GND}
N 250 13670 250 13680 {
lab=GND}
N 310 13620 310 13670 {
lab=Y3}
N 310 13670 310 13680 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 13650 1 0 {name=M1030
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 13630 360 13630 {
lab=word227}
N 360 13630 400 13630 {
lab=word227}
N 330 13620 330 13670 {
lab=GND}
N 330 13670 330 13680 {
lab=GND}
N 390 13620 390 13670 {
lab=Y4}
N 390 13670 390 13680 {
lab=Y4}
N 400 13630 440 13630 {
lab=word227}
N 440 13630 480 13630 {
lab=word227}
N 410 13620 410 13670 {
lab=GND}
N 410 13670 410 13680 {
lab=GND}
N 470 13620 470 13670 {
lab=Y5}
N 470 13670 470 13680 {
lab=Y5}

N 490 13680 520 13680 {
lab=GND}
N 520 13670 520 13680 {
lab=GND}
N 480 13630 520 13630 {
lab=word227}
N 520 13630 560 13630 {
lab=word227}
N 490 13620 490 13670 {
lab=GND}
N 490 13670 490 13680 {
lab=GND}
N 550 13620 550 13670 {
lab=Y6}
N 550 13670 550 13680 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13650 1 0 {name=M1031
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13680 600 13680 {
lab=GND}
N 600 13670 600 13680 {
lab=GND}
N 560 13630 600 13630 {
lab=word227}
N 600 13630 640 13630 {
lab=word227}
N 570 13620 570 13670 {
lab=GND}
N 570 13670 570 13680 {
lab=GND}
N 630 13620 630 13670 {
lab=Y7}
N 630 13670 630 13680 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13650 1 0 {name=M1032
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13690 0 0 {name=p251 lab=word228}
N 0 13690 40 13690 {
lab=word228}
N 40 13690 80 13690 {
lab=word228}
N 10 13680 10 13730 {
lab=GND}
N 10 13730 10 13740 {
lab=GND}
N 70 13680 70 13730 {
lab=Y0}
N 70 13730 70 13740 {
lab=Y0}

N 90 13740 120 13740 {
lab=GND}
N 120 13730 120 13740 {
lab=GND}
N 80 13690 120 13690 {
lab=word228}
N 120 13690 160 13690 {
lab=word228}
N 90 13680 90 13730 {
lab=GND}
N 90 13730 90 13740 {
lab=GND}
N 150 13680 150 13730 {
lab=Y1}
N 150 13730 150 13740 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 13710 1 0 {name=M1033
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 13740 200 13740 {
lab=GND}
N 200 13730 200 13740 {
lab=GND}
N 160 13690 200 13690 {
lab=word228}
N 200 13690 240 13690 {
lab=word228}
N 170 13680 170 13730 {
lab=GND}
N 170 13730 170 13740 {
lab=GND}
N 230 13680 230 13730 {
lab=Y2}
N 230 13730 230 13740 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 13710 1 0 {name=M1034
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 13690 280 13690 {
lab=word228}
N 280 13690 320 13690 {
lab=word228}
N 250 13680 250 13730 {
lab=GND}
N 250 13730 250 13740 {
lab=GND}
N 310 13680 310 13730 {
lab=Y3}
N 310 13730 310 13740 {
lab=Y3}

N 330 13740 360 13740 {
lab=GND}
N 360 13730 360 13740 {
lab=GND}
N 320 13690 360 13690 {
lab=word228}
N 360 13690 400 13690 {
lab=word228}
N 330 13680 330 13730 {
lab=GND}
N 330 13730 330 13740 {
lab=GND}
N 390 13680 390 13730 {
lab=Y4}
N 390 13730 390 13740 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 13710 1 0 {name=M1035
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 13740 440 13740 {
lab=GND}
N 440 13730 440 13740 {
lab=GND}
N 400 13690 440 13690 {
lab=word228}
N 440 13690 480 13690 {
lab=word228}
N 410 13680 410 13730 {
lab=GND}
N 410 13730 410 13740 {
lab=GND}
N 470 13680 470 13730 {
lab=Y5}
N 470 13730 470 13740 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 13710 1 0 {name=M1036
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 13740 520 13740 {
lab=GND}
N 520 13730 520 13740 {
lab=GND}
N 480 13690 520 13690 {
lab=word228}
N 520 13690 560 13690 {
lab=word228}
N 490 13680 490 13730 {
lab=GND}
N 490 13730 490 13740 {
lab=GND}
N 550 13680 550 13730 {
lab=Y6}
N 550 13730 550 13740 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13710 1 0 {name=M1037
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13740 600 13740 {
lab=GND}
N 600 13730 600 13740 {
lab=GND}
N 560 13690 600 13690 {
lab=word228}
N 600 13690 640 13690 {
lab=word228}
N 570 13680 570 13730 {
lab=GND}
N 570 13730 570 13740 {
lab=GND}
N 630 13680 630 13730 {
lab=Y7}
N 630 13730 630 13740 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13710 1 0 {name=M1038
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13750 0 0 {name=p252 lab=word229}
N 0 13750 40 13750 {
lab=word229}
N 40 13750 80 13750 {
lab=word229}
N 10 13740 10 13790 {
lab=GND}
N 10 13790 10 13800 {
lab=GND}
N 70 13740 70 13790 {
lab=Y0}
N 70 13790 70 13800 {
lab=Y0}

N 90 13800 120 13800 {
lab=GND}
N 120 13790 120 13800 {
lab=GND}
N 80 13750 120 13750 {
lab=word229}
N 120 13750 160 13750 {
lab=word229}
N 90 13740 90 13790 {
lab=GND}
N 90 13790 90 13800 {
lab=GND}
N 150 13740 150 13790 {
lab=Y1}
N 150 13790 150 13800 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 13770 1 0 {name=M1039
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 13800 200 13800 {
lab=GND}
N 200 13790 200 13800 {
lab=GND}
N 160 13750 200 13750 {
lab=word229}
N 200 13750 240 13750 {
lab=word229}
N 170 13740 170 13790 {
lab=GND}
N 170 13790 170 13800 {
lab=GND}
N 230 13740 230 13790 {
lab=Y2}
N 230 13790 230 13800 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 13770 1 0 {name=M1040
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 13750 280 13750 {
lab=word229}
N 280 13750 320 13750 {
lab=word229}
N 250 13740 250 13790 {
lab=GND}
N 250 13790 250 13800 {
lab=GND}
N 310 13740 310 13790 {
lab=Y3}
N 310 13790 310 13800 {
lab=Y3}

N 330 13800 360 13800 {
lab=GND}
N 360 13790 360 13800 {
lab=GND}
N 320 13750 360 13750 {
lab=word229}
N 360 13750 400 13750 {
lab=word229}
N 330 13740 330 13790 {
lab=GND}
N 330 13790 330 13800 {
lab=GND}
N 390 13740 390 13790 {
lab=Y4}
N 390 13790 390 13800 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 13770 1 0 {name=M1041
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 13750 440 13750 {
lab=word229}
N 440 13750 480 13750 {
lab=word229}
N 410 13740 410 13790 {
lab=GND}
N 410 13790 410 13800 {
lab=GND}
N 470 13740 470 13790 {
lab=Y5}
N 470 13790 470 13800 {
lab=Y5}

N 490 13800 520 13800 {
lab=GND}
N 520 13790 520 13800 {
lab=GND}
N 480 13750 520 13750 {
lab=word229}
N 520 13750 560 13750 {
lab=word229}
N 490 13740 490 13790 {
lab=GND}
N 490 13790 490 13800 {
lab=GND}
N 550 13740 550 13790 {
lab=Y6}
N 550 13790 550 13800 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13770 1 0 {name=M1042
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13800 600 13800 {
lab=GND}
N 600 13790 600 13800 {
lab=GND}
N 560 13750 600 13750 {
lab=word229}
N 600 13750 640 13750 {
lab=word229}
N 570 13740 570 13790 {
lab=GND}
N 570 13790 570 13800 {
lab=GND}
N 630 13740 630 13790 {
lab=Y7}
N 630 13790 630 13800 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13770 1 0 {name=M1043
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13810 0 0 {name=p253 lab=word230}
N 0 13810 40 13810 {
lab=word230}
N 40 13810 80 13810 {
lab=word230}
N 10 13800 10 13850 {
lab=GND}
N 10 13850 10 13860 {
lab=GND}
N 70 13800 70 13850 {
lab=Y0}
N 70 13850 70 13860 {
lab=Y0}

N 90 13860 120 13860 {
lab=GND}
N 120 13850 120 13860 {
lab=GND}
N 80 13810 120 13810 {
lab=word230}
N 120 13810 160 13810 {
lab=word230}
N 90 13800 90 13850 {
lab=GND}
N 90 13850 90 13860 {
lab=GND}
N 150 13800 150 13850 {
lab=Y1}
N 150 13850 150 13860 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 13830 1 0 {name=M1044
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 13860 200 13860 {
lab=GND}
N 200 13850 200 13860 {
lab=GND}
N 160 13810 200 13810 {
lab=word230}
N 200 13810 240 13810 {
lab=word230}
N 170 13800 170 13850 {
lab=GND}
N 170 13850 170 13860 {
lab=GND}
N 230 13800 230 13850 {
lab=Y2}
N 230 13850 230 13860 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 13830 1 0 {name=M1045
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 13810 280 13810 {
lab=word230}
N 280 13810 320 13810 {
lab=word230}
N 250 13800 250 13850 {
lab=GND}
N 250 13850 250 13860 {
lab=GND}
N 310 13800 310 13850 {
lab=Y3}
N 310 13850 310 13860 {
lab=Y3}
N 320 13810 360 13810 {
lab=word230}
N 360 13810 400 13810 {
lab=word230}
N 330 13800 330 13850 {
lab=GND}
N 330 13850 330 13860 {
lab=GND}
N 390 13800 390 13850 {
lab=Y4}
N 390 13850 390 13860 {
lab=Y4}

N 410 13860 440 13860 {
lab=GND}
N 440 13850 440 13860 {
lab=GND}
N 400 13810 440 13810 {
lab=word230}
N 440 13810 480 13810 {
lab=word230}
N 410 13800 410 13850 {
lab=GND}
N 410 13850 410 13860 {
lab=GND}
N 470 13800 470 13850 {
lab=Y5}
N 470 13850 470 13860 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 13830 1 0 {name=M1046
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 13860 520 13860 {
lab=GND}
N 520 13850 520 13860 {
lab=GND}
N 480 13810 520 13810 {
lab=word230}
N 520 13810 560 13810 {
lab=word230}
N 490 13800 490 13850 {
lab=GND}
N 490 13850 490 13860 {
lab=GND}
N 550 13800 550 13850 {
lab=Y6}
N 550 13850 550 13860 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13830 1 0 {name=M1047
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13860 600 13860 {
lab=GND}
N 600 13850 600 13860 {
lab=GND}
N 560 13810 600 13810 {
lab=word230}
N 600 13810 640 13810 {
lab=word230}
N 570 13800 570 13850 {
lab=GND}
N 570 13850 570 13860 {
lab=GND}
N 630 13800 630 13850 {
lab=Y7}
N 630 13850 630 13860 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13830 1 0 {name=M1048
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13870 0 0 {name=p254 lab=word231}
N 0 13870 40 13870 {
lab=word231}
N 40 13870 80 13870 {
lab=word231}
N 10 13860 10 13910 {
lab=GND}
N 10 13910 10 13920 {
lab=GND}
N 70 13860 70 13910 {
lab=Y0}
N 70 13910 70 13920 {
lab=Y0}

N 90 13920 120 13920 {
lab=GND}
N 120 13910 120 13920 {
lab=GND}
N 80 13870 120 13870 {
lab=word231}
N 120 13870 160 13870 {
lab=word231}
N 90 13860 90 13910 {
lab=GND}
N 90 13910 90 13920 {
lab=GND}
N 150 13860 150 13910 {
lab=Y1}
N 150 13910 150 13920 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 13890 1 0 {name=M1049
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 13920 200 13920 {
lab=GND}
N 200 13910 200 13920 {
lab=GND}
N 160 13870 200 13870 {
lab=word231}
N 200 13870 240 13870 {
lab=word231}
N 170 13860 170 13910 {
lab=GND}
N 170 13910 170 13920 {
lab=GND}
N 230 13860 230 13910 {
lab=Y2}
N 230 13910 230 13920 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 13890 1 0 {name=M1050
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 13870 280 13870 {
lab=word231}
N 280 13870 320 13870 {
lab=word231}
N 250 13860 250 13910 {
lab=GND}
N 250 13910 250 13920 {
lab=GND}
N 310 13860 310 13910 {
lab=Y3}
N 310 13910 310 13920 {
lab=Y3}
N 320 13870 360 13870 {
lab=word231}
N 360 13870 400 13870 {
lab=word231}
N 330 13860 330 13910 {
lab=GND}
N 330 13910 330 13920 {
lab=GND}
N 390 13860 390 13910 {
lab=Y4}
N 390 13910 390 13920 {
lab=Y4}
N 400 13870 440 13870 {
lab=word231}
N 440 13870 480 13870 {
lab=word231}
N 410 13860 410 13910 {
lab=GND}
N 410 13910 410 13920 {
lab=GND}
N 470 13860 470 13910 {
lab=Y5}
N 470 13910 470 13920 {
lab=Y5}

N 490 13920 520 13920 {
lab=GND}
N 520 13910 520 13920 {
lab=GND}
N 480 13870 520 13870 {
lab=word231}
N 520 13870 560 13870 {
lab=word231}
N 490 13860 490 13910 {
lab=GND}
N 490 13910 490 13920 {
lab=GND}
N 550 13860 550 13910 {
lab=Y6}
N 550 13910 550 13920 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13890 1 0 {name=M1051
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13920 600 13920 {
lab=GND}
N 600 13910 600 13920 {
lab=GND}
N 560 13870 600 13870 {
lab=word231}
N 600 13870 640 13870 {
lab=word231}
N 570 13860 570 13910 {
lab=GND}
N 570 13910 570 13920 {
lab=GND}
N 630 13860 630 13910 {
lab=Y7}
N 630 13910 630 13920 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13890 1 0 {name=M1052
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13930 0 0 {name=p255 lab=word232}
N 0 13930 40 13930 {
lab=word232}
N 40 13930 80 13930 {
lab=word232}
N 10 13920 10 13970 {
lab=GND}
N 10 13970 10 13980 {
lab=GND}
N 70 13920 70 13970 {
lab=Y0}
N 70 13970 70 13980 {
lab=Y0}

N 90 13980 120 13980 {
lab=GND}
N 120 13970 120 13980 {
lab=GND}
N 80 13930 120 13930 {
lab=word232}
N 120 13930 160 13930 {
lab=word232}
N 90 13920 90 13970 {
lab=GND}
N 90 13970 90 13980 {
lab=GND}
N 150 13920 150 13970 {
lab=Y1}
N 150 13970 150 13980 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 13950 1 0 {name=M1053
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 13930 200 13930 {
lab=word232}
N 200 13930 240 13930 {
lab=word232}
N 170 13920 170 13970 {
lab=GND}
N 170 13970 170 13980 {
lab=GND}
N 230 13920 230 13970 {
lab=Y2}
N 230 13970 230 13980 {
lab=Y2}

N 250 13980 280 13980 {
lab=GND}
N 280 13970 280 13980 {
lab=GND}
N 240 13930 280 13930 {
lab=word232}
N 280 13930 320 13930 {
lab=word232}
N 250 13920 250 13970 {
lab=GND}
N 250 13970 250 13980 {
lab=GND}
N 310 13920 310 13970 {
lab=Y3}
N 310 13970 310 13980 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 13950 1 0 {name=M1054
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 13980 360 13980 {
lab=GND}
N 360 13970 360 13980 {
lab=GND}
N 320 13930 360 13930 {
lab=word232}
N 360 13930 400 13930 {
lab=word232}
N 330 13920 330 13970 {
lab=GND}
N 330 13970 330 13980 {
lab=GND}
N 390 13920 390 13970 {
lab=Y4}
N 390 13970 390 13980 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 13950 1 0 {name=M1055
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 13980 440 13980 {
lab=GND}
N 440 13970 440 13980 {
lab=GND}
N 400 13930 440 13930 {
lab=word232}
N 440 13930 480 13930 {
lab=word232}
N 410 13920 410 13970 {
lab=GND}
N 410 13970 410 13980 {
lab=GND}
N 470 13920 470 13970 {
lab=Y5}
N 470 13970 470 13980 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 13950 1 0 {name=M1056
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 13980 520 13980 {
lab=GND}
N 520 13970 520 13980 {
lab=GND}
N 480 13930 520 13930 {
lab=word232}
N 520 13930 560 13930 {
lab=word232}
N 490 13920 490 13970 {
lab=GND}
N 490 13970 490 13980 {
lab=GND}
N 550 13920 550 13970 {
lab=Y6}
N 550 13970 550 13980 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 13950 1 0 {name=M1057
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 13980 600 13980 {
lab=GND}
N 600 13970 600 13980 {
lab=GND}
N 560 13930 600 13930 {
lab=word232}
N 600 13930 640 13930 {
lab=word232}
N 570 13920 570 13970 {
lab=GND}
N 570 13970 570 13980 {
lab=GND}
N 630 13920 630 13970 {
lab=Y7}
N 630 13970 630 13980 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 13950 1 0 {name=M1058
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 13990 0 0 {name=p256 lab=word233}
N 0 13990 40 13990 {
lab=word233}
N 40 13990 80 13990 {
lab=word233}
N 10 13980 10 14030 {
lab=GND}
N 10 14030 10 14040 {
lab=GND}
N 70 13980 70 14030 {
lab=Y0}
N 70 14030 70 14040 {
lab=Y0}

N 90 14040 120 14040 {
lab=GND}
N 120 14030 120 14040 {
lab=GND}
N 80 13990 120 13990 {
lab=word233}
N 120 13990 160 13990 {
lab=word233}
N 90 13980 90 14030 {
lab=GND}
N 90 14030 90 14040 {
lab=GND}
N 150 13980 150 14030 {
lab=Y1}
N 150 14030 150 14040 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 14010 1 0 {name=M1059
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 13990 200 13990 {
lab=word233}
N 200 13990 240 13990 {
lab=word233}
N 170 13980 170 14030 {
lab=GND}
N 170 14030 170 14040 {
lab=GND}
N 230 13980 230 14030 {
lab=Y2}
N 230 14030 230 14040 {
lab=Y2}

N 250 14040 280 14040 {
lab=GND}
N 280 14030 280 14040 {
lab=GND}
N 240 13990 280 13990 {
lab=word233}
N 280 13990 320 13990 {
lab=word233}
N 250 13980 250 14030 {
lab=GND}
N 250 14030 250 14040 {
lab=GND}
N 310 13980 310 14030 {
lab=Y3}
N 310 14030 310 14040 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 14010 1 0 {name=M1060
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 14040 360 14040 {
lab=GND}
N 360 14030 360 14040 {
lab=GND}
N 320 13990 360 13990 {
lab=word233}
N 360 13990 400 13990 {
lab=word233}
N 330 13980 330 14030 {
lab=GND}
N 330 14030 330 14040 {
lab=GND}
N 390 13980 390 14030 {
lab=Y4}
N 390 14030 390 14040 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 14010 1 0 {name=M1061
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 13990 440 13990 {
lab=word233}
N 440 13990 480 13990 {
lab=word233}
N 410 13980 410 14030 {
lab=GND}
N 410 14030 410 14040 {
lab=GND}
N 470 13980 470 14030 {
lab=Y5}
N 470 14030 470 14040 {
lab=Y5}

N 490 14040 520 14040 {
lab=GND}
N 520 14030 520 14040 {
lab=GND}
N 480 13990 520 13990 {
lab=word233}
N 520 13990 560 13990 {
lab=word233}
N 490 13980 490 14030 {
lab=GND}
N 490 14030 490 14040 {
lab=GND}
N 550 13980 550 14030 {
lab=Y6}
N 550 14030 550 14040 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14010 1 0 {name=M1062
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14040 600 14040 {
lab=GND}
N 600 14030 600 14040 {
lab=GND}
N 560 13990 600 13990 {
lab=word233}
N 600 13990 640 13990 {
lab=word233}
N 570 13980 570 14030 {
lab=GND}
N 570 14030 570 14040 {
lab=GND}
N 630 13980 630 14030 {
lab=Y7}
N 630 14030 630 14040 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14010 1 0 {name=M1063
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14050 0 0 {name=p257 lab=word234}
N 0 14050 40 14050 {
lab=word234}
N 40 14050 80 14050 {
lab=word234}
N 10 14040 10 14090 {
lab=GND}
N 10 14090 10 14100 {
lab=GND}
N 70 14040 70 14090 {
lab=Y0}
N 70 14090 70 14100 {
lab=Y0}

N 90 14100 120 14100 {
lab=GND}
N 120 14090 120 14100 {
lab=GND}
N 80 14050 120 14050 {
lab=word234}
N 120 14050 160 14050 {
lab=word234}
N 90 14040 90 14090 {
lab=GND}
N 90 14090 90 14100 {
lab=GND}
N 150 14040 150 14090 {
lab=Y1}
N 150 14090 150 14100 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 14070 1 0 {name=M1064
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 14050 200 14050 {
lab=word234}
N 200 14050 240 14050 {
lab=word234}
N 170 14040 170 14090 {
lab=GND}
N 170 14090 170 14100 {
lab=GND}
N 230 14040 230 14090 {
lab=Y2}
N 230 14090 230 14100 {
lab=Y2}

N 250 14100 280 14100 {
lab=GND}
N 280 14090 280 14100 {
lab=GND}
N 240 14050 280 14050 {
lab=word234}
N 280 14050 320 14050 {
lab=word234}
N 250 14040 250 14090 {
lab=GND}
N 250 14090 250 14100 {
lab=GND}
N 310 14040 310 14090 {
lab=Y3}
N 310 14090 310 14100 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 14070 1 0 {name=M1065
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 14050 360 14050 {
lab=word234}
N 360 14050 400 14050 {
lab=word234}
N 330 14040 330 14090 {
lab=GND}
N 330 14090 330 14100 {
lab=GND}
N 390 14040 390 14090 {
lab=Y4}
N 390 14090 390 14100 {
lab=Y4}

N 410 14100 440 14100 {
lab=GND}
N 440 14090 440 14100 {
lab=GND}
N 400 14050 440 14050 {
lab=word234}
N 440 14050 480 14050 {
lab=word234}
N 410 14040 410 14090 {
lab=GND}
N 410 14090 410 14100 {
lab=GND}
N 470 14040 470 14090 {
lab=Y5}
N 470 14090 470 14100 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 14070 1 0 {name=M1066
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 14100 520 14100 {
lab=GND}
N 520 14090 520 14100 {
lab=GND}
N 480 14050 520 14050 {
lab=word234}
N 520 14050 560 14050 {
lab=word234}
N 490 14040 490 14090 {
lab=GND}
N 490 14090 490 14100 {
lab=GND}
N 550 14040 550 14090 {
lab=Y6}
N 550 14090 550 14100 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14070 1 0 {name=M1067
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14100 600 14100 {
lab=GND}
N 600 14090 600 14100 {
lab=GND}
N 560 14050 600 14050 {
lab=word234}
N 600 14050 640 14050 {
lab=word234}
N 570 14040 570 14090 {
lab=GND}
N 570 14090 570 14100 {
lab=GND}
N 630 14040 630 14090 {
lab=Y7}
N 630 14090 630 14100 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14070 1 0 {name=M1068
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14110 0 0 {name=p258 lab=word235}
N 0 14110 40 14110 {
lab=word235}
N 40 14110 80 14110 {
lab=word235}
N 10 14100 10 14150 {
lab=GND}
N 10 14150 10 14160 {
lab=GND}
N 70 14100 70 14150 {
lab=Y0}
N 70 14150 70 14160 {
lab=Y0}

N 90 14160 120 14160 {
lab=GND}
N 120 14150 120 14160 {
lab=GND}
N 80 14110 120 14110 {
lab=word235}
N 120 14110 160 14110 {
lab=word235}
N 90 14100 90 14150 {
lab=GND}
N 90 14150 90 14160 {
lab=GND}
N 150 14100 150 14150 {
lab=Y1}
N 150 14150 150 14160 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 14130 1 0 {name=M1069
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 14110 200 14110 {
lab=word235}
N 200 14110 240 14110 {
lab=word235}
N 170 14100 170 14150 {
lab=GND}
N 170 14150 170 14160 {
lab=GND}
N 230 14100 230 14150 {
lab=Y2}
N 230 14150 230 14160 {
lab=Y2}

N 250 14160 280 14160 {
lab=GND}
N 280 14150 280 14160 {
lab=GND}
N 240 14110 280 14110 {
lab=word235}
N 280 14110 320 14110 {
lab=word235}
N 250 14100 250 14150 {
lab=GND}
N 250 14150 250 14160 {
lab=GND}
N 310 14100 310 14150 {
lab=Y3}
N 310 14150 310 14160 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 14130 1 0 {name=M1070
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 14110 360 14110 {
lab=word235}
N 360 14110 400 14110 {
lab=word235}
N 330 14100 330 14150 {
lab=GND}
N 330 14150 330 14160 {
lab=GND}
N 390 14100 390 14150 {
lab=Y4}
N 390 14150 390 14160 {
lab=Y4}
N 400 14110 440 14110 {
lab=word235}
N 440 14110 480 14110 {
lab=word235}
N 410 14100 410 14150 {
lab=GND}
N 410 14150 410 14160 {
lab=GND}
N 470 14100 470 14150 {
lab=Y5}
N 470 14150 470 14160 {
lab=Y5}

N 490 14160 520 14160 {
lab=GND}
N 520 14150 520 14160 {
lab=GND}
N 480 14110 520 14110 {
lab=word235}
N 520 14110 560 14110 {
lab=word235}
N 490 14100 490 14150 {
lab=GND}
N 490 14150 490 14160 {
lab=GND}
N 550 14100 550 14150 {
lab=Y6}
N 550 14150 550 14160 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14130 1 0 {name=M1071
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14160 600 14160 {
lab=GND}
N 600 14150 600 14160 {
lab=GND}
N 560 14110 600 14110 {
lab=word235}
N 600 14110 640 14110 {
lab=word235}
N 570 14100 570 14150 {
lab=GND}
N 570 14150 570 14160 {
lab=GND}
N 630 14100 630 14150 {
lab=Y7}
N 630 14150 630 14160 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14130 1 0 {name=M1072
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14170 0 0 {name=p259 lab=word236}
N 0 14170 40 14170 {
lab=word236}
N 40 14170 80 14170 {
lab=word236}
N 10 14160 10 14210 {
lab=GND}
N 10 14210 10 14220 {
lab=GND}
N 70 14160 70 14210 {
lab=Y0}
N 70 14210 70 14220 {
lab=Y0}

N 90 14220 120 14220 {
lab=GND}
N 120 14210 120 14220 {
lab=GND}
N 80 14170 120 14170 {
lab=word236}
N 120 14170 160 14170 {
lab=word236}
N 90 14160 90 14210 {
lab=GND}
N 90 14210 90 14220 {
lab=GND}
N 150 14160 150 14210 {
lab=Y1}
N 150 14210 150 14220 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 14190 1 0 {name=M1073
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 14170 200 14170 {
lab=word236}
N 200 14170 240 14170 {
lab=word236}
N 170 14160 170 14210 {
lab=GND}
N 170 14210 170 14220 {
lab=GND}
N 230 14160 230 14210 {
lab=Y2}
N 230 14210 230 14220 {
lab=Y2}
N 240 14170 280 14170 {
lab=word236}
N 280 14170 320 14170 {
lab=word236}
N 250 14160 250 14210 {
lab=GND}
N 250 14210 250 14220 {
lab=GND}
N 310 14160 310 14210 {
lab=Y3}
N 310 14210 310 14220 {
lab=Y3}

N 330 14220 360 14220 {
lab=GND}
N 360 14210 360 14220 {
lab=GND}
N 320 14170 360 14170 {
lab=word236}
N 360 14170 400 14170 {
lab=word236}
N 330 14160 330 14210 {
lab=GND}
N 330 14210 330 14220 {
lab=GND}
N 390 14160 390 14210 {
lab=Y4}
N 390 14210 390 14220 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 14190 1 0 {name=M1074
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 14220 440 14220 {
lab=GND}
N 440 14210 440 14220 {
lab=GND}
N 400 14170 440 14170 {
lab=word236}
N 440 14170 480 14170 {
lab=word236}
N 410 14160 410 14210 {
lab=GND}
N 410 14210 410 14220 {
lab=GND}
N 470 14160 470 14210 {
lab=Y5}
N 470 14210 470 14220 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 14190 1 0 {name=M1075
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 14220 520 14220 {
lab=GND}
N 520 14210 520 14220 {
lab=GND}
N 480 14170 520 14170 {
lab=word236}
N 520 14170 560 14170 {
lab=word236}
N 490 14160 490 14210 {
lab=GND}
N 490 14210 490 14220 {
lab=GND}
N 550 14160 550 14210 {
lab=Y6}
N 550 14210 550 14220 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14190 1 0 {name=M1076
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14220 600 14220 {
lab=GND}
N 600 14210 600 14220 {
lab=GND}
N 560 14170 600 14170 {
lab=word236}
N 600 14170 640 14170 {
lab=word236}
N 570 14160 570 14210 {
lab=GND}
N 570 14210 570 14220 {
lab=GND}
N 630 14160 630 14210 {
lab=Y7}
N 630 14210 630 14220 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14190 1 0 {name=M1077
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14230 0 0 {name=p260 lab=word237}
N 0 14230 40 14230 {
lab=word237}
N 40 14230 80 14230 {
lab=word237}
N 10 14220 10 14270 {
lab=GND}
N 10 14270 10 14280 {
lab=GND}
N 70 14220 70 14270 {
lab=Y0}
N 70 14270 70 14280 {
lab=Y0}

N 90 14280 120 14280 {
lab=GND}
N 120 14270 120 14280 {
lab=GND}
N 80 14230 120 14230 {
lab=word237}
N 120 14230 160 14230 {
lab=word237}
N 90 14220 90 14270 {
lab=GND}
N 90 14270 90 14280 {
lab=GND}
N 150 14220 150 14270 {
lab=Y1}
N 150 14270 150 14280 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 14250 1 0 {name=M1078
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 14230 200 14230 {
lab=word237}
N 200 14230 240 14230 {
lab=word237}
N 170 14220 170 14270 {
lab=GND}
N 170 14270 170 14280 {
lab=GND}
N 230 14220 230 14270 {
lab=Y2}
N 230 14270 230 14280 {
lab=Y2}
N 240 14230 280 14230 {
lab=word237}
N 280 14230 320 14230 {
lab=word237}
N 250 14220 250 14270 {
lab=GND}
N 250 14270 250 14280 {
lab=GND}
N 310 14220 310 14270 {
lab=Y3}
N 310 14270 310 14280 {
lab=Y3}

N 330 14280 360 14280 {
lab=GND}
N 360 14270 360 14280 {
lab=GND}
N 320 14230 360 14230 {
lab=word237}
N 360 14230 400 14230 {
lab=word237}
N 330 14220 330 14270 {
lab=GND}
N 330 14270 330 14280 {
lab=GND}
N 390 14220 390 14270 {
lab=Y4}
N 390 14270 390 14280 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 14250 1 0 {name=M1079
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 14230 440 14230 {
lab=word237}
N 440 14230 480 14230 {
lab=word237}
N 410 14220 410 14270 {
lab=GND}
N 410 14270 410 14280 {
lab=GND}
N 470 14220 470 14270 {
lab=Y5}
N 470 14270 470 14280 {
lab=Y5}

N 490 14280 520 14280 {
lab=GND}
N 520 14270 520 14280 {
lab=GND}
N 480 14230 520 14230 {
lab=word237}
N 520 14230 560 14230 {
lab=word237}
N 490 14220 490 14270 {
lab=GND}
N 490 14270 490 14280 {
lab=GND}
N 550 14220 550 14270 {
lab=Y6}
N 550 14270 550 14280 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14250 1 0 {name=M1080
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14280 600 14280 {
lab=GND}
N 600 14270 600 14280 {
lab=GND}
N 560 14230 600 14230 {
lab=word237}
N 600 14230 640 14230 {
lab=word237}
N 570 14220 570 14270 {
lab=GND}
N 570 14270 570 14280 {
lab=GND}
N 630 14220 630 14270 {
lab=Y7}
N 630 14270 630 14280 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14250 1 0 {name=M1081
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14290 0 0 {name=p261 lab=word238}
N 0 14290 40 14290 {
lab=word238}
N 40 14290 80 14290 {
lab=word238}
N 10 14280 10 14330 {
lab=GND}
N 10 14330 10 14340 {
lab=GND}
N 70 14280 70 14330 {
lab=Y0}
N 70 14330 70 14340 {
lab=Y0}

N 90 14340 120 14340 {
lab=GND}
N 120 14330 120 14340 {
lab=GND}
N 80 14290 120 14290 {
lab=word238}
N 120 14290 160 14290 {
lab=word238}
N 90 14280 90 14330 {
lab=GND}
N 90 14330 90 14340 {
lab=GND}
N 150 14280 150 14330 {
lab=Y1}
N 150 14330 150 14340 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 14310 1 0 {name=M1082
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 14290 200 14290 {
lab=word238}
N 200 14290 240 14290 {
lab=word238}
N 170 14280 170 14330 {
lab=GND}
N 170 14330 170 14340 {
lab=GND}
N 230 14280 230 14330 {
lab=Y2}
N 230 14330 230 14340 {
lab=Y2}
N 240 14290 280 14290 {
lab=word238}
N 280 14290 320 14290 {
lab=word238}
N 250 14280 250 14330 {
lab=GND}
N 250 14330 250 14340 {
lab=GND}
N 310 14280 310 14330 {
lab=Y3}
N 310 14330 310 14340 {
lab=Y3}
N 320 14290 360 14290 {
lab=word238}
N 360 14290 400 14290 {
lab=word238}
N 330 14280 330 14330 {
lab=GND}
N 330 14330 330 14340 {
lab=GND}
N 390 14280 390 14330 {
lab=Y4}
N 390 14330 390 14340 {
lab=Y4}

N 410 14340 440 14340 {
lab=GND}
N 440 14330 440 14340 {
lab=GND}
N 400 14290 440 14290 {
lab=word238}
N 440 14290 480 14290 {
lab=word238}
N 410 14280 410 14330 {
lab=GND}
N 410 14330 410 14340 {
lab=GND}
N 470 14280 470 14330 {
lab=Y5}
N 470 14330 470 14340 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 14310 1 0 {name=M1083
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 14340 520 14340 {
lab=GND}
N 520 14330 520 14340 {
lab=GND}
N 480 14290 520 14290 {
lab=word238}
N 520 14290 560 14290 {
lab=word238}
N 490 14280 490 14330 {
lab=GND}
N 490 14330 490 14340 {
lab=GND}
N 550 14280 550 14330 {
lab=Y6}
N 550 14330 550 14340 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14310 1 0 {name=M1084
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14340 600 14340 {
lab=GND}
N 600 14330 600 14340 {
lab=GND}
N 560 14290 600 14290 {
lab=word238}
N 600 14290 640 14290 {
lab=word238}
N 570 14280 570 14330 {
lab=GND}
N 570 14330 570 14340 {
lab=GND}
N 630 14280 630 14330 {
lab=Y7}
N 630 14330 630 14340 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14310 1 0 {name=M1085
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14350 0 0 {name=p262 lab=word239}
N 0 14350 40 14350 {
lab=word239}
N 40 14350 80 14350 {
lab=word239}
N 10 14340 10 14390 {
lab=GND}
N 10 14390 10 14400 {
lab=GND}
N 70 14340 70 14390 {
lab=Y0}
N 70 14390 70 14400 {
lab=Y0}

N 90 14400 120 14400 {
lab=GND}
N 120 14390 120 14400 {
lab=GND}
N 80 14350 120 14350 {
lab=word239}
N 120 14350 160 14350 {
lab=word239}
N 90 14340 90 14390 {
lab=GND}
N 90 14390 90 14400 {
lab=GND}
N 150 14340 150 14390 {
lab=Y1}
N 150 14390 150 14400 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 14370 1 0 {name=M1086
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 14350 200 14350 {
lab=word239}
N 200 14350 240 14350 {
lab=word239}
N 170 14340 170 14390 {
lab=GND}
N 170 14390 170 14400 {
lab=GND}
N 230 14340 230 14390 {
lab=Y2}
N 230 14390 230 14400 {
lab=Y2}
N 240 14350 280 14350 {
lab=word239}
N 280 14350 320 14350 {
lab=word239}
N 250 14340 250 14390 {
lab=GND}
N 250 14390 250 14400 {
lab=GND}
N 310 14340 310 14390 {
lab=Y3}
N 310 14390 310 14400 {
lab=Y3}
N 320 14350 360 14350 {
lab=word239}
N 360 14350 400 14350 {
lab=word239}
N 330 14340 330 14390 {
lab=GND}
N 330 14390 330 14400 {
lab=GND}
N 390 14340 390 14390 {
lab=Y4}
N 390 14390 390 14400 {
lab=Y4}
N 400 14350 440 14350 {
lab=word239}
N 440 14350 480 14350 {
lab=word239}
N 410 14340 410 14390 {
lab=GND}
N 410 14390 410 14400 {
lab=GND}
N 470 14340 470 14390 {
lab=Y5}
N 470 14390 470 14400 {
lab=Y5}

N 490 14400 520 14400 {
lab=GND}
N 520 14390 520 14400 {
lab=GND}
N 480 14350 520 14350 {
lab=word239}
N 520 14350 560 14350 {
lab=word239}
N 490 14340 490 14390 {
lab=GND}
N 490 14390 490 14400 {
lab=GND}
N 550 14340 550 14390 {
lab=Y6}
N 550 14390 550 14400 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14370 1 0 {name=M1087
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14400 600 14400 {
lab=GND}
N 600 14390 600 14400 {
lab=GND}
N 560 14350 600 14350 {
lab=word239}
N 600 14350 640 14350 {
lab=word239}
N 570 14340 570 14390 {
lab=GND}
N 570 14390 570 14400 {
lab=GND}
N 630 14340 630 14390 {
lab=Y7}
N 630 14390 630 14400 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14370 1 0 {name=M1088
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14410 0 0 {name=p263 lab=word240}
N 0 14410 40 14410 {
lab=word240}
N 40 14410 80 14410 {
lab=word240}
N 10 14400 10 14450 {
lab=GND}
N 10 14450 10 14460 {
lab=GND}
N 70 14400 70 14450 {
lab=Y0}
N 70 14450 70 14460 {
lab=Y0}
N 80 14410 120 14410 {
lab=word240}
N 120 14410 160 14410 {
lab=word240}
N 90 14400 90 14450 {
lab=GND}
N 90 14450 90 14460 {
lab=GND}
N 150 14400 150 14450 {
lab=Y1}
N 150 14450 150 14460 {
lab=Y1}

N 170 14460 200 14460 {
lab=GND}
N 200 14450 200 14460 {
lab=GND}
N 160 14410 200 14410 {
lab=word240}
N 200 14410 240 14410 {
lab=word240}
N 170 14400 170 14450 {
lab=GND}
N 170 14450 170 14460 {
lab=GND}
N 230 14400 230 14450 {
lab=Y2}
N 230 14450 230 14460 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 14430 1 0 {name=M1089
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 14460 280 14460 {
lab=GND}
N 280 14450 280 14460 {
lab=GND}
N 240 14410 280 14410 {
lab=word240}
N 280 14410 320 14410 {
lab=word240}
N 250 14400 250 14450 {
lab=GND}
N 250 14450 250 14460 {
lab=GND}
N 310 14400 310 14450 {
lab=Y3}
N 310 14450 310 14460 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 14430 1 0 {name=M1090
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 14460 360 14460 {
lab=GND}
N 360 14450 360 14460 {
lab=GND}
N 320 14410 360 14410 {
lab=word240}
N 360 14410 400 14410 {
lab=word240}
N 330 14400 330 14450 {
lab=GND}
N 330 14450 330 14460 {
lab=GND}
N 390 14400 390 14450 {
lab=Y4}
N 390 14450 390 14460 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 14430 1 0 {name=M1091
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 14460 440 14460 {
lab=GND}
N 440 14450 440 14460 {
lab=GND}
N 400 14410 440 14410 {
lab=word240}
N 440 14410 480 14410 {
lab=word240}
N 410 14400 410 14450 {
lab=GND}
N 410 14450 410 14460 {
lab=GND}
N 470 14400 470 14450 {
lab=Y5}
N 470 14450 470 14460 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 14430 1 0 {name=M1092
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 14460 520 14460 {
lab=GND}
N 520 14450 520 14460 {
lab=GND}
N 480 14410 520 14410 {
lab=word240}
N 520 14410 560 14410 {
lab=word240}
N 490 14400 490 14450 {
lab=GND}
N 490 14450 490 14460 {
lab=GND}
N 550 14400 550 14450 {
lab=Y6}
N 550 14450 550 14460 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14430 1 0 {name=M1093
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14460 600 14460 {
lab=GND}
N 600 14450 600 14460 {
lab=GND}
N 560 14410 600 14410 {
lab=word240}
N 600 14410 640 14410 {
lab=word240}
N 570 14400 570 14450 {
lab=GND}
N 570 14450 570 14460 {
lab=GND}
N 630 14400 630 14450 {
lab=Y7}
N 630 14450 630 14460 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14430 1 0 {name=M1094
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14470 0 0 {name=p264 lab=word241}
N 0 14470 40 14470 {
lab=word241}
N 40 14470 80 14470 {
lab=word241}
N 10 14460 10 14510 {
lab=GND}
N 10 14510 10 14520 {
lab=GND}
N 70 14460 70 14510 {
lab=Y0}
N 70 14510 70 14520 {
lab=Y0}
N 80 14470 120 14470 {
lab=word241}
N 120 14470 160 14470 {
lab=word241}
N 90 14460 90 14510 {
lab=GND}
N 90 14510 90 14520 {
lab=GND}
N 150 14460 150 14510 {
lab=Y1}
N 150 14510 150 14520 {
lab=Y1}

N 170 14520 200 14520 {
lab=GND}
N 200 14510 200 14520 {
lab=GND}
N 160 14470 200 14470 {
lab=word241}
N 200 14470 240 14470 {
lab=word241}
N 170 14460 170 14510 {
lab=GND}
N 170 14510 170 14520 {
lab=GND}
N 230 14460 230 14510 {
lab=Y2}
N 230 14510 230 14520 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 14490 1 0 {name=M1095
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 14520 280 14520 {
lab=GND}
N 280 14510 280 14520 {
lab=GND}
N 240 14470 280 14470 {
lab=word241}
N 280 14470 320 14470 {
lab=word241}
N 250 14460 250 14510 {
lab=GND}
N 250 14510 250 14520 {
lab=GND}
N 310 14460 310 14510 {
lab=Y3}
N 310 14510 310 14520 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 14490 1 0 {name=M1096
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 14520 360 14520 {
lab=GND}
N 360 14510 360 14520 {
lab=GND}
N 320 14470 360 14470 {
lab=word241}
N 360 14470 400 14470 {
lab=word241}
N 330 14460 330 14510 {
lab=GND}
N 330 14510 330 14520 {
lab=GND}
N 390 14460 390 14510 {
lab=Y4}
N 390 14510 390 14520 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 14490 1 0 {name=M1097
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 14470 440 14470 {
lab=word241}
N 440 14470 480 14470 {
lab=word241}
N 410 14460 410 14510 {
lab=GND}
N 410 14510 410 14520 {
lab=GND}
N 470 14460 470 14510 {
lab=Y5}
N 470 14510 470 14520 {
lab=Y5}

N 490 14520 520 14520 {
lab=GND}
N 520 14510 520 14520 {
lab=GND}
N 480 14470 520 14470 {
lab=word241}
N 520 14470 560 14470 {
lab=word241}
N 490 14460 490 14510 {
lab=GND}
N 490 14510 490 14520 {
lab=GND}
N 550 14460 550 14510 {
lab=Y6}
N 550 14510 550 14520 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14490 1 0 {name=M1098
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14520 600 14520 {
lab=GND}
N 600 14510 600 14520 {
lab=GND}
N 560 14470 600 14470 {
lab=word241}
N 600 14470 640 14470 {
lab=word241}
N 570 14460 570 14510 {
lab=GND}
N 570 14510 570 14520 {
lab=GND}
N 630 14460 630 14510 {
lab=Y7}
N 630 14510 630 14520 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14490 1 0 {name=M1099
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14530 0 0 {name=p265 lab=word242}
N 0 14530 40 14530 {
lab=word242}
N 40 14530 80 14530 {
lab=word242}
N 10 14520 10 14570 {
lab=GND}
N 10 14570 10 14580 {
lab=GND}
N 70 14520 70 14570 {
lab=Y0}
N 70 14570 70 14580 {
lab=Y0}
N 80 14530 120 14530 {
lab=word242}
N 120 14530 160 14530 {
lab=word242}
N 90 14520 90 14570 {
lab=GND}
N 90 14570 90 14580 {
lab=GND}
N 150 14520 150 14570 {
lab=Y1}
N 150 14570 150 14580 {
lab=Y1}

N 170 14580 200 14580 {
lab=GND}
N 200 14570 200 14580 {
lab=GND}
N 160 14530 200 14530 {
lab=word242}
N 200 14530 240 14530 {
lab=word242}
N 170 14520 170 14570 {
lab=GND}
N 170 14570 170 14580 {
lab=GND}
N 230 14520 230 14570 {
lab=Y2}
N 230 14570 230 14580 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 14550 1 0 {name=M1100
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 14580 280 14580 {
lab=GND}
N 280 14570 280 14580 {
lab=GND}
N 240 14530 280 14530 {
lab=word242}
N 280 14530 320 14530 {
lab=word242}
N 250 14520 250 14570 {
lab=GND}
N 250 14570 250 14580 {
lab=GND}
N 310 14520 310 14570 {
lab=Y3}
N 310 14570 310 14580 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 14550 1 0 {name=M1101
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
