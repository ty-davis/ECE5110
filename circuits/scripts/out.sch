ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21970 0 0 {name=p389 lab=word366}

N 10 22020 40 22020 {
lab=GND}
N 40 22010 40 22020 {
lab=GND}
N 0 21970 40 21970 {
lab=word366}
N 40 21970 80 21970 {
lab=word366}
N 10 21960 10 22010 {
lab=GND}
N 10 22010 10 22020 {
lab=GND}
N 70 21960 70 22010 {
lab=Y0}
N 70 22010 70 22020 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21990 1 0 {name=M1614
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22020 120 22020 {
lab=GND}
N 120 22010 120 22020 {
lab=GND}
N 80 21970 120 21970 {
lab=word366}
N 120 21970 160 21970 {
lab=word366}
N 90 21960 90 22010 {
lab=GND}
N 90 22010 90 22020 {
lab=GND}
N 150 21960 150 22010 {
lab=Y1}
N 150 22010 150 22020 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21990 1 0 {name=M1615
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21970 200 21970 {
lab=word366}
N 200 21970 240 21970 {
lab=word366}
N 170 21960 170 22010 {
lab=GND}
N 170 22010 170 22020 {
lab=GND}
N 230 21960 230 22010 {
lab=Y2}
N 230 22010 230 22020 {
lab=Y2}

N 250 22020 280 22020 {
lab=GND}
N 280 22010 280 22020 {
lab=GND}
N 240 21970 280 21970 {
lab=word366}
N 280 21970 320 21970 {
lab=word366}
N 250 21960 250 22010 {
lab=GND}
N 250 22010 250 22020 {
lab=GND}
N 310 21960 310 22010 {
lab=Y3}
N 310 22010 310 22020 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 21990 1 0 {name=M1616
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 22020 360 22020 {
lab=GND}
N 360 22010 360 22020 {
lab=GND}
N 320 21970 360 21970 {
lab=word366}
N 360 21970 400 21970 {
lab=word366}
N 330 21960 330 22010 {
lab=GND}
N 330 22010 330 22020 {
lab=GND}
N 390 21960 390 22010 {
lab=Y4}
N 390 22010 390 22020 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 21990 1 0 {name=M1617
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 21970 440 21970 {
lab=word366}
N 440 21970 480 21970 {
lab=word366}
N 410 21960 410 22010 {
lab=GND}
N 410 22010 410 22020 {
lab=GND}
N 470 21960 470 22010 {
lab=Y5}
N 470 22010 470 22020 {
lab=Y5}

N 490 22020 520 22020 {
lab=GND}
N 520 22010 520 22020 {
lab=GND}
N 480 21970 520 21970 {
lab=word366}
N 520 21970 560 21970 {
lab=word366}
N 490 21960 490 22010 {
lab=GND}
N 490 22010 490 22020 {
lab=GND}
N 550 21960 550 22010 {
lab=Y6}
N 550 22010 550 22020 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 21990 1 0 {name=M1618
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 22020 600 22020 {
lab=GND}
N 600 22010 600 22020 {
lab=GND}
N 560 21970 600 21970 {
lab=word366}
N 600 21970 640 21970 {
lab=word366}
N 570 21960 570 22010 {
lab=GND}
N 570 22010 570 22020 {
lab=GND}
N 630 21960 630 22010 {
lab=Y7}
N 630 22010 630 22020 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21990 1 0 {name=M1619
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22030 0 0 {name=p390 lab=word367}

N 10 22080 40 22080 {
lab=GND}
N 40 22070 40 22080 {
lab=GND}
N 0 22030 40 22030 {
lab=word367}
N 40 22030 80 22030 {
lab=word367}
N 10 22020 10 22070 {
lab=GND}
N 10 22070 10 22080 {
lab=GND}
N 70 22020 70 22070 {
lab=Y0}
N 70 22070 70 22080 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22050 1 0 {name=M1620
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22080 120 22080 {
lab=GND}
N 120 22070 120 22080 {
lab=GND}
N 80 22030 120 22030 {
lab=word367}
N 120 22030 160 22030 {
lab=word367}
N 90 22020 90 22070 {
lab=GND}
N 90 22070 90 22080 {
lab=GND}
N 150 22020 150 22070 {
lab=Y1}
N 150 22070 150 22080 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22050 1 0 {name=M1621
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 22030 200 22030 {
lab=word367}
N 200 22030 240 22030 {
lab=word367}
N 170 22020 170 22070 {
lab=GND}
N 170 22070 170 22080 {
lab=GND}
N 230 22020 230 22070 {
lab=Y2}
N 230 22070 230 22080 {
lab=Y2}

N 250 22080 280 22080 {
lab=GND}
N 280 22070 280 22080 {
lab=GND}
N 240 22030 280 22030 {
lab=word367}
N 280 22030 320 22030 {
lab=word367}
N 250 22020 250 22070 {
lab=GND}
N 250 22070 250 22080 {
lab=GND}
N 310 22020 310 22070 {
lab=Y3}
N 310 22070 310 22080 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 22050 1 0 {name=M1622
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 22080 360 22080 {
lab=GND}
N 360 22070 360 22080 {
lab=GND}
N 320 22030 360 22030 {
lab=word367}
N 360 22030 400 22030 {
lab=word367}
N 330 22020 330 22070 {
lab=GND}
N 330 22070 330 22080 {
lab=GND}
N 390 22020 390 22070 {
lab=Y4}
N 390 22070 390 22080 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 22050 1 0 {name=M1623
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 22080 440 22080 {
lab=GND}
N 440 22070 440 22080 {
lab=GND}
N 400 22030 440 22030 {
lab=word367}
N 440 22030 480 22030 {
lab=word367}
N 410 22020 410 22070 {
lab=GND}
N 410 22070 410 22080 {
lab=GND}
N 470 22020 470 22070 {
lab=Y5}
N 470 22070 470 22080 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 22050 1 0 {name=M1624
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 22030 520 22030 {
lab=word367}
N 520 22030 560 22030 {
lab=word367}
N 490 22020 490 22070 {
lab=GND}
N 490 22070 490 22080 {
lab=GND}
N 550 22020 550 22070 {
lab=Y6}
N 550 22070 550 22080 {
lab=Y6}

N 570 22080 600 22080 {
lab=GND}
N 600 22070 600 22080 {
lab=GND}
N 560 22030 600 22030 {
lab=word367}
N 600 22030 640 22030 {
lab=word367}
N 570 22020 570 22070 {
lab=GND}
N 570 22070 570 22080 {
lab=GND}
N 630 22020 630 22070 {
lab=Y7}
N 630 22070 630 22080 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22050 1 0 {name=M1625
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22090 0 0 {name=p391 lab=word368}

N 10 22140 40 22140 {
lab=GND}
N 40 22130 40 22140 {
lab=GND}
N 0 22090 40 22090 {
lab=word368}
N 40 22090 80 22090 {
lab=word368}
N 10 22080 10 22130 {
lab=GND}
N 10 22130 10 22140 {
lab=GND}
N 70 22080 70 22130 {
lab=Y0}
N 70 22130 70 22140 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22110 1 0 {name=M1626
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22140 120 22140 {
lab=GND}
N 120 22130 120 22140 {
lab=GND}
N 80 22090 120 22090 {
lab=word368}
N 120 22090 160 22090 {
lab=word368}
N 90 22080 90 22130 {
lab=GND}
N 90 22130 90 22140 {
lab=GND}
N 150 22080 150 22130 {
lab=Y1}
N 150 22130 150 22140 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22110 1 0 {name=M1627
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 22090 200 22090 {
lab=word368}
N 200 22090 240 22090 {
lab=word368}
N 170 22080 170 22130 {
lab=GND}
N 170 22130 170 22140 {
lab=GND}
N 230 22080 230 22130 {
lab=Y2}
N 230 22130 230 22140 {
lab=Y2}

N 250 22140 280 22140 {
lab=GND}
N 280 22130 280 22140 {
lab=GND}
N 240 22090 280 22090 {
lab=word368}
N 280 22090 320 22090 {
lab=word368}
N 250 22080 250 22130 {
lab=GND}
N 250 22130 250 22140 {
lab=GND}
N 310 22080 310 22130 {
lab=Y3}
N 310 22130 310 22140 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 22110 1 0 {name=M1628
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 22140 360 22140 {
lab=GND}
N 360 22130 360 22140 {
lab=GND}
N 320 22090 360 22090 {
lab=word368}
N 360 22090 400 22090 {
lab=word368}
N 330 22080 330 22130 {
lab=GND}
N 330 22130 330 22140 {
lab=GND}
N 390 22080 390 22130 {
lab=Y4}
N 390 22130 390 22140 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 22110 1 0 {name=M1629
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 22140 440 22140 {
lab=GND}
N 440 22130 440 22140 {
lab=GND}
N 400 22090 440 22090 {
lab=word368}
N 440 22090 480 22090 {
lab=word368}
N 410 22080 410 22130 {
lab=GND}
N 410 22130 410 22140 {
lab=GND}
N 470 22080 470 22130 {
lab=Y5}
N 470 22130 470 22140 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 22110 1 0 {name=M1630
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 22140 520 22140 {
lab=GND}
N 520 22130 520 22140 {
lab=GND}
N 480 22090 520 22090 {
lab=word368}
N 520 22090 560 22090 {
lab=word368}
N 490 22080 490 22130 {
lab=GND}
N 490 22130 490 22140 {
lab=GND}
N 550 22080 550 22130 {
lab=Y6}
N 550 22130 550 22140 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 22110 1 0 {name=M1631
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 22140 600 22140 {
lab=GND}
N 600 22130 600 22140 {
lab=GND}
N 560 22090 600 22090 {
lab=word368}
N 600 22090 640 22090 {
lab=word368}
N 570 22080 570 22130 {
lab=GND}
N 570 22130 570 22140 {
lab=GND}
N 630 22080 630 22130 {
lab=Y7}
N 630 22130 630 22140 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22110 1 0 {name=M1632
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22150 0 0 {name=p392 lab=word369}

N 10 22200 40 22200 {
lab=GND}
N 40 22190 40 22200 {
lab=GND}
N 0 22150 40 22150 {
lab=word369}
N 40 22150 80 22150 {
lab=word369}
N 10 22140 10 22190 {
lab=GND}
N 10 22190 10 22200 {
lab=GND}
N 70 22140 70 22190 {
lab=Y0}
N 70 22190 70 22200 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22170 1 0 {name=M1633
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22200 120 22200 {
lab=GND}
N 120 22190 120 22200 {
lab=GND}
N 80 22150 120 22150 {
lab=word369}
N 120 22150 160 22150 {
lab=word369}
N 90 22140 90 22190 {
lab=GND}
N 90 22190 90 22200 {
lab=GND}
N 150 22140 150 22190 {
lab=Y1}
N 150 22190 150 22200 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22170 1 0 {name=M1634
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22200 200 22200 {
lab=GND}
N 200 22190 200 22200 {
lab=GND}
N 160 22150 200 22150 {
lab=word369}
N 200 22150 240 22150 {
lab=word369}
N 170 22140 170 22190 {
lab=GND}
N 170 22190 170 22200 {
lab=GND}
N 230 22140 230 22190 {
lab=Y2}
N 230 22190 230 22200 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22170 1 0 {name=M1635
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 22150 280 22150 {
lab=word369}
N 280 22150 320 22150 {
lab=word369}
N 250 22140 250 22190 {
lab=GND}
N 250 22190 250 22200 {
lab=GND}
N 310 22140 310 22190 {
lab=Y3}
N 310 22190 310 22200 {
lab=Y3}
N 320 22150 360 22150 {
lab=word369}
N 360 22150 400 22150 {
lab=word369}
N 330 22140 330 22190 {
lab=GND}
N 330 22190 330 22200 {
lab=GND}
N 390 22140 390 22190 {
lab=Y4}
N 390 22190 390 22200 {
lab=Y4}
N 400 22150 440 22150 {
lab=word369}
N 440 22150 480 22150 {
lab=word369}
N 410 22140 410 22190 {
lab=GND}
N 410 22190 410 22200 {
lab=GND}
N 470 22140 470 22190 {
lab=Y5}
N 470 22190 470 22200 {
lab=Y5}
N 480 22150 520 22150 {
lab=word369}
N 520 22150 560 22150 {
lab=word369}
N 490 22140 490 22190 {
lab=GND}
N 490 22190 490 22200 {
lab=GND}
N 550 22140 550 22190 {
lab=Y6}
N 550 22190 550 22200 {
lab=Y6}

N 570 22200 600 22200 {
lab=GND}
N 600 22190 600 22200 {
lab=GND}
N 560 22150 600 22150 {
lab=word369}
N 600 22150 640 22150 {
lab=word369}
N 570 22140 570 22190 {
lab=GND}
N 570 22190 570 22200 {
lab=GND}
N 630 22140 630 22190 {
lab=Y7}
N 630 22190 630 22200 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22170 1 0 {name=M1636
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22210 0 0 {name=p393 lab=word370}

N 10 22260 40 22260 {
lab=GND}
N 40 22250 40 22260 {
lab=GND}
N 0 22210 40 22210 {
lab=word370}
N 40 22210 80 22210 {
lab=word370}
N 10 22200 10 22250 {
lab=GND}
N 10 22250 10 22260 {
lab=GND}
N 70 22200 70 22250 {
lab=Y0}
N 70 22250 70 22260 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22230 1 0 {name=M1637
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22260 120 22260 {
lab=GND}
N 120 22250 120 22260 {
lab=GND}
N 80 22210 120 22210 {
lab=word370}
N 120 22210 160 22210 {
lab=word370}
N 90 22200 90 22250 {
lab=GND}
N 90 22250 90 22260 {
lab=GND}
N 150 22200 150 22250 {
lab=Y1}
N 150 22250 150 22260 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22230 1 0 {name=M1638
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22260 200 22260 {
lab=GND}
N 200 22250 200 22260 {
lab=GND}
N 160 22210 200 22210 {
lab=word370}
N 200 22210 240 22210 {
lab=word370}
N 170 22200 170 22250 {
lab=GND}
N 170 22250 170 22260 {
lab=GND}
N 230 22200 230 22250 {
lab=Y2}
N 230 22250 230 22260 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22230 1 0 {name=M1639
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 22210 280 22210 {
lab=word370}
N 280 22210 320 22210 {
lab=word370}
N 250 22200 250 22250 {
lab=GND}
N 250 22250 250 22260 {
lab=GND}
N 310 22200 310 22250 {
lab=Y3}
N 310 22250 310 22260 {
lab=Y3}
N 320 22210 360 22210 {
lab=word370}
N 360 22210 400 22210 {
lab=word370}
N 330 22200 330 22250 {
lab=GND}
N 330 22250 330 22260 {
lab=GND}
N 390 22200 390 22250 {
lab=Y4}
N 390 22250 390 22260 {
lab=Y4}
N 400 22210 440 22210 {
lab=word370}
N 440 22210 480 22210 {
lab=word370}
N 410 22200 410 22250 {
lab=GND}
N 410 22250 410 22260 {
lab=GND}
N 470 22200 470 22250 {
lab=Y5}
N 470 22250 470 22260 {
lab=Y5}

N 490 22260 520 22260 {
lab=GND}
N 520 22250 520 22260 {
lab=GND}
N 480 22210 520 22210 {
lab=word370}
N 520 22210 560 22210 {
lab=word370}
N 490 22200 490 22250 {
lab=GND}
N 490 22250 490 22260 {
lab=GND}
N 550 22200 550 22250 {
lab=Y6}
N 550 22250 550 22260 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 22230 1 0 {name=M1640
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 22260 600 22260 {
lab=GND}
N 600 22250 600 22260 {
lab=GND}
N 560 22210 600 22210 {
lab=word370}
N 600 22210 640 22210 {
lab=word370}
N 570 22200 570 22250 {
lab=GND}
N 570 22250 570 22260 {
lab=GND}
N 630 22200 630 22250 {
lab=Y7}
N 630 22250 630 22260 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22230 1 0 {name=M1641
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22270 0 0 {name=p394 lab=word371}

N 10 22320 40 22320 {
lab=GND}
N 40 22310 40 22320 {
lab=GND}
N 0 22270 40 22270 {
lab=word371}
N 40 22270 80 22270 {
lab=word371}
N 10 22260 10 22310 {
lab=GND}
N 10 22310 10 22320 {
lab=GND}
N 70 22260 70 22310 {
lab=Y0}
N 70 22310 70 22320 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22290 1 0 {name=M1642
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22320 120 22320 {
lab=GND}
N 120 22310 120 22320 {
lab=GND}
N 80 22270 120 22270 {
lab=word371}
N 120 22270 160 22270 {
lab=word371}
N 90 22260 90 22310 {
lab=GND}
N 90 22310 90 22320 {
lab=GND}
N 150 22260 150 22310 {
lab=Y1}
N 150 22310 150 22320 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22290 1 0 {name=M1643
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22320 200 22320 {
lab=GND}
N 200 22310 200 22320 {
lab=GND}
N 160 22270 200 22270 {
lab=word371}
N 200 22270 240 22270 {
lab=word371}
N 170 22260 170 22310 {
lab=GND}
N 170 22310 170 22320 {
lab=GND}
N 230 22260 230 22310 {
lab=Y2}
N 230 22310 230 22320 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22290 1 0 {name=M1644
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 22270 280 22270 {
lab=word371}
N 280 22270 320 22270 {
lab=word371}
N 250 22260 250 22310 {
lab=GND}
N 250 22310 250 22320 {
lab=GND}
N 310 22260 310 22310 {
lab=Y3}
N 310 22310 310 22320 {
lab=Y3}
N 320 22270 360 22270 {
lab=word371}
N 360 22270 400 22270 {
lab=word371}
N 330 22260 330 22310 {
lab=GND}
N 330 22310 330 22320 {
lab=GND}
N 390 22260 390 22310 {
lab=Y4}
N 390 22310 390 22320 {
lab=Y4}

N 410 22320 440 22320 {
lab=GND}
N 440 22310 440 22320 {
lab=GND}
N 400 22270 440 22270 {
lab=word371}
N 440 22270 480 22270 {
lab=word371}
N 410 22260 410 22310 {
lab=GND}
N 410 22310 410 22320 {
lab=GND}
N 470 22260 470 22310 {
lab=Y5}
N 470 22310 470 22320 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 22290 1 0 {name=M1645
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 22270 520 22270 {
lab=word371}
N 520 22270 560 22270 {
lab=word371}
N 490 22260 490 22310 {
lab=GND}
N 490 22310 490 22320 {
lab=GND}
N 550 22260 550 22310 {
lab=Y6}
N 550 22310 550 22320 {
lab=Y6}

N 570 22320 600 22320 {
lab=GND}
N 600 22310 600 22320 {
lab=GND}
N 560 22270 600 22270 {
lab=word371}
N 600 22270 640 22270 {
lab=word371}
N 570 22260 570 22310 {
lab=GND}
N 570 22310 570 22320 {
lab=GND}
N 630 22260 630 22310 {
lab=Y7}
N 630 22310 630 22320 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22290 1 0 {name=M1646
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22330 0 0 {name=p395 lab=word372}

N 10 22380 40 22380 {
lab=GND}
N 40 22370 40 22380 {
lab=GND}
N 0 22330 40 22330 {
lab=word372}
N 40 22330 80 22330 {
lab=word372}
N 10 22320 10 22370 {
lab=GND}
N 10 22370 10 22380 {
lab=GND}
N 70 22320 70 22370 {
lab=Y0}
N 70 22370 70 22380 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22350 1 0 {name=M1647
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22380 120 22380 {
lab=GND}
N 120 22370 120 22380 {
lab=GND}
N 80 22330 120 22330 {
lab=word372}
N 120 22330 160 22330 {
lab=word372}
N 90 22320 90 22370 {
lab=GND}
N 90 22370 90 22380 {
lab=GND}
N 150 22320 150 22370 {
lab=Y1}
N 150 22370 150 22380 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22350 1 0 {name=M1648
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22380 200 22380 {
lab=GND}
N 200 22370 200 22380 {
lab=GND}
N 160 22330 200 22330 {
lab=word372}
N 200 22330 240 22330 {
lab=word372}
N 170 22320 170 22370 {
lab=GND}
N 170 22370 170 22380 {
lab=GND}
N 230 22320 230 22370 {
lab=Y2}
N 230 22370 230 22380 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22350 1 0 {name=M1649
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 22330 280 22330 {
lab=word372}
N 280 22330 320 22330 {
lab=word372}
N 250 22320 250 22370 {
lab=GND}
N 250 22370 250 22380 {
lab=GND}
N 310 22320 310 22370 {
lab=Y3}
N 310 22370 310 22380 {
lab=Y3}
N 320 22330 360 22330 {
lab=word372}
N 360 22330 400 22330 {
lab=word372}
N 330 22320 330 22370 {
lab=GND}
N 330 22370 330 22380 {
lab=GND}
N 390 22320 390 22370 {
lab=Y4}
N 390 22370 390 22380 {
lab=Y4}

N 410 22380 440 22380 {
lab=GND}
N 440 22370 440 22380 {
lab=GND}
N 400 22330 440 22330 {
lab=word372}
N 440 22330 480 22330 {
lab=word372}
N 410 22320 410 22370 {
lab=GND}
N 410 22370 410 22380 {
lab=GND}
N 470 22320 470 22370 {
lab=Y5}
N 470 22370 470 22380 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 22350 1 0 {name=M1650
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 22380 520 22380 {
lab=GND}
N 520 22370 520 22380 {
lab=GND}
N 480 22330 520 22330 {
lab=word372}
N 520 22330 560 22330 {
lab=word372}
N 490 22320 490 22370 {
lab=GND}
N 490 22370 490 22380 {
lab=GND}
N 550 22320 550 22370 {
lab=Y6}
N 550 22370 550 22380 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 22350 1 0 {name=M1651
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 22380 600 22380 {
lab=GND}
N 600 22370 600 22380 {
lab=GND}
N 560 22330 600 22330 {
lab=word372}
N 600 22330 640 22330 {
lab=word372}
N 570 22320 570 22370 {
lab=GND}
N 570 22370 570 22380 {
lab=GND}
N 630 22320 630 22370 {
lab=Y7}
N 630 22370 630 22380 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22350 1 0 {name=M1652
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22390 0 0 {name=p396 lab=word373}

N 10 22440 40 22440 {
lab=GND}
N 40 22430 40 22440 {
lab=GND}
N 0 22390 40 22390 {
lab=word373}
N 40 22390 80 22390 {
lab=word373}
N 10 22380 10 22430 {
lab=GND}
N 10 22430 10 22440 {
lab=GND}
N 70 22380 70 22430 {
lab=Y0}
N 70 22430 70 22440 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22410 1 0 {name=M1653
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22440 120 22440 {
lab=GND}
N 120 22430 120 22440 {
lab=GND}
N 80 22390 120 22390 {
lab=word373}
N 120 22390 160 22390 {
lab=word373}
N 90 22380 90 22430 {
lab=GND}
N 90 22430 90 22440 {
lab=GND}
N 150 22380 150 22430 {
lab=Y1}
N 150 22430 150 22440 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22410 1 0 {name=M1654
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22440 200 22440 {
lab=GND}
N 200 22430 200 22440 {
lab=GND}
N 160 22390 200 22390 {
lab=word373}
N 200 22390 240 22390 {
lab=word373}
N 170 22380 170 22430 {
lab=GND}
N 170 22430 170 22440 {
lab=GND}
N 230 22380 230 22430 {
lab=Y2}
N 230 22430 230 22440 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22410 1 0 {name=M1655
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 22390 280 22390 {
lab=word373}
N 280 22390 320 22390 {
lab=word373}
N 250 22380 250 22430 {
lab=GND}
N 250 22430 250 22440 {
lab=GND}
N 310 22380 310 22430 {
lab=Y3}
N 310 22430 310 22440 {
lab=Y3}

N 330 22440 360 22440 {
lab=GND}
N 360 22430 360 22440 {
lab=GND}
N 320 22390 360 22390 {
lab=word373}
N 360 22390 400 22390 {
lab=word373}
N 330 22380 330 22430 {
lab=GND}
N 330 22430 330 22440 {
lab=GND}
N 390 22380 390 22430 {
lab=Y4}
N 390 22430 390 22440 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 22410 1 0 {name=M1656
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 22390 440 22390 {
lab=word373}
N 440 22390 480 22390 {
lab=word373}
N 410 22380 410 22430 {
lab=GND}
N 410 22430 410 22440 {
lab=GND}
N 470 22380 470 22430 {
lab=Y5}
N 470 22430 470 22440 {
lab=Y5}
N 480 22390 520 22390 {
lab=word373}
N 520 22390 560 22390 {
lab=word373}
N 490 22380 490 22430 {
lab=GND}
N 490 22430 490 22440 {
lab=GND}
N 550 22380 550 22430 {
lab=Y6}
N 550 22430 550 22440 {
lab=Y6}

N 570 22440 600 22440 {
lab=GND}
N 600 22430 600 22440 {
lab=GND}
N 560 22390 600 22390 {
lab=word373}
N 600 22390 640 22390 {
lab=word373}
N 570 22380 570 22430 {
lab=GND}
N 570 22430 570 22440 {
lab=GND}
N 630 22380 630 22430 {
lab=Y7}
N 630 22430 630 22440 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22410 1 0 {name=M1657
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22450 0 0 {name=p397 lab=word374}

N 10 22500 40 22500 {
lab=GND}
N 40 22490 40 22500 {
lab=GND}
N 0 22450 40 22450 {
lab=word374}
N 40 22450 80 22450 {
lab=word374}
N 10 22440 10 22490 {
lab=GND}
N 10 22490 10 22500 {
lab=GND}
N 70 22440 70 22490 {
lab=Y0}
N 70 22490 70 22500 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22470 1 0 {name=M1658
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22500 120 22500 {
lab=GND}
N 120 22490 120 22500 {
lab=GND}
N 80 22450 120 22450 {
lab=word374}
N 120 22450 160 22450 {
lab=word374}
N 90 22440 90 22490 {
lab=GND}
N 90 22490 90 22500 {
lab=GND}
N 150 22440 150 22490 {
lab=Y1}
N 150 22490 150 22500 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22470 1 0 {name=M1659
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22500 200 22500 {
lab=GND}
N 200 22490 200 22500 {
lab=GND}
N 160 22450 200 22450 {
lab=word374}
N 200 22450 240 22450 {
lab=word374}
N 170 22440 170 22490 {
lab=GND}
N 170 22490 170 22500 {
lab=GND}
N 230 22440 230 22490 {
lab=Y2}
N 230 22490 230 22500 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22470 1 0 {name=M1660
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 22450 280 22450 {
lab=word374}
N 280 22450 320 22450 {
lab=word374}
N 250 22440 250 22490 {
lab=GND}
N 250 22490 250 22500 {
lab=GND}
N 310 22440 310 22490 {
lab=Y3}
N 310 22490 310 22500 {
lab=Y3}

N 330 22500 360 22500 {
lab=GND}
N 360 22490 360 22500 {
lab=GND}
N 320 22450 360 22450 {
lab=word374}
N 360 22450 400 22450 {
lab=word374}
N 330 22440 330 22490 {
lab=GND}
N 330 22490 330 22500 {
lab=GND}
N 390 22440 390 22490 {
lab=Y4}
N 390 22490 390 22500 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 22470 1 0 {name=M1661
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 22450 440 22450 {
lab=word374}
N 440 22450 480 22450 {
lab=word374}
N 410 22440 410 22490 {
lab=GND}
N 410 22490 410 22500 {
lab=GND}
N 470 22440 470 22490 {
lab=Y5}
N 470 22490 470 22500 {
lab=Y5}

N 490 22500 520 22500 {
lab=GND}
N 520 22490 520 22500 {
lab=GND}
N 480 22450 520 22450 {
lab=word374}
N 520 22450 560 22450 {
lab=word374}
N 490 22440 490 22490 {
lab=GND}
N 490 22490 490 22500 {
lab=GND}
N 550 22440 550 22490 {
lab=Y6}
N 550 22490 550 22500 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 22470 1 0 {name=M1662
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 22500 600 22500 {
lab=GND}
N 600 22490 600 22500 {
lab=GND}
N 560 22450 600 22450 {
lab=word374}
N 600 22450 640 22450 {
lab=word374}
N 570 22440 570 22490 {
lab=GND}
N 570 22490 570 22500 {
lab=GND}
N 630 22440 630 22490 {
lab=Y7}
N 630 22490 630 22500 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22470 1 0 {name=M1663
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22510 0 0 {name=p398 lab=word375}

N 10 22560 40 22560 {
lab=GND}
N 40 22550 40 22560 {
lab=GND}
N 0 22510 40 22510 {
lab=word375}
N 40 22510 80 22510 {
lab=word375}
N 10 22500 10 22550 {
lab=GND}
N 10 22550 10 22560 {
lab=GND}
N 70 22500 70 22550 {
lab=Y0}
N 70 22550 70 22560 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22530 1 0 {name=M1664
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22560 120 22560 {
lab=GND}
N 120 22550 120 22560 {
lab=GND}
N 80 22510 120 22510 {
lab=word375}
N 120 22510 160 22510 {
lab=word375}
N 90 22500 90 22550 {
lab=GND}
N 90 22550 90 22560 {
lab=GND}
N 150 22500 150 22550 {
lab=Y1}
N 150 22550 150 22560 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22530 1 0 {name=M1665
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22560 200 22560 {
lab=GND}
N 200 22550 200 22560 {
lab=GND}
N 160 22510 200 22510 {
lab=word375}
N 200 22510 240 22510 {
lab=word375}
N 170 22500 170 22550 {
lab=GND}
N 170 22550 170 22560 {
lab=GND}
N 230 22500 230 22550 {
lab=Y2}
N 230 22550 230 22560 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22530 1 0 {name=M1666
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 22510 280 22510 {
lab=word375}
N 280 22510 320 22510 {
lab=word375}
N 250 22500 250 22550 {
lab=GND}
N 250 22550 250 22560 {
lab=GND}
N 310 22500 310 22550 {
lab=Y3}
N 310 22550 310 22560 {
lab=Y3}

N 330 22560 360 22560 {
lab=GND}
N 360 22550 360 22560 {
lab=GND}
N 320 22510 360 22510 {
lab=word375}
N 360 22510 400 22510 {
lab=word375}
N 330 22500 330 22550 {
lab=GND}
N 330 22550 330 22560 {
lab=GND}
N 390 22500 390 22550 {
lab=Y4}
N 390 22550 390 22560 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 22530 1 0 {name=M1667
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 22560 440 22560 {
lab=GND}
N 440 22550 440 22560 {
lab=GND}
N 400 22510 440 22510 {
lab=word375}
N 440 22510 480 22510 {
lab=word375}
N 410 22500 410 22550 {
lab=GND}
N 410 22550 410 22560 {
lab=GND}
N 470 22500 470 22550 {
lab=Y5}
N 470 22550 470 22560 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 22530 1 0 {name=M1668
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 22510 520 22510 {
lab=word375}
N 520 22510 560 22510 {
lab=word375}
N 490 22500 490 22550 {
lab=GND}
N 490 22550 490 22560 {
lab=GND}
N 550 22500 550 22550 {
lab=Y6}
N 550 22550 550 22560 {
lab=Y6}

N 570 22560 600 22560 {
lab=GND}
N 600 22550 600 22560 {
lab=GND}
N 560 22510 600 22510 {
lab=word375}
N 600 22510 640 22510 {
lab=word375}
N 570 22500 570 22550 {
lab=GND}
N 570 22550 570 22560 {
lab=GND}
N 630 22500 630 22550 {
lab=Y7}
N 630 22550 630 22560 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22530 1 0 {name=M1669
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22570 0 0 {name=p399 lab=word376}

N 10 22620 40 22620 {
lab=GND}
N 40 22610 40 22620 {
lab=GND}
N 0 22570 40 22570 {
lab=word376}
N 40 22570 80 22570 {
lab=word376}
N 10 22560 10 22610 {
lab=GND}
N 10 22610 10 22620 {
lab=GND}
N 70 22560 70 22610 {
lab=Y0}
N 70 22610 70 22620 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22590 1 0 {name=M1670
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22620 120 22620 {
lab=GND}
N 120 22610 120 22620 {
lab=GND}
N 80 22570 120 22570 {
lab=word376}
N 120 22570 160 22570 {
lab=word376}
N 90 22560 90 22610 {
lab=GND}
N 90 22610 90 22620 {
lab=GND}
N 150 22560 150 22610 {
lab=Y1}
N 150 22610 150 22620 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22590 1 0 {name=M1671
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22620 200 22620 {
lab=GND}
N 200 22610 200 22620 {
lab=GND}
N 160 22570 200 22570 {
lab=word376}
N 200 22570 240 22570 {
lab=word376}
N 170 22560 170 22610 {
lab=GND}
N 170 22610 170 22620 {
lab=GND}
N 230 22560 230 22610 {
lab=Y2}
N 230 22610 230 22620 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22590 1 0 {name=M1672
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 22570 280 22570 {
lab=word376}
N 280 22570 320 22570 {
lab=word376}
N 250 22560 250 22610 {
lab=GND}
N 250 22610 250 22620 {
lab=GND}
N 310 22560 310 22610 {
lab=Y3}
N 310 22610 310 22620 {
lab=Y3}

N 330 22620 360 22620 {
lab=GND}
N 360 22610 360 22620 {
lab=GND}
N 320 22570 360 22570 {
lab=word376}
N 360 22570 400 22570 {
lab=word376}
N 330 22560 330 22610 {
lab=GND}
N 330 22610 330 22620 {
lab=GND}
N 390 22560 390 22610 {
lab=Y4}
N 390 22610 390 22620 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 22590 1 0 {name=M1673
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 22620 440 22620 {
lab=GND}
N 440 22610 440 22620 {
lab=GND}
N 400 22570 440 22570 {
lab=word376}
N 440 22570 480 22570 {
lab=word376}
N 410 22560 410 22610 {
lab=GND}
N 410 22610 410 22620 {
lab=GND}
N 470 22560 470 22610 {
lab=Y5}
N 470 22610 470 22620 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 22590 1 0 {name=M1674
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 22620 520 22620 {
lab=GND}
N 520 22610 520 22620 {
lab=GND}
N 480 22570 520 22570 {
lab=word376}
N 520 22570 560 22570 {
lab=word376}
N 490 22560 490 22610 {
lab=GND}
N 490 22610 490 22620 {
lab=GND}
N 550 22560 550 22610 {
lab=Y6}
N 550 22610 550 22620 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 22590 1 0 {name=M1675
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 22620 600 22620 {
lab=GND}
N 600 22610 600 22620 {
lab=GND}
N 560 22570 600 22570 {
lab=word376}
N 600 22570 640 22570 {
lab=word376}
N 570 22560 570 22610 {
lab=GND}
N 570 22610 570 22620 {
lab=GND}
N 630 22560 630 22610 {
lab=Y7}
N 630 22610 630 22620 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22590 1 0 {name=M1676
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22630 0 0 {name=p400 lab=word377}

N 10 22680 40 22680 {
lab=GND}
N 40 22670 40 22680 {
lab=GND}
N 0 22630 40 22630 {
lab=word377}
N 40 22630 80 22630 {
lab=word377}
N 10 22620 10 22670 {
lab=GND}
N 10 22670 10 22680 {
lab=GND}
N 70 22620 70 22670 {
lab=Y0}
N 70 22670 70 22680 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22650 1 0 {name=M1677
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22680 120 22680 {
lab=GND}
N 120 22670 120 22680 {
lab=GND}
N 80 22630 120 22630 {
lab=word377}
N 120 22630 160 22630 {
lab=word377}
N 90 22620 90 22670 {
lab=GND}
N 90 22670 90 22680 {
lab=GND}
N 150 22620 150 22670 {
lab=Y1}
N 150 22670 150 22680 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22650 1 0 {name=M1678
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22680 200 22680 {
lab=GND}
N 200 22670 200 22680 {
lab=GND}
N 160 22630 200 22630 {
lab=word377}
N 200 22630 240 22630 {
lab=word377}
N 170 22620 170 22670 {
lab=GND}
N 170 22670 170 22680 {
lab=GND}
N 230 22620 230 22670 {
lab=Y2}
N 230 22670 230 22680 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22650 1 0 {name=M1679
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 22680 280 22680 {
lab=GND}
N 280 22670 280 22680 {
lab=GND}
N 240 22630 280 22630 {
lab=word377}
N 280 22630 320 22630 {
lab=word377}
N 250 22620 250 22670 {
lab=GND}
N 250 22670 250 22680 {
lab=GND}
N 310 22620 310 22670 {
lab=Y3}
N 310 22670 310 22680 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 22650 1 0 {name=M1680
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 22630 360 22630 {
lab=word377}
N 360 22630 400 22630 {
lab=word377}
N 330 22620 330 22670 {
lab=GND}
N 330 22670 330 22680 {
lab=GND}
N 390 22620 390 22670 {
lab=Y4}
N 390 22670 390 22680 {
lab=Y4}
N 400 22630 440 22630 {
lab=word377}
N 440 22630 480 22630 {
lab=word377}
N 410 22620 410 22670 {
lab=GND}
N 410 22670 410 22680 {
lab=GND}
N 470 22620 470 22670 {
lab=Y5}
N 470 22670 470 22680 {
lab=Y5}
N 480 22630 520 22630 {
lab=word377}
N 520 22630 560 22630 {
lab=word377}
N 490 22620 490 22670 {
lab=GND}
N 490 22670 490 22680 {
lab=GND}
N 550 22620 550 22670 {
lab=Y6}
N 550 22670 550 22680 {
lab=Y6}

N 570 22680 600 22680 {
lab=GND}
N 600 22670 600 22680 {
lab=GND}
N 560 22630 600 22630 {
lab=word377}
N 600 22630 640 22630 {
lab=word377}
N 570 22620 570 22670 {
lab=GND}
N 570 22670 570 22680 {
lab=GND}
N 630 22620 630 22670 {
lab=Y7}
N 630 22670 630 22680 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22650 1 0 {name=M1681
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22690 0 0 {name=p401 lab=word378}

N 10 22740 40 22740 {
lab=GND}
N 40 22730 40 22740 {
lab=GND}
N 0 22690 40 22690 {
lab=word378}
N 40 22690 80 22690 {
lab=word378}
N 10 22680 10 22730 {
lab=GND}
N 10 22730 10 22740 {
lab=GND}
N 70 22680 70 22730 {
lab=Y0}
N 70 22730 70 22740 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22710 1 0 {name=M1682
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22740 120 22740 {
lab=GND}
N 120 22730 120 22740 {
lab=GND}
N 80 22690 120 22690 {
lab=word378}
N 120 22690 160 22690 {
lab=word378}
N 90 22680 90 22730 {
lab=GND}
N 90 22730 90 22740 {
lab=GND}
N 150 22680 150 22730 {
lab=Y1}
N 150 22730 150 22740 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22710 1 0 {name=M1683
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22740 200 22740 {
lab=GND}
N 200 22730 200 22740 {
lab=GND}
N 160 22690 200 22690 {
lab=word378}
N 200 22690 240 22690 {
lab=word378}
N 170 22680 170 22730 {
lab=GND}
N 170 22730 170 22740 {
lab=GND}
N 230 22680 230 22730 {
lab=Y2}
N 230 22730 230 22740 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22710 1 0 {name=M1684
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 22740 280 22740 {
lab=GND}
N 280 22730 280 22740 {
lab=GND}
N 240 22690 280 22690 {
lab=word378}
N 280 22690 320 22690 {
lab=word378}
N 250 22680 250 22730 {
lab=GND}
N 250 22730 250 22740 {
lab=GND}
N 310 22680 310 22730 {
lab=Y3}
N 310 22730 310 22740 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 22710 1 0 {name=M1685
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 22690 360 22690 {
lab=word378}
N 360 22690 400 22690 {
lab=word378}
N 330 22680 330 22730 {
lab=GND}
N 330 22730 330 22740 {
lab=GND}
N 390 22680 390 22730 {
lab=Y4}
N 390 22730 390 22740 {
lab=Y4}
N 400 22690 440 22690 {
lab=word378}
N 440 22690 480 22690 {
lab=word378}
N 410 22680 410 22730 {
lab=GND}
N 410 22730 410 22740 {
lab=GND}
N 470 22680 470 22730 {
lab=Y5}
N 470 22730 470 22740 {
lab=Y5}

N 490 22740 520 22740 {
lab=GND}
N 520 22730 520 22740 {
lab=GND}
N 480 22690 520 22690 {
lab=word378}
N 520 22690 560 22690 {
lab=word378}
N 490 22680 490 22730 {
lab=GND}
N 490 22730 490 22740 {
lab=GND}
N 550 22680 550 22730 {
lab=Y6}
N 550 22730 550 22740 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 22710 1 0 {name=M1686
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 22740 600 22740 {
lab=GND}
N 600 22730 600 22740 {
lab=GND}
N 560 22690 600 22690 {
lab=word378}
N 600 22690 640 22690 {
lab=word378}
N 570 22680 570 22730 {
lab=GND}
N 570 22730 570 22740 {
lab=GND}
N 630 22680 630 22730 {
lab=Y7}
N 630 22730 630 22740 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22710 1 0 {name=M1687
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22750 0 0 {name=p402 lab=word379}

N 10 22800 40 22800 {
lab=GND}
N 40 22790 40 22800 {
lab=GND}
N 0 22750 40 22750 {
lab=word379}
N 40 22750 80 22750 {
lab=word379}
N 10 22740 10 22790 {
lab=GND}
N 10 22790 10 22800 {
lab=GND}
N 70 22740 70 22790 {
lab=Y0}
N 70 22790 70 22800 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22770 1 0 {name=M1688
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22800 120 22800 {
lab=GND}
N 120 22790 120 22800 {
lab=GND}
N 80 22750 120 22750 {
lab=word379}
N 120 22750 160 22750 {
lab=word379}
N 90 22740 90 22790 {
lab=GND}
N 90 22790 90 22800 {
lab=GND}
N 150 22740 150 22790 {
lab=Y1}
N 150 22790 150 22800 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22770 1 0 {name=M1689
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22800 200 22800 {
lab=GND}
N 200 22790 200 22800 {
lab=GND}
N 160 22750 200 22750 {
lab=word379}
N 200 22750 240 22750 {
lab=word379}
N 170 22740 170 22790 {
lab=GND}
N 170 22790 170 22800 {
lab=GND}
N 230 22740 230 22790 {
lab=Y2}
N 230 22790 230 22800 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22770 1 0 {name=M1690
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 22800 280 22800 {
lab=GND}
N 280 22790 280 22800 {
lab=GND}
N 240 22750 280 22750 {
lab=word379}
N 280 22750 320 22750 {
lab=word379}
N 250 22740 250 22790 {
lab=GND}
N 250 22790 250 22800 {
lab=GND}
N 310 22740 310 22790 {
lab=Y3}
N 310 22790 310 22800 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 22770 1 0 {name=M1691
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 22750 360 22750 {
lab=word379}
N 360 22750 400 22750 {
lab=word379}
N 330 22740 330 22790 {
lab=GND}
N 330 22790 330 22800 {
lab=GND}
N 390 22740 390 22790 {
lab=Y4}
N 390 22790 390 22800 {
lab=Y4}

N 410 22800 440 22800 {
lab=GND}
N 440 22790 440 22800 {
lab=GND}
N 400 22750 440 22750 {
lab=word379}
N 440 22750 480 22750 {
lab=word379}
N 410 22740 410 22790 {
lab=GND}
N 410 22790 410 22800 {
lab=GND}
N 470 22740 470 22790 {
lab=Y5}
N 470 22790 470 22800 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 22770 1 0 {name=M1692
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 22750 520 22750 {
lab=word379}
N 520 22750 560 22750 {
lab=word379}
N 490 22740 490 22790 {
lab=GND}
N 490 22790 490 22800 {
lab=GND}
N 550 22740 550 22790 {
lab=Y6}
N 550 22790 550 22800 {
lab=Y6}

N 570 22800 600 22800 {
lab=GND}
N 600 22790 600 22800 {
lab=GND}
N 560 22750 600 22750 {
lab=word379}
N 600 22750 640 22750 {
lab=word379}
N 570 22740 570 22790 {
lab=GND}
N 570 22790 570 22800 {
lab=GND}
N 630 22740 630 22790 {
lab=Y7}
N 630 22790 630 22800 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22770 1 0 {name=M1693
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22810 0 0 {name=p403 lab=word380}

N 10 22860 40 22860 {
lab=GND}
N 40 22850 40 22860 {
lab=GND}
N 0 22810 40 22810 {
lab=word380}
N 40 22810 80 22810 {
lab=word380}
N 10 22800 10 22850 {
lab=GND}
N 10 22850 10 22860 {
lab=GND}
N 70 22800 70 22850 {
lab=Y0}
N 70 22850 70 22860 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22830 1 0 {name=M1694
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22860 120 22860 {
lab=GND}
N 120 22850 120 22860 {
lab=GND}
N 80 22810 120 22810 {
lab=word380}
N 120 22810 160 22810 {
lab=word380}
N 90 22800 90 22850 {
lab=GND}
N 90 22850 90 22860 {
lab=GND}
N 150 22800 150 22850 {
lab=Y1}
N 150 22850 150 22860 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22830 1 0 {name=M1695
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22860 200 22860 {
lab=GND}
N 200 22850 200 22860 {
lab=GND}
N 160 22810 200 22810 {
lab=word380}
N 200 22810 240 22810 {
lab=word380}
N 170 22800 170 22850 {
lab=GND}
N 170 22850 170 22860 {
lab=GND}
N 230 22800 230 22850 {
lab=Y2}
N 230 22850 230 22860 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22830 1 0 {name=M1696
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 22860 280 22860 {
lab=GND}
N 280 22850 280 22860 {
lab=GND}
N 240 22810 280 22810 {
lab=word380}
N 280 22810 320 22810 {
lab=word380}
N 250 22800 250 22850 {
lab=GND}
N 250 22850 250 22860 {
lab=GND}
N 310 22800 310 22850 {
lab=Y3}
N 310 22850 310 22860 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 22830 1 0 {name=M1697
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 22810 360 22810 {
lab=word380}
N 360 22810 400 22810 {
lab=word380}
N 330 22800 330 22850 {
lab=GND}
N 330 22850 330 22860 {
lab=GND}
N 390 22800 390 22850 {
lab=Y4}
N 390 22850 390 22860 {
lab=Y4}

N 410 22860 440 22860 {
lab=GND}
N 440 22850 440 22860 {
lab=GND}
N 400 22810 440 22810 {
lab=word380}
N 440 22810 480 22810 {
lab=word380}
N 410 22800 410 22850 {
lab=GND}
N 410 22850 410 22860 {
lab=GND}
N 470 22800 470 22850 {
lab=Y5}
N 470 22850 470 22860 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 22830 1 0 {name=M1698
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 22860 520 22860 {
lab=GND}
N 520 22850 520 22860 {
lab=GND}
N 480 22810 520 22810 {
lab=word380}
N 520 22810 560 22810 {
lab=word380}
N 490 22800 490 22850 {
lab=GND}
N 490 22850 490 22860 {
lab=GND}
N 550 22800 550 22850 {
lab=Y6}
N 550 22850 550 22860 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 22830 1 0 {name=M1699
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 22860 600 22860 {
lab=GND}
N 600 22850 600 22860 {
lab=GND}
N 560 22810 600 22810 {
lab=word380}
N 600 22810 640 22810 {
lab=word380}
N 570 22800 570 22850 {
lab=GND}
N 570 22850 570 22860 {
lab=GND}
N 630 22800 630 22850 {
lab=Y7}
N 630 22850 630 22860 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22830 1 0 {name=M1700
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22870 0 0 {name=p404 lab=word381}

N 10 22920 40 22920 {
lab=GND}
N 40 22910 40 22920 {
lab=GND}
N 0 22870 40 22870 {
lab=word381}
N 40 22870 80 22870 {
lab=word381}
N 10 22860 10 22910 {
lab=GND}
N 10 22910 10 22920 {
lab=GND}
N 70 22860 70 22910 {
lab=Y0}
N 70 22910 70 22920 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22890 1 0 {name=M1701
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22920 120 22920 {
lab=GND}
N 120 22910 120 22920 {
lab=GND}
N 80 22870 120 22870 {
lab=word381}
N 120 22870 160 22870 {
lab=word381}
N 90 22860 90 22910 {
lab=GND}
N 90 22910 90 22920 {
lab=GND}
N 150 22860 150 22910 {
lab=Y1}
N 150 22910 150 22920 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22890 1 0 {name=M1702
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22920 200 22920 {
lab=GND}
N 200 22910 200 22920 {
lab=GND}
N 160 22870 200 22870 {
lab=word381}
N 200 22870 240 22870 {
lab=word381}
N 170 22860 170 22910 {
lab=GND}
N 170 22910 170 22920 {
lab=GND}
N 230 22860 230 22910 {
lab=Y2}
N 230 22910 230 22920 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22890 1 0 {name=M1703
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 22920 280 22920 {
lab=GND}
N 280 22910 280 22920 {
lab=GND}
N 240 22870 280 22870 {
lab=word381}
N 280 22870 320 22870 {
lab=word381}
N 250 22860 250 22910 {
lab=GND}
N 250 22910 250 22920 {
lab=GND}
N 310 22860 310 22910 {
lab=Y3}
N 310 22910 310 22920 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 22890 1 0 {name=M1704
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 22920 360 22920 {
lab=GND}
N 360 22910 360 22920 {
lab=GND}
N 320 22870 360 22870 {
lab=word381}
N 360 22870 400 22870 {
lab=word381}
N 330 22860 330 22910 {
lab=GND}
N 330 22910 330 22920 {
lab=GND}
N 390 22860 390 22910 {
lab=Y4}
N 390 22910 390 22920 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 22890 1 0 {name=M1705
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 22870 440 22870 {
lab=word381}
N 440 22870 480 22870 {
lab=word381}
N 410 22860 410 22910 {
lab=GND}
N 410 22910 410 22920 {
lab=GND}
N 470 22860 470 22910 {
lab=Y5}
N 470 22910 470 22920 {
lab=Y5}
N 480 22870 520 22870 {
lab=word381}
N 520 22870 560 22870 {
lab=word381}
N 490 22860 490 22910 {
lab=GND}
N 490 22910 490 22920 {
lab=GND}
N 550 22860 550 22910 {
lab=Y6}
N 550 22910 550 22920 {
lab=Y6}

N 570 22920 600 22920 {
lab=GND}
N 600 22910 600 22920 {
lab=GND}
N 560 22870 600 22870 {
lab=word381}
N 600 22870 640 22870 {
lab=word381}
N 570 22860 570 22910 {
lab=GND}
N 570 22910 570 22920 {
lab=GND}
N 630 22860 630 22910 {
lab=Y7}
N 630 22910 630 22920 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22890 1 0 {name=M1706
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22930 0 0 {name=p405 lab=word382}

N 10 22980 40 22980 {
lab=GND}
N 40 22970 40 22980 {
lab=GND}
N 0 22930 40 22930 {
lab=word382}
N 40 22930 80 22930 {
lab=word382}
N 10 22920 10 22970 {
lab=GND}
N 10 22970 10 22980 {
lab=GND}
N 70 22920 70 22970 {
lab=Y0}
N 70 22970 70 22980 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 22950 1 0 {name=M1707
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 22980 120 22980 {
lab=GND}
N 120 22970 120 22980 {
lab=GND}
N 80 22930 120 22930 {
lab=word382}
N 120 22930 160 22930 {
lab=word382}
N 90 22920 90 22970 {
lab=GND}
N 90 22970 90 22980 {
lab=GND}
N 150 22920 150 22970 {
lab=Y1}
N 150 22970 150 22980 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 22950 1 0 {name=M1708
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 22980 200 22980 {
lab=GND}
N 200 22970 200 22980 {
lab=GND}
N 160 22930 200 22930 {
lab=word382}
N 200 22930 240 22930 {
lab=word382}
N 170 22920 170 22970 {
lab=GND}
N 170 22970 170 22980 {
lab=GND}
N 230 22920 230 22970 {
lab=Y2}
N 230 22970 230 22980 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 22950 1 0 {name=M1709
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 22980 280 22980 {
lab=GND}
N 280 22970 280 22980 {
lab=GND}
N 240 22930 280 22930 {
lab=word382}
N 280 22930 320 22930 {
lab=word382}
N 250 22920 250 22970 {
lab=GND}
N 250 22970 250 22980 {
lab=GND}
N 310 22920 310 22970 {
lab=Y3}
N 310 22970 310 22980 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 22950 1 0 {name=M1710
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 22980 360 22980 {
lab=GND}
N 360 22970 360 22980 {
lab=GND}
N 320 22930 360 22930 {
lab=word382}
N 360 22930 400 22930 {
lab=word382}
N 330 22920 330 22970 {
lab=GND}
N 330 22970 330 22980 {
lab=GND}
N 390 22920 390 22970 {
lab=Y4}
N 390 22970 390 22980 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 22950 1 0 {name=M1711
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 22930 440 22930 {
lab=word382}
N 440 22930 480 22930 {
lab=word382}
N 410 22920 410 22970 {
lab=GND}
N 410 22970 410 22980 {
lab=GND}
N 470 22920 470 22970 {
lab=Y5}
N 470 22970 470 22980 {
lab=Y5}

N 490 22980 520 22980 {
lab=GND}
N 520 22970 520 22980 {
lab=GND}
N 480 22930 520 22930 {
lab=word382}
N 520 22930 560 22930 {
lab=word382}
N 490 22920 490 22970 {
lab=GND}
N 490 22970 490 22980 {
lab=GND}
N 550 22920 550 22970 {
lab=Y6}
N 550 22970 550 22980 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 22950 1 0 {name=M1712
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 22980 600 22980 {
lab=GND}
N 600 22970 600 22980 {
lab=GND}
N 560 22930 600 22930 {
lab=word382}
N 600 22930 640 22930 {
lab=word382}
N 570 22920 570 22970 {
lab=GND}
N 570 22970 570 22980 {
lab=GND}
N 630 22920 630 22970 {
lab=Y7}
N 630 22970 630 22980 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 22950 1 0 {name=M1713
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 22990 0 0 {name=p406 lab=word383}

N 10 23040 40 23040 {
lab=GND}
N 40 23030 40 23040 {
lab=GND}
N 0 22990 40 22990 {
lab=word383}
N 40 22990 80 22990 {
lab=word383}
N 10 22980 10 23030 {
lab=GND}
N 10 23030 10 23040 {
lab=GND}
N 70 22980 70 23030 {
lab=Y0}
N 70 23030 70 23040 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 23010 1 0 {name=M1714
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 23040 120 23040 {
lab=GND}
N 120 23030 120 23040 {
lab=GND}
N 80 22990 120 22990 {
lab=word383}
N 120 22990 160 22990 {
lab=word383}
N 90 22980 90 23030 {
lab=GND}
N 90 23030 90 23040 {
lab=GND}
N 150 22980 150 23030 {
lab=Y1}
N 150 23030 150 23040 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 23010 1 0 {name=M1715
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 23040 200 23040 {
lab=GND}
N 200 23030 200 23040 {
lab=GND}
N 160 22990 200 22990 {
lab=word383}
N 200 22990 240 22990 {
lab=word383}
N 170 22980 170 23030 {
lab=GND}
N 170 23030 170 23040 {
lab=GND}
N 230 22980 230 23030 {
lab=Y2}
N 230 23030 230 23040 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 23010 1 0 {name=M1716
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 23040 280 23040 {
lab=GND}
N 280 23030 280 23040 {
lab=GND}
N 240 22990 280 22990 {
lab=word383}
N 280 22990 320 22990 {
lab=word383}
N 250 22980 250 23030 {
lab=GND}
N 250 23030 250 23040 {
lab=GND}
N 310 22980 310 23030 {
lab=Y3}
N 310 23030 310 23040 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 23010 1 0 {name=M1717
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 23040 360 23040 {
lab=GND}
N 360 23030 360 23040 {
lab=GND}
N 320 22990 360 22990 {
lab=word383}
N 360 22990 400 22990 {
lab=word383}
N 330 22980 330 23030 {
lab=GND}
N 330 23030 330 23040 {
lab=GND}
N 390 22980 390 23030 {
lab=Y4}
N 390 23030 390 23040 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 23010 1 0 {name=M1718
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 23040 440 23040 {
lab=GND}
N 440 23030 440 23040 {
lab=GND}
N 400 22990 440 22990 {
lab=word383}
N 440 22990 480 22990 {
lab=word383}
N 410 22980 410 23030 {
lab=GND}
N 410 23030 410 23040 {
lab=GND}
N 470 22980 470 23030 {
lab=Y5}
N 470 23030 470 23040 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 23010 1 0 {name=M1719
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 22990 520 22990 {
lab=word383}
N 520 22990 560 22990 {
lab=word383}
N 490 22980 490 23030 {
lab=GND}
N 490 23030 490 23040 {
lab=GND}
N 550 22980 550 23030 {
lab=Y6}
N 550 23030 550 23040 {
lab=Y6}

N 570 23040 600 23040 {
lab=GND}
N 600 23030 600 23040 {
lab=GND}
N 560 22990 600 22990 {
lab=word383}
N 600 22990 640 22990 {
lab=word383}
N 570 22980 570 23030 {
lab=GND}
N 570 23030 570 23040 {
lab=GND}
N 630 22980 630 23030 {
lab=Y7}
N 630 23030 630 23040 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 23010 1 0 {name=M1720
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 23050 0 0 {name=p407 lab=word384}
N 0 23050 40 23050 {
lab=word384}
N 40 23050 80 23050 {
lab=word384}
N 10 23040 10 23090 {
lab=GND}
N 10 23090 10 23100 {
lab=GND}
N 70 23040 70 23090 {
lab=Y0}
N 70 23090 70 23100 {
lab=Y0}
N 80 23050 120 23050 {
lab=word384}
N 120 23050 160 23050 {
lab=word384}
N 90 23040 90 23090 {
lab=GND}
N 90 23090 90 23100 {
lab=GND}
N 150 23040 150 23090 {
lab=Y1}
N 150 23090 150 23100 {
lab=Y1}
N 160 23050 200 23050 {
lab=word384}
N 200 23050 240 23050 {
lab=word384}
N 170 23040 170 23090 {
lab=GND}
N 170 23090 170 23100 {
lab=GND}
N 230 23040 230 23090 {
lab=Y2}
N 230 23090 230 23100 {
lab=Y2}
N 240 23050 280 23050 {
lab=word384}
N 280 23050 320 23050 {
lab=word384}
N 250 23040 250 23090 {
lab=GND}
N 250 23090 250 23100 {
lab=GND}
N 310 23040 310 23090 {
lab=Y3}
N 310 23090 310 23100 {
lab=Y3}
N 320 23050 360 23050 {
lab=word384}
N 360 23050 400 23050 {
lab=word384}
N 330 23040 330 23090 {
lab=GND}
N 330 23090 330 23100 {
lab=GND}
N 390 23040 390 23090 {
lab=Y4}
N 390 23090 390 23100 {
lab=Y4}
N 400 23050 440 23050 {
lab=word384}
N 440 23050 480 23050 {
lab=word384}
N 410 23040 410 23090 {
lab=GND}
N 410 23090 410 23100 {
lab=GND}
N 470 23040 470 23090 {
lab=Y5}
N 470 23090 470 23100 {
lab=Y5}
N 480 23050 520 23050 {
lab=word384}
N 520 23050 560 23050 {
lab=word384}
N 490 23040 490 23090 {
lab=GND}
N 490 23090 490 23100 {
lab=GND}
N 550 23040 550 23090 {
lab=Y6}
N 550 23090 550 23100 {
lab=Y6}
N 560 23050 600 23050 {
lab=word384}
N 600 23050 640 23050 {
lab=word384}
N 570 23040 570 23090 {
lab=GND}
N 570 23090 570 23100 {
lab=GND}
N 630 23040 630 23090 {
lab=Y7}
N 630 23090 630 23100 {
lab=Y7}
C {devices/ipin.sym} 0 23110 0 0 {name=p408 lab=word385}
N 0 23110 40 23110 {
lab=word385}
N 40 23110 80 23110 {
lab=word385}
N 10 23100 10 23150 {
lab=GND}
N 10 23150 10 23160 {
lab=GND}
N 70 23100 70 23150 {
lab=Y0}
N 70 23150 70 23160 {
lab=Y0}
N 80 23110 120 23110 {
lab=word385}
N 120 23110 160 23110 {
lab=word385}
N 90 23100 90 23150 {
lab=GND}
N 90 23150 90 23160 {
lab=GND}
N 150 23100 150 23150 {
lab=Y1}
N 150 23150 150 23160 {
lab=Y1}
N 160 23110 200 23110 {
lab=word385}
N 200 23110 240 23110 {
lab=word385}
N 170 23100 170 23150 {
lab=GND}
N 170 23150 170 23160 {
lab=GND}
N 230 23100 230 23150 {
lab=Y2}
N 230 23150 230 23160 {
lab=Y2}
N 240 23110 280 23110 {
lab=word385}
N 280 23110 320 23110 {
lab=word385}
N 250 23100 250 23150 {
lab=GND}
N 250 23150 250 23160 {
lab=GND}
N 310 23100 310 23150 {
lab=Y3}
N 310 23150 310 23160 {
lab=Y3}
N 320 23110 360 23110 {
lab=word385}
N 360 23110 400 23110 {
lab=word385}
N 330 23100 330 23150 {
lab=GND}
N 330 23150 330 23160 {
lab=GND}
N 390 23100 390 23150 {
lab=Y4}
N 390 23150 390 23160 {
lab=Y4}
N 400 23110 440 23110 {
lab=word385}
N 440 23110 480 23110 {
lab=word385}
N 410 23100 410 23150 {
lab=GND}
N 410 23150 410 23160 {
lab=GND}
N 470 23100 470 23150 {
lab=Y5}
N 470 23150 470 23160 {
lab=Y5}
N 480 23110 520 23110 {
lab=word385}
N 520 23110 560 23110 {
lab=word385}
N 490 23100 490 23150 {
lab=GND}
N 490 23150 490 23160 {
lab=GND}
N 550 23100 550 23150 {
lab=Y6}
N 550 23150 550 23160 {
lab=Y6}
N 560 23110 600 23110 {
lab=word385}
N 600 23110 640 23110 {
lab=word385}
N 570 23100 570 23150 {
lab=GND}
N 570 23150 570 23160 {
lab=GND}
N 630 23100 630 23150 {
lab=Y7}
N 630 23150 630 23160 {
lab=Y7}
C {devices/ipin.sym} 0 23170 0 0 {name=p409 lab=word386}
N 0 23170 40 23170 {
lab=word386}
N 40 23170 80 23170 {
lab=word386}
N 10 23160 10 23210 {
lab=GND}
N 10 23210 10 23220 {
lab=GND}
N 70 23160 70 23210 {
lab=Y0}
N 70 23210 70 23220 {
lab=Y0}
N 80 23170 120 23170 {
lab=word386}
N 120 23170 160 23170 {
lab=word386}
N 90 23160 90 23210 {
lab=GND}
N 90 23210 90 23220 {
lab=GND}
N 150 23160 150 23210 {
lab=Y1}
N 150 23210 150 23220 {
lab=Y1}
N 160 23170 200 23170 {
lab=word386}
N 200 23170 240 23170 {
lab=word386}
N 170 23160 170 23210 {
lab=GND}
N 170 23210 170 23220 {
lab=GND}
N 230 23160 230 23210 {
lab=Y2}
N 230 23210 230 23220 {
lab=Y2}
N 240 23170 280 23170 {
lab=word386}
N 280 23170 320 23170 {
lab=word386}
N 250 23160 250 23210 {
lab=GND}
N 250 23210 250 23220 {
lab=GND}
N 310 23160 310 23210 {
lab=Y3}
N 310 23210 310 23220 {
lab=Y3}
N 320 23170 360 23170 {
lab=word386}
N 360 23170 400 23170 {
lab=word386}
N 330 23160 330 23210 {
lab=GND}
N 330 23210 330 23220 {
lab=GND}
N 390 23160 390 23210 {
lab=Y4}
N 390 23210 390 23220 {
lab=Y4}
N 400 23170 440 23170 {
lab=word386}
N 440 23170 480 23170 {
lab=word386}
N 410 23160 410 23210 {
lab=GND}
N 410 23210 410 23220 {
lab=GND}
N 470 23160 470 23210 {
lab=Y5}
N 470 23210 470 23220 {
lab=Y5}
N 480 23170 520 23170 {
lab=word386}
N 520 23170 560 23170 {
lab=word386}
N 490 23160 490 23210 {
lab=GND}
N 490 23210 490 23220 {
lab=GND}
N 550 23160 550 23210 {
lab=Y6}
N 550 23210 550 23220 {
lab=Y6}

N 570 23220 600 23220 {
lab=GND}
N 600 23210 600 23220 {
lab=GND}
N 560 23170 600 23170 {
lab=word386}
N 600 23170 640 23170 {
lab=word386}
N 570 23160 570 23210 {
lab=GND}
N 570 23210 570 23220 {
lab=GND}
N 630 23160 630 23210 {
lab=Y7}
N 630 23210 630 23220 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 23190 1 0 {name=M1721
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 23230 0 0 {name=p410 lab=word387}
N 0 23230 40 23230 {
lab=word387}
N 40 23230 80 23230 {
lab=word387}
N 10 23220 10 23270 {
lab=GND}
N 10 23270 10 23280 {
lab=GND}
N 70 23220 70 23270 {
lab=Y0}
N 70 23270 70 23280 {
lab=Y0}
N 80 23230 120 23230 {
lab=word387}
N 120 23230 160 23230 {
lab=word387}
N 90 23220 90 23270 {
lab=GND}
N 90 23270 90 23280 {
lab=GND}
N 150 23220 150 23270 {
lab=Y1}
N 150 23270 150 23280 {
lab=Y1}
N 160 23230 200 23230 {
lab=word387}
N 200 23230 240 23230 {
lab=word387}
N 170 23220 170 23270 {
lab=GND}
N 170 23270 170 23280 {
lab=GND}
N 230 23220 230 23270 {
lab=Y2}
N 230 23270 230 23280 {
lab=Y2}
N 240 23230 280 23230 {
lab=word387}
N 280 23230 320 23230 {
lab=word387}
N 250 23220 250 23270 {
lab=GND}
N 250 23270 250 23280 {
lab=GND}
N 310 23220 310 23270 {
lab=Y3}
N 310 23270 310 23280 {
lab=Y3}
N 320 23230 360 23230 {
lab=word387}
N 360 23230 400 23230 {
lab=word387}
N 330 23220 330 23270 {
lab=GND}
N 330 23270 330 23280 {
lab=GND}
N 390 23220 390 23270 {
lab=Y4}
N 390 23270 390 23280 {
lab=Y4}
N 400 23230 440 23230 {
lab=word387}
N 440 23230 480 23230 {
lab=word387}
N 410 23220 410 23270 {
lab=GND}
N 410 23270 410 23280 {
lab=GND}
N 470 23220 470 23270 {
lab=Y5}
N 470 23270 470 23280 {
lab=Y5}
N 480 23230 520 23230 {
lab=word387}
N 520 23230 560 23230 {
lab=word387}
N 490 23220 490 23270 {
lab=GND}
N 490 23270 490 23280 {
lab=GND}
N 550 23220 550 23270 {
lab=Y6}
N 550 23270 550 23280 {
lab=Y6}

N 570 23280 600 23280 {
lab=GND}
N 600 23270 600 23280 {
lab=GND}
N 560 23230 600 23230 {
lab=word387}
N 600 23230 640 23230 {
lab=word387}
N 570 23220 570 23270 {
lab=GND}
N 570 23270 570 23280 {
lab=GND}
N 630 23220 630 23270 {
lab=Y7}
N 630 23270 630 23280 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 23250 1 0 {name=M1722
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 23290 0 0 {name=p411 lab=word388}
N 0 23290 40 23290 {
lab=word388}
N 40 23290 80 23290 {
lab=word388}
N 10 23280 10 23330 {
lab=GND}
N 10 23330 10 23340 {
lab=GND}
N 70 23280 70 23330 {
lab=Y0}
N 70 23330 70 23340 {
lab=Y0}
N 80 23290 120 23290 {
lab=word388}
N 120 23290 160 23290 {
lab=word388}
N 90 23280 90 23330 {
lab=GND}
N 90 23330 90 23340 {
lab=GND}
N 150 23280 150 23330 {
lab=Y1}
N 150 23330 150 23340 {
lab=Y1}
N 160 23290 200 23290 {
lab=word388}
N 200 23290 240 23290 {
lab=word388}
N 170 23280 170 23330 {
lab=GND}
N 170 23330 170 23340 {
lab=GND}
N 230 23280 230 23330 {
lab=Y2}
N 230 23330 230 23340 {
lab=Y2}
N 240 23290 280 23290 {
lab=word388}
N 280 23290 320 23290 {
lab=word388}
N 250 23280 250 23330 {
lab=GND}
N 250 23330 250 23340 {
lab=GND}
N 310 23280 310 23330 {
lab=Y3}
N 310 23330 310 23340 {
lab=Y3}
N 320 23290 360 23290 {
lab=word388}
N 360 23290 400 23290 {
lab=word388}
N 330 23280 330 23330 {
lab=GND}
N 330 23330 330 23340 {
lab=GND}
N 390 23280 390 23330 {
lab=Y4}
N 390 23330 390 23340 {
lab=Y4}
N 400 23290 440 23290 {
lab=word388}
N 440 23290 480 23290 {
lab=word388}
N 410 23280 410 23330 {
lab=GND}
N 410 23330 410 23340 {
lab=GND}
N 470 23280 470 23330 {
lab=Y5}
N 470 23330 470 23340 {
lab=Y5}

N 490 23340 520 23340 {
lab=GND}
N 520 23330 520 23340 {
lab=GND}
N 480 23290 520 23290 {
lab=word388}
N 520 23290 560 23290 {
lab=word388}
N 490 23280 490 23330 {
lab=GND}
N 490 23330 490 23340 {
lab=GND}
N 550 23280 550 23330 {
lab=Y6}
N 550 23330 550 23340 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 23310 1 0 {name=M1723
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 23290 600 23290 {
lab=word388}
N 600 23290 640 23290 {
lab=word388}
N 570 23280 570 23330 {
lab=GND}
N 570 23330 570 23340 {
lab=GND}
N 630 23280 630 23330 {
lab=Y7}
N 630 23330 630 23340 {
lab=Y7}
C {devices/ipin.sym} 0 23350 0 0 {name=p412 lab=word389}
N 0 23350 40 23350 {
lab=word389}
N 40 23350 80 23350 {
lab=word389}
N 10 23340 10 23390 {
lab=GND}
N 10 23390 10 23400 {
lab=GND}
N 70 23340 70 23390 {
lab=Y0}
N 70 23390 70 23400 {
lab=Y0}
N 80 23350 120 23350 {
lab=word389}
N 120 23350 160 23350 {
lab=word389}
N 90 23340 90 23390 {
lab=GND}
N 90 23390 90 23400 {
lab=GND}
N 150 23340 150 23390 {
lab=Y1}
N 150 23390 150 23400 {
lab=Y1}
N 160 23350 200 23350 {
lab=word389}
N 200 23350 240 23350 {
lab=word389}
N 170 23340 170 23390 {
lab=GND}
N 170 23390 170 23400 {
lab=GND}
N 230 23340 230 23390 {
lab=Y2}
N 230 23390 230 23400 {
lab=Y2}
N 240 23350 280 23350 {
lab=word389}
N 280 23350 320 23350 {
lab=word389}
N 250 23340 250 23390 {
lab=GND}
N 250 23390 250 23400 {
lab=GND}
N 310 23340 310 23390 {
lab=Y3}
N 310 23390 310 23400 {
lab=Y3}
N 320 23350 360 23350 {
lab=word389}
N 360 23350 400 23350 {
lab=word389}
N 330 23340 330 23390 {
lab=GND}
N 330 23390 330 23400 {
lab=GND}
N 390 23340 390 23390 {
lab=Y4}
N 390 23390 390 23400 {
lab=Y4}

N 410 23400 440 23400 {
lab=GND}
N 440 23390 440 23400 {
lab=GND}
N 400 23350 440 23350 {
lab=word389}
N 440 23350 480 23350 {
lab=word389}
N 410 23340 410 23390 {
lab=GND}
N 410 23390 410 23400 {
lab=GND}
N 470 23340 470 23390 {
lab=Y5}
N 470 23390 470 23400 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 23370 1 0 {name=M1724
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 23350 520 23350 {
lab=word389}
N 520 23350 560 23350 {
lab=word389}
N 490 23340 490 23390 {
lab=GND}
N 490 23390 490 23400 {
lab=GND}
N 550 23340 550 23390 {
lab=Y6}
N 550 23390 550 23400 {
lab=Y6}
N 560 23350 600 23350 {
lab=word389}
N 600 23350 640 23350 {
lab=word389}
N 570 23340 570 23390 {
lab=GND}
N 570 23390 570 23400 {
lab=GND}
N 630 23340 630 23390 {
lab=Y7}
N 630 23390 630 23400 {
lab=Y7}
C {devices/ipin.sym} 0 23410 0 0 {name=p413 lab=word390}
N 0 23410 40 23410 {
lab=word390}
N 40 23410 80 23410 {
lab=word390}
N 10 23400 10 23450 {
lab=GND}
N 10 23450 10 23460 {
lab=GND}
N 70 23400 70 23450 {
lab=Y0}
N 70 23450 70 23460 {
lab=Y0}
N 80 23410 120 23410 {
lab=word390}
N 120 23410 160 23410 {
lab=word390}
N 90 23400 90 23450 {
lab=GND}
N 90 23450 90 23460 {
lab=GND}
N 150 23400 150 23450 {
lab=Y1}
N 150 23450 150 23460 {
lab=Y1}
N 160 23410 200 23410 {
lab=word390}
N 200 23410 240 23410 {
lab=word390}
N 170 23400 170 23450 {
lab=GND}
N 170 23450 170 23460 {
lab=GND}
N 230 23400 230 23450 {
lab=Y2}
N 230 23450 230 23460 {
lab=Y2}
N 240 23410 280 23410 {
lab=word390}
N 280 23410 320 23410 {
lab=word390}
N 250 23400 250 23450 {
lab=GND}
N 250 23450 250 23460 {
lab=GND}
N 310 23400 310 23450 {
lab=Y3}
N 310 23450 310 23460 {
lab=Y3}
N 320 23410 360 23410 {
lab=word390}
N 360 23410 400 23410 {
lab=word390}
N 330 23400 330 23450 {
lab=GND}
N 330 23450 330 23460 {
lab=GND}
N 390 23400 390 23450 {
lab=Y4}
N 390 23450 390 23460 {
lab=Y4}

N 410 23460 440 23460 {
lab=GND}
N 440 23450 440 23460 {
lab=GND}
N 400 23410 440 23410 {
lab=word390}
N 440 23410 480 23410 {
lab=word390}
N 410 23400 410 23450 {
lab=GND}
N 410 23450 410 23460 {
lab=GND}
N 470 23400 470 23450 {
lab=Y5}
N 470 23450 470 23460 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 23430 1 0 {name=M1725
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 23410 520 23410 {
lab=word390}
N 520 23410 560 23410 {
lab=word390}
N 490 23400 490 23450 {
lab=GND}
N 490 23450 490 23460 {
lab=GND}
N 550 23400 550 23450 {
lab=Y6}
N 550 23450 550 23460 {
lab=Y6}

N 570 23460 600 23460 {
lab=GND}
N 600 23450 600 23460 {
lab=GND}
N 560 23410 600 23410 {
lab=word390}
N 600 23410 640 23410 {
lab=word390}
N 570 23400 570 23450 {
lab=GND}
N 570 23450 570 23460 {
lab=GND}
N 630 23400 630 23450 {
lab=Y7}
N 630 23450 630 23460 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 23430 1 0 {name=M1726
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 23470 0 0 {name=p414 lab=word391}
N 0 23470 40 23470 {
lab=word391}
N 40 23470 80 23470 {
lab=word391}
N 10 23460 10 23510 {
lab=GND}
N 10 23510 10 23520 {
lab=GND}
N 70 23460 70 23510 {
lab=Y0}
N 70 23510 70 23520 {
lab=Y0}
N 80 23470 120 23470 {
lab=word391}
N 120 23470 160 23470 {
lab=word391}
N 90 23460 90 23510 {
lab=GND}
N 90 23510 90 23520 {
lab=GND}
N 150 23460 150 23510 {
lab=Y1}
N 150 23510 150 23520 {
lab=Y1}
N 160 23470 200 23470 {
lab=word391}
N 200 23470 240 23470 {
lab=word391}
N 170 23460 170 23510 {
lab=GND}
N 170 23510 170 23520 {
lab=GND}
N 230 23460 230 23510 {
lab=Y2}
N 230 23510 230 23520 {
lab=Y2}
N 240 23470 280 23470 {
lab=word391}
N 280 23470 320 23470 {
lab=word391}
N 250 23460 250 23510 {
lab=GND}
N 250 23510 250 23520 {
lab=GND}
N 310 23460 310 23510 {
lab=Y3}
N 310 23510 310 23520 {
lab=Y3}
N 320 23470 360 23470 {
lab=word391}
N 360 23470 400 23470 {
lab=word391}
N 330 23460 330 23510 {
lab=GND}
N 330 23510 330 23520 {
lab=GND}
N 390 23460 390 23510 {
lab=Y4}
N 390 23510 390 23520 {
lab=Y4}

N 410 23520 440 23520 {
lab=GND}
N 440 23510 440 23520 {
lab=GND}
N 400 23470 440 23470 {
lab=word391}
N 440 23470 480 23470 {
lab=word391}
N 410 23460 410 23510 {
lab=GND}
N 410 23510 410 23520 {
lab=GND}
N 470 23460 470 23510 {
lab=Y5}
N 470 23510 470 23520 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 23490 1 0 {name=M1727
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 23520 520 23520 {
lab=GND}
N 520 23510 520 23520 {
lab=GND}
N 480 23470 520 23470 {
lab=word391}
N 520 23470 560 23470 {
lab=word391}
N 490 23460 490 23510 {
lab=GND}
N 490 23510 490 23520 {
lab=GND}
N 550 23460 550 23510 {
lab=Y6}
N 550 23510 550 23520 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 23490 1 0 {name=M1728
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 23520 600 23520 {
lab=GND}
N 600 23510 600 23520 {
lab=GND}
N 560 23470 600 23470 {
lab=word391}
N 600 23470 640 23470 {
lab=word391}
N 570 23460 570 23510 {
lab=GND}
N 570 23510 570 23520 {
lab=GND}
N 630 23460 630 23510 {
lab=Y7}
N 630 23510 630 23520 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 23490 1 0 {name=M1729
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 23530 0 0 {name=p415 lab=word392}
N 0 23530 40 23530 {
lab=word392}
N 40 23530 80 23530 {
lab=word392}
N 10 23520 10 23570 {
lab=GND}
N 10 23570 10 23580 {
lab=GND}
N 70 23520 70 23570 {
lab=Y0}
N 70 23570 70 23580 {
lab=Y0}
N 80 23530 120 23530 {
lab=word392}
N 120 23530 160 23530 {
lab=word392}
N 90 23520 90 23570 {
lab=GND}
N 90 23570 90 23580 {
lab=GND}
N 150 23520 150 23570 {
lab=Y1}
N 150 23570 150 23580 {
lab=Y1}
N 160 23530 200 23530 {
lab=word392}
N 200 23530 240 23530 {
lab=word392}
N 170 23520 170 23570 {
lab=GND}
N 170 23570 170 23580 {
lab=GND}
N 230 23520 230 23570 {
lab=Y2}
N 230 23570 230 23580 {
lab=Y2}
N 240 23530 280 23530 {
lab=word392}
N 280 23530 320 23530 {
lab=word392}
N 250 23520 250 23570 {
lab=GND}
N 250 23570 250 23580 {
lab=GND}
N 310 23520 310 23570 {
lab=Y3}
N 310 23570 310 23580 {
lab=Y3}

N 330 23580 360 23580 {
lab=GND}
N 360 23570 360 23580 {
lab=GND}
N 320 23530 360 23530 {
lab=word392}
N 360 23530 400 23530 {
lab=word392}
N 330 23520 330 23570 {
lab=GND}
N 330 23570 330 23580 {
lab=GND}
N 390 23520 390 23570 {
lab=Y4}
N 390 23570 390 23580 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 23550 1 0 {name=M1730
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 23530 440 23530 {
lab=word392}
N 440 23530 480 23530 {
lab=word392}
N 410 23520 410 23570 {
lab=GND}
N 410 23570 410 23580 {
lab=GND}
N 470 23520 470 23570 {
lab=Y5}
N 470 23570 470 23580 {
lab=Y5}

N 490 23580 520 23580 {
lab=GND}
N 520 23570 520 23580 {
lab=GND}
N 480 23530 520 23530 {
lab=word392}
N 520 23530 560 23530 {
lab=word392}
N 490 23520 490 23570 {
lab=GND}
N 490 23570 490 23580 {
lab=GND}
N 550 23520 550 23570 {
lab=Y6}
N 550 23570 550 23580 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 23550 1 0 {name=M1731
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 23530 600 23530 {
lab=word392}
N 600 23530 640 23530 {
lab=word392}
N 570 23520 570 23570 {
lab=GND}
N 570 23570 570 23580 {
lab=GND}
N 630 23520 630 23570 {
lab=Y7}
N 630 23570 630 23580 {
lab=Y7}
C {devices/ipin.sym} 0 23590 0 0 {name=p416 lab=word393}
N 0 23590 40 23590 {
lab=word393}
N 40 23590 80 23590 {
lab=word393}
N 10 23580 10 23630 {
lab=GND}
N 10 23630 10 23640 {
lab=GND}
N 70 23580 70 23630 {
lab=Y0}
N 70 23630 70 23640 {
lab=Y0}
N 80 23590 120 23590 {
lab=word393}
N 120 23590 160 23590 {
lab=word393}
N 90 23580 90 23630 {
lab=GND}
N 90 23630 90 23640 {
lab=GND}
N 150 23580 150 23630 {
lab=Y1}
N 150 23630 150 23640 {
lab=Y1}
N 160 23590 200 23590 {
lab=word393}
N 200 23590 240 23590 {
lab=word393}
N 170 23580 170 23630 {
lab=GND}
N 170 23630 170 23640 {
lab=GND}
N 230 23580 230 23630 {
lab=Y2}
N 230 23630 230 23640 {
lab=Y2}
N 240 23590 280 23590 {
lab=word393}
N 280 23590 320 23590 {
lab=word393}
N 250 23580 250 23630 {
lab=GND}
N 250 23630 250 23640 {
lab=GND}
N 310 23580 310 23630 {
lab=Y3}
N 310 23630 310 23640 {
lab=Y3}

N 330 23640 360 23640 {
lab=GND}
N 360 23630 360 23640 {
lab=GND}
N 320 23590 360 23590 {
lab=word393}
N 360 23590 400 23590 {
lab=word393}
N 330 23580 330 23630 {
lab=GND}
N 330 23630 330 23640 {
lab=GND}
N 390 23580 390 23630 {
lab=Y4}
N 390 23630 390 23640 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 23610 1 0 {name=M1732
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 23640 440 23640 {
lab=GND}
N 440 23630 440 23640 {
lab=GND}
N 400 23590 440 23590 {
lab=word393}
N 440 23590 480 23590 {
lab=word393}
N 410 23580 410 23630 {
lab=GND}
N 410 23630 410 23640 {
lab=GND}
N 470 23580 470 23630 {
lab=Y5}
N 470 23630 470 23640 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 23610 1 0 {name=M1733
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 23590 520 23590 {
lab=word393}
N 520 23590 560 23590 {
lab=word393}
N 490 23580 490 23630 {
lab=GND}
N 490 23630 490 23640 {
lab=GND}
N 550 23580 550 23630 {
lab=Y6}
N 550 23630 550 23640 {
lab=Y6}
N 560 23590 600 23590 {
lab=word393}
N 600 23590 640 23590 {
lab=word393}
N 570 23580 570 23630 {
lab=GND}
N 570 23630 570 23640 {
lab=GND}
N 630 23580 630 23630 {
lab=Y7}
N 630 23630 630 23640 {
lab=Y7}
C {devices/ipin.sym} 0 23650 0 0 {name=p417 lab=word394}
N 0 23650 40 23650 {
lab=word394}
N 40 23650 80 23650 {
lab=word394}
N 10 23640 10 23690 {
lab=GND}
N 10 23690 10 23700 {
lab=GND}
N 70 23640 70 23690 {
lab=Y0}
N 70 23690 70 23700 {
lab=Y0}
N 80 23650 120 23650 {
lab=word394}
N 120 23650 160 23650 {
lab=word394}
N 90 23640 90 23690 {
lab=GND}
N 90 23690 90 23700 {
lab=GND}
N 150 23640 150 23690 {
lab=Y1}
N 150 23690 150 23700 {
lab=Y1}
N 160 23650 200 23650 {
lab=word394}
N 200 23650 240 23650 {
lab=word394}
N 170 23640 170 23690 {
lab=GND}
N 170 23690 170 23700 {
lab=GND}
N 230 23640 230 23690 {
lab=Y2}
N 230 23690 230 23700 {
lab=Y2}
N 240 23650 280 23650 {
lab=word394}
N 280 23650 320 23650 {
lab=word394}
N 250 23640 250 23690 {
lab=GND}
N 250 23690 250 23700 {
lab=GND}
N 310 23640 310 23690 {
lab=Y3}
N 310 23690 310 23700 {
lab=Y3}

N 330 23700 360 23700 {
lab=GND}
N 360 23690 360 23700 {
lab=GND}
N 320 23650 360 23650 {
lab=word394}
N 360 23650 400 23650 {
lab=word394}
N 330 23640 330 23690 {
lab=GND}
N 330 23690 330 23700 {
lab=GND}
N 390 23640 390 23690 {
lab=Y4}
N 390 23690 390 23700 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 23670 1 0 {name=M1734
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 23700 440 23700 {
lab=GND}
N 440 23690 440 23700 {
lab=GND}
N 400 23650 440 23650 {
lab=word394}
N 440 23650 480 23650 {
lab=word394}
N 410 23640 410 23690 {
lab=GND}
N 410 23690 410 23700 {
lab=GND}
N 470 23640 470 23690 {
lab=Y5}
N 470 23690 470 23700 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 23670 1 0 {name=M1735
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 23700 520 23700 {
lab=GND}
N 520 23690 520 23700 {
lab=GND}
N 480 23650 520 23650 {
lab=word394}
N 520 23650 560 23650 {
lab=word394}
N 490 23640 490 23690 {
lab=GND}
N 490 23690 490 23700 {
lab=GND}
N 550 23640 550 23690 {
lab=Y6}
N 550 23690 550 23700 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 23670 1 0 {name=M1736
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 23700 600 23700 {
lab=GND}
N 600 23690 600 23700 {
lab=GND}
N 560 23650 600 23650 {
lab=word394}
N 600 23650 640 23650 {
lab=word394}
N 570 23640 570 23690 {
lab=GND}
N 570 23690 570 23700 {
lab=GND}
N 630 23640 630 23690 {
lab=Y7}
N 630 23690 630 23700 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 23670 1 0 {name=M1737
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 23710 0 0 {name=p418 lab=word395}
N 0 23710 40 23710 {
lab=word395}
N 40 23710 80 23710 {
lab=word395}
N 10 23700 10 23750 {
lab=GND}
N 10 23750 10 23760 {
lab=GND}
N 70 23700 70 23750 {
lab=Y0}
N 70 23750 70 23760 {
lab=Y0}
N 80 23710 120 23710 {
lab=word395}
N 120 23710 160 23710 {
lab=word395}
N 90 23700 90 23750 {
lab=GND}
N 90 23750 90 23760 {
lab=GND}
N 150 23700 150 23750 {
lab=Y1}
N 150 23750 150 23760 {
lab=Y1}
N 160 23710 200 23710 {
lab=word395}
N 200 23710 240 23710 {
lab=word395}
N 170 23700 170 23750 {
lab=GND}
N 170 23750 170 23760 {
lab=GND}
N 230 23700 230 23750 {
lab=Y2}
N 230 23750 230 23760 {
lab=Y2}

N 250 23760 280 23760 {
lab=GND}
N 280 23750 280 23760 {
lab=GND}
N 240 23710 280 23710 {
lab=word395}
N 280 23710 320 23710 {
lab=word395}
N 250 23700 250 23750 {
lab=GND}
N 250 23750 250 23760 {
lab=GND}
N 310 23700 310 23750 {
lab=Y3}
N 310 23750 310 23760 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 23730 1 0 {name=M1738
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 23710 360 23710 {
lab=word395}
N 360 23710 400 23710 {
lab=word395}
N 330 23700 330 23750 {
lab=GND}
N 330 23750 330 23760 {
lab=GND}
N 390 23700 390 23750 {
lab=Y4}
N 390 23750 390 23760 {
lab=Y4}
N 400 23710 440 23710 {
lab=word395}
N 440 23710 480 23710 {
lab=word395}
N 410 23700 410 23750 {
lab=GND}
N 410 23750 410 23760 {
lab=GND}
N 470 23700 470 23750 {
lab=Y5}
N 470 23750 470 23760 {
lab=Y5}

N 490 23760 520 23760 {
lab=GND}
N 520 23750 520 23760 {
lab=GND}
N 480 23710 520 23710 {
lab=word395}
N 520 23710 560 23710 {
lab=word395}
N 490 23700 490 23750 {
lab=GND}
N 490 23750 490 23760 {
lab=GND}
N 550 23700 550 23750 {
lab=Y6}
N 550 23750 550 23760 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 23730 1 0 {name=M1739
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 23710 600 23710 {
lab=word395}
N 600 23710 640 23710 {
lab=word395}
N 570 23700 570 23750 {
lab=GND}
N 570 23750 570 23760 {
lab=GND}
N 630 23700 630 23750 {
lab=Y7}
N 630 23750 630 23760 {
lab=Y7}
C {devices/ipin.sym} 0 23770 0 0 {name=p419 lab=word396}
N 0 23770 40 23770 {
lab=word396}
N 40 23770 80 23770 {
lab=word396}
N 10 23760 10 23810 {
lab=GND}
N 10 23810 10 23820 {
lab=GND}
N 70 23760 70 23810 {
lab=Y0}
N 70 23810 70 23820 {
lab=Y0}
N 80 23770 120 23770 {
lab=word396}
N 120 23770 160 23770 {
lab=word396}
N 90 23760 90 23810 {
lab=GND}
N 90 23810 90 23820 {
lab=GND}
N 150 23760 150 23810 {
lab=Y1}
N 150 23810 150 23820 {
lab=Y1}
N 160 23770 200 23770 {
lab=word396}
N 200 23770 240 23770 {
lab=word396}
N 170 23760 170 23810 {
lab=GND}
N 170 23810 170 23820 {
lab=GND}
N 230 23760 230 23810 {
lab=Y2}
N 230 23810 230 23820 {
lab=Y2}

N 250 23820 280 23820 {
lab=GND}
N 280 23810 280 23820 {
lab=GND}
N 240 23770 280 23770 {
lab=word396}
N 280 23770 320 23770 {
lab=word396}
N 250 23760 250 23810 {
lab=GND}
N 250 23810 250 23820 {
lab=GND}
N 310 23760 310 23810 {
lab=Y3}
N 310 23810 310 23820 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 23790 1 0 {name=M1740
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 23770 360 23770 {
lab=word396}
N 360 23770 400 23770 {
lab=word396}
N 330 23760 330 23810 {
lab=GND}
N 330 23810 330 23820 {
lab=GND}
N 390 23760 390 23810 {
lab=Y4}
N 390 23810 390 23820 {
lab=Y4}

N 410 23820 440 23820 {
lab=GND}
N 440 23810 440 23820 {
lab=GND}
N 400 23770 440 23770 {
lab=word396}
N 440 23770 480 23770 {
lab=word396}
N 410 23760 410 23810 {
lab=GND}
N 410 23810 410 23820 {
lab=GND}
N 470 23760 470 23810 {
lab=Y5}
N 470 23810 470 23820 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 23790 1 0 {name=M1741
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 23770 520 23770 {
lab=word396}
N 520 23770 560 23770 {
lab=word396}
N 490 23760 490 23810 {
lab=GND}
N 490 23810 490 23820 {
lab=GND}
N 550 23760 550 23810 {
lab=Y6}
N 550 23810 550 23820 {
lab=Y6}

N 570 23820 600 23820 {
lab=GND}
N 600 23810 600 23820 {
lab=GND}
N 560 23770 600 23770 {
lab=word396}
N 600 23770 640 23770 {
lab=word396}
N 570 23760 570 23810 {
lab=GND}
N 570 23810 570 23820 {
lab=GND}
N 630 23760 630 23810 {
lab=Y7}
N 630 23810 630 23820 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 23790 1 0 {name=M1742
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 23830 0 0 {name=p420 lab=word397}
N 0 23830 40 23830 {
lab=word397}
N 40 23830 80 23830 {
lab=word397}
N 10 23820 10 23870 {
lab=GND}
N 10 23870 10 23880 {
lab=GND}
N 70 23820 70 23870 {
lab=Y0}
N 70 23870 70 23880 {
lab=Y0}
N 80 23830 120 23830 {
lab=word397}
N 120 23830 160 23830 {
lab=word397}
N 90 23820 90 23870 {
lab=GND}
N 90 23870 90 23880 {
lab=GND}
N 150 23820 150 23870 {
lab=Y1}
N 150 23870 150 23880 {
lab=Y1}
N 160 23830 200 23830 {
lab=word397}
N 200 23830 240 23830 {
lab=word397}
N 170 23820 170 23870 {
lab=GND}
N 170 23870 170 23880 {
lab=GND}
N 230 23820 230 23870 {
lab=Y2}
N 230 23870 230 23880 {
lab=Y2}

N 250 23880 280 23880 {
lab=GND}
N 280 23870 280 23880 {
lab=GND}
N 240 23830 280 23830 {
lab=word397}
N 280 23830 320 23830 {
lab=word397}
N 250 23820 250 23870 {
lab=GND}
N 250 23870 250 23880 {
lab=GND}
N 310 23820 310 23870 {
lab=Y3}
N 310 23870 310 23880 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 23850 1 0 {name=M1743
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 23880 360 23880 {
lab=GND}
N 360 23870 360 23880 {
lab=GND}
N 320 23830 360 23830 {
lab=word397}
N 360 23830 400 23830 {
lab=word397}
N 330 23820 330 23870 {
lab=GND}
N 330 23870 330 23880 {
lab=GND}
N 390 23820 390 23870 {
lab=Y4}
N 390 23870 390 23880 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 23850 1 0 {name=M1744
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 23830 440 23830 {
lab=word397}
N 440 23830 480 23830 {
lab=word397}
N 410 23820 410 23870 {
lab=GND}
N 410 23870 410 23880 {
lab=GND}
N 470 23820 470 23870 {
lab=Y5}
N 470 23870 470 23880 {
lab=Y5}
N 480 23830 520 23830 {
lab=word397}
N 520 23830 560 23830 {
lab=word397}
N 490 23820 490 23870 {
lab=GND}
N 490 23870 490 23880 {
lab=GND}
N 550 23820 550 23870 {
lab=Y6}
N 550 23870 550 23880 {
lab=Y6}

N 570 23880 600 23880 {
lab=GND}
N 600 23870 600 23880 {
lab=GND}
N 560 23830 600 23830 {
lab=word397}
N 600 23830 640 23830 {
lab=word397}
N 570 23820 570 23870 {
lab=GND}
N 570 23870 570 23880 {
lab=GND}
N 630 23820 630 23870 {
lab=Y7}
N 630 23870 630 23880 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 23850 1 0 {name=M1745
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 23890 0 0 {name=p421 lab=word398}
N 0 23890 40 23890 {
lab=word398}
N 40 23890 80 23890 {
lab=word398}
N 10 23880 10 23930 {
lab=GND}
N 10 23930 10 23940 {
lab=GND}
N 70 23880 70 23930 {
lab=Y0}
N 70 23930 70 23940 {
lab=Y0}
N 80 23890 120 23890 {
lab=word398}
N 120 23890 160 23890 {
lab=word398}
N 90 23880 90 23930 {
lab=GND}
N 90 23930 90 23940 {
lab=GND}
N 150 23880 150 23930 {
lab=Y1}
N 150 23930 150 23940 {
lab=Y1}
N 160 23890 200 23890 {
lab=word398}
N 200 23890 240 23890 {
lab=word398}
N 170 23880 170 23930 {
lab=GND}
N 170 23930 170 23940 {
lab=GND}
N 230 23880 230 23930 {
lab=Y2}
N 230 23930 230 23940 {
lab=Y2}

N 250 23940 280 23940 {
lab=GND}
N 280 23930 280 23940 {
lab=GND}
N 240 23890 280 23890 {
lab=word398}
N 280 23890 320 23890 {
lab=word398}
N 250 23880 250 23930 {
lab=GND}
N 250 23930 250 23940 {
lab=GND}
N 310 23880 310 23930 {
lab=Y3}
N 310 23930 310 23940 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 23910 1 0 {name=M1746
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 23940 360 23940 {
lab=GND}
N 360 23930 360 23940 {
lab=GND}
N 320 23890 360 23890 {
lab=word398}
N 360 23890 400 23890 {
lab=word398}
N 330 23880 330 23930 {
lab=GND}
N 330 23930 330 23940 {
lab=GND}
N 390 23880 390 23930 {
lab=Y4}
N 390 23930 390 23940 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 23910 1 0 {name=M1747
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 23940 440 23940 {
lab=GND}
N 440 23930 440 23940 {
lab=GND}
N 400 23890 440 23890 {
lab=word398}
N 440 23890 480 23890 {
lab=word398}
N 410 23880 410 23930 {
lab=GND}
N 410 23930 410 23940 {
lab=GND}
N 470 23880 470 23930 {
lab=Y5}
N 470 23930 470 23940 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 23910 1 0 {name=M1748
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 23890 520 23890 {
lab=word398}
N 520 23890 560 23890 {
lab=word398}
N 490 23880 490 23930 {
lab=GND}
N 490 23930 490 23940 {
lab=GND}
N 550 23880 550 23930 {
lab=Y6}
N 550 23930 550 23940 {
lab=Y6}

N 570 23940 600 23940 {
lab=GND}
N 600 23930 600 23940 {
lab=GND}
N 560 23890 600 23890 {
lab=word398}
N 600 23890 640 23890 {
lab=word398}
N 570 23880 570 23930 {
lab=GND}
N 570 23930 570 23940 {
lab=GND}
N 630 23880 630 23930 {
lab=Y7}
N 630 23930 630 23940 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 23910 1 0 {name=M1749
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 23950 0 0 {name=p422 lab=word399}
N 0 23950 40 23950 {
lab=word399}
N 40 23950 80 23950 {
lab=word399}
N 10 23940 10 23990 {
lab=GND}
N 10 23990 10 24000 {
lab=GND}
N 70 23940 70 23990 {
lab=Y0}
N 70 23990 70 24000 {
lab=Y0}
N 80 23950 120 23950 {
lab=word399}
N 120 23950 160 23950 {
lab=word399}
N 90 23940 90 23990 {
lab=GND}
N 90 23990 90 24000 {
lab=GND}
N 150 23940 150 23990 {
lab=Y1}
N 150 23990 150 24000 {
lab=Y1}

N 170 24000 200 24000 {
lab=GND}
N 200 23990 200 24000 {
lab=GND}
N 160 23950 200 23950 {
lab=word399}
N 200 23950 240 23950 {
lab=word399}
N 170 23940 170 23990 {
lab=GND}
N 170 23990 170 24000 {
lab=GND}
N 230 23940 230 23990 {
lab=Y2}
N 230 23990 230 24000 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 23970 1 0 {name=M1750
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 23950 280 23950 {
lab=word399}
N 280 23950 320 23950 {
lab=word399}
N 250 23940 250 23990 {
lab=GND}
N 250 23990 250 24000 {
lab=GND}
N 310 23940 310 23990 {
lab=Y3}
N 310 23990 310 24000 {
lab=Y3}
N 320 23950 360 23950 {
lab=word399}
N 360 23950 400 23950 {
lab=word399}
N 330 23940 330 23990 {
lab=GND}
N 330 23990 330 24000 {
lab=GND}
N 390 23940 390 23990 {
lab=Y4}
N 390 23990 390 24000 {
lab=Y4}
N 400 23950 440 23950 {
lab=word399}
N 440 23950 480 23950 {
lab=word399}
N 410 23940 410 23990 {
lab=GND}
N 410 23990 410 24000 {
lab=GND}
N 470 23940 470 23990 {
lab=Y5}
N 470 23990 470 24000 {
lab=Y5}
N 480 23950 520 23950 {
lab=word399}
N 520 23950 560 23950 {
lab=word399}
N 490 23940 490 23990 {
lab=GND}
N 490 23990 490 24000 {
lab=GND}
N 550 23940 550 23990 {
lab=Y6}
N 550 23990 550 24000 {
lab=Y6}

N 570 24000 600 24000 {
lab=GND}
N 600 23990 600 24000 {
lab=GND}
N 560 23950 600 23950 {
lab=word399}
N 600 23950 640 23950 {
lab=word399}
N 570 23940 570 23990 {
lab=GND}
N 570 23990 570 24000 {
lab=GND}
N 630 23940 630 23990 {
lab=Y7}
N 630 23990 630 24000 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 23970 1 0 {name=M1751
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24010 0 0 {name=p423 lab=word400}
N 0 24010 40 24010 {
lab=word400}
N 40 24010 80 24010 {
lab=word400}
N 10 24000 10 24050 {
lab=GND}
N 10 24050 10 24060 {
lab=GND}
N 70 24000 70 24050 {
lab=Y0}
N 70 24050 70 24060 {
lab=Y0}
N 80 24010 120 24010 {
lab=word400}
N 120 24010 160 24010 {
lab=word400}
N 90 24000 90 24050 {
lab=GND}
N 90 24050 90 24060 {
lab=GND}
N 150 24000 150 24050 {
lab=Y1}
N 150 24050 150 24060 {
lab=Y1}

N 170 24060 200 24060 {
lab=GND}
N 200 24050 200 24060 {
lab=GND}
N 160 24010 200 24010 {
lab=word400}
N 200 24010 240 24010 {
lab=word400}
N 170 24000 170 24050 {
lab=GND}
N 170 24050 170 24060 {
lab=GND}
N 230 24000 230 24050 {
lab=Y2}
N 230 24050 230 24060 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 24030 1 0 {name=M1752
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 24010 280 24010 {
lab=word400}
N 280 24010 320 24010 {
lab=word400}
N 250 24000 250 24050 {
lab=GND}
N 250 24050 250 24060 {
lab=GND}
N 310 24000 310 24050 {
lab=Y3}
N 310 24050 310 24060 {
lab=Y3}
N 320 24010 360 24010 {
lab=word400}
N 360 24010 400 24010 {
lab=word400}
N 330 24000 330 24050 {
lab=GND}
N 330 24050 330 24060 {
lab=GND}
N 390 24000 390 24050 {
lab=Y4}
N 390 24050 390 24060 {
lab=Y4}

N 410 24060 440 24060 {
lab=GND}
N 440 24050 440 24060 {
lab=GND}
N 400 24010 440 24010 {
lab=word400}
N 440 24010 480 24010 {
lab=word400}
N 410 24000 410 24050 {
lab=GND}
N 410 24050 410 24060 {
lab=GND}
N 470 24000 470 24050 {
lab=Y5}
N 470 24050 470 24060 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 24030 1 0 {name=M1753
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 24010 520 24010 {
lab=word400}
N 520 24010 560 24010 {
lab=word400}
N 490 24000 490 24050 {
lab=GND}
N 490 24050 490 24060 {
lab=GND}
N 550 24000 550 24050 {
lab=Y6}
N 550 24050 550 24060 {
lab=Y6}

N 570 24060 600 24060 {
lab=GND}
N 600 24050 600 24060 {
lab=GND}
N 560 24010 600 24010 {
lab=word400}
N 600 24010 640 24010 {
lab=word400}
N 570 24000 570 24050 {
lab=GND}
N 570 24050 570 24060 {
lab=GND}
N 630 24000 630 24050 {
lab=Y7}
N 630 24050 630 24060 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 24030 1 0 {name=M1754
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24070 0 0 {name=p424 lab=word401}
N 0 24070 40 24070 {
lab=word401}
N 40 24070 80 24070 {
lab=word401}
N 10 24060 10 24110 {
lab=GND}
N 10 24110 10 24120 {
lab=GND}
N 70 24060 70 24110 {
lab=Y0}
N 70 24110 70 24120 {
lab=Y0}
N 80 24070 120 24070 {
lab=word401}
N 120 24070 160 24070 {
lab=word401}
N 90 24060 90 24110 {
lab=GND}
N 90 24110 90 24120 {
lab=GND}
N 150 24060 150 24110 {
lab=Y1}
N 150 24110 150 24120 {
lab=Y1}

N 170 24120 200 24120 {
lab=GND}
N 200 24110 200 24120 {
lab=GND}
N 160 24070 200 24070 {
lab=word401}
N 200 24070 240 24070 {
lab=word401}
N 170 24060 170 24110 {
lab=GND}
N 170 24110 170 24120 {
lab=GND}
N 230 24060 230 24110 {
lab=Y2}
N 230 24110 230 24120 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 24090 1 0 {name=M1755
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 24070 280 24070 {
lab=word401}
N 280 24070 320 24070 {
lab=word401}
N 250 24060 250 24110 {
lab=GND}
N 250 24110 250 24120 {
lab=GND}
N 310 24060 310 24110 {
lab=Y3}
N 310 24110 310 24120 {
lab=Y3}

N 330 24120 360 24120 {
lab=GND}
N 360 24110 360 24120 {
lab=GND}
N 320 24070 360 24070 {
lab=word401}
N 360 24070 400 24070 {
lab=word401}
N 330 24060 330 24110 {
lab=GND}
N 330 24110 330 24120 {
lab=GND}
N 390 24060 390 24110 {
lab=Y4}
N 390 24110 390 24120 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 24090 1 0 {name=M1756
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 24070 440 24070 {
lab=word401}
N 440 24070 480 24070 {
lab=word401}
N 410 24060 410 24110 {
lab=GND}
N 410 24110 410 24120 {
lab=GND}
N 470 24060 470 24110 {
lab=Y5}
N 470 24110 470 24120 {
lab=Y5}

N 490 24120 520 24120 {
lab=GND}
N 520 24110 520 24120 {
lab=GND}
N 480 24070 520 24070 {
lab=word401}
N 520 24070 560 24070 {
lab=word401}
N 490 24060 490 24110 {
lab=GND}
N 490 24110 490 24120 {
lab=GND}
N 550 24060 550 24110 {
lab=Y6}
N 550 24110 550 24120 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 24090 1 0 {name=M1757
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 24070 600 24070 {
lab=word401}
N 600 24070 640 24070 {
lab=word401}
N 570 24060 570 24110 {
lab=GND}
N 570 24110 570 24120 {
lab=GND}
N 630 24060 630 24110 {
lab=Y7}
N 630 24110 630 24120 {
lab=Y7}
C {devices/ipin.sym} 0 24130 0 0 {name=p425 lab=word402}
N 0 24130 40 24130 {
lab=word402}
N 40 24130 80 24130 {
lab=word402}
N 10 24120 10 24170 {
lab=GND}
N 10 24170 10 24180 {
lab=GND}
N 70 24120 70 24170 {
lab=Y0}
N 70 24170 70 24180 {
lab=Y0}
N 80 24130 120 24130 {
lab=word402}
N 120 24130 160 24130 {
lab=word402}
N 90 24120 90 24170 {
lab=GND}
N 90 24170 90 24180 {
lab=GND}
N 150 24120 150 24170 {
lab=Y1}
N 150 24170 150 24180 {
lab=Y1}

N 170 24180 200 24180 {
lab=GND}
N 200 24170 200 24180 {
lab=GND}
N 160 24130 200 24130 {
lab=word402}
N 200 24130 240 24130 {
lab=word402}
N 170 24120 170 24170 {
lab=GND}
N 170 24170 170 24180 {
lab=GND}
N 230 24120 230 24170 {
lab=Y2}
N 230 24170 230 24180 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 24150 1 0 {name=M1758
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 24130 280 24130 {
lab=word402}
N 280 24130 320 24130 {
lab=word402}
N 250 24120 250 24170 {
lab=GND}
N 250 24170 250 24180 {
lab=GND}
N 310 24120 310 24170 {
lab=Y3}
N 310 24170 310 24180 {
lab=Y3}

N 330 24180 360 24180 {
lab=GND}
N 360 24170 360 24180 {
lab=GND}
N 320 24130 360 24130 {
lab=word402}
N 360 24130 400 24130 {
lab=word402}
N 330 24120 330 24170 {
lab=GND}
N 330 24170 330 24180 {
lab=GND}
N 390 24120 390 24170 {
lab=Y4}
N 390 24170 390 24180 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 24150 1 0 {name=M1759
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 24180 440 24180 {
lab=GND}
N 440 24170 440 24180 {
lab=GND}
N 400 24130 440 24130 {
lab=word402}
N 440 24130 480 24130 {
lab=word402}
N 410 24120 410 24170 {
lab=GND}
N 410 24170 410 24180 {
lab=GND}
N 470 24120 470 24170 {
lab=Y5}
N 470 24170 470 24180 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 24150 1 0 {name=M1760
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 24180 520 24180 {
lab=GND}
N 520 24170 520 24180 {
lab=GND}
N 480 24130 520 24130 {
lab=word402}
N 520 24130 560 24130 {
lab=word402}
N 490 24120 490 24170 {
lab=GND}
N 490 24170 490 24180 {
lab=GND}
N 550 24120 550 24170 {
lab=Y6}
N 550 24170 550 24180 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 24150 1 0 {name=M1761
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 24180 600 24180 {
lab=GND}
N 600 24170 600 24180 {
lab=GND}
N 560 24130 600 24130 {
lab=word402}
N 600 24130 640 24130 {
lab=word402}
N 570 24120 570 24170 {
lab=GND}
N 570 24170 570 24180 {
lab=GND}
N 630 24120 630 24170 {
lab=Y7}
N 630 24170 630 24180 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 24150 1 0 {name=M1762
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24190 0 0 {name=p426 lab=word403}
N 0 24190 40 24190 {
lab=word403}
N 40 24190 80 24190 {
lab=word403}
N 10 24180 10 24230 {
lab=GND}
N 10 24230 10 24240 {
lab=GND}
N 70 24180 70 24230 {
lab=Y0}
N 70 24230 70 24240 {
lab=Y0}
N 80 24190 120 24190 {
lab=word403}
N 120 24190 160 24190 {
lab=word403}
N 90 24180 90 24230 {
lab=GND}
N 90 24230 90 24240 {
lab=GND}
N 150 24180 150 24230 {
lab=Y1}
N 150 24230 150 24240 {
lab=Y1}

N 170 24240 200 24240 {
lab=GND}
N 200 24230 200 24240 {
lab=GND}
N 160 24190 200 24190 {
lab=word403}
N 200 24190 240 24190 {
lab=word403}
N 170 24180 170 24230 {
lab=GND}
N 170 24230 170 24240 {
lab=GND}
N 230 24180 230 24230 {
lab=Y2}
N 230 24230 230 24240 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 24210 1 0 {name=M1763
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 24240 280 24240 {
lab=GND}
N 280 24230 280 24240 {
lab=GND}
N 240 24190 280 24190 {
lab=word403}
N 280 24190 320 24190 {
lab=word403}
N 250 24180 250 24230 {
lab=GND}
N 250 24230 250 24240 {
lab=GND}
N 310 24180 310 24230 {
lab=Y3}
N 310 24230 310 24240 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 24210 1 0 {name=M1764
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 24190 360 24190 {
lab=word403}
N 360 24190 400 24190 {
lab=word403}
N 330 24180 330 24230 {
lab=GND}
N 330 24230 330 24240 {
lab=GND}
N 390 24180 390 24230 {
lab=Y4}
N 390 24230 390 24240 {
lab=Y4}

N 410 24240 440 24240 {
lab=GND}
N 440 24230 440 24240 {
lab=GND}
N 400 24190 440 24190 {
lab=word403}
N 440 24190 480 24190 {
lab=word403}
N 410 24180 410 24230 {
lab=GND}
N 410 24230 410 24240 {
lab=GND}
N 470 24180 470 24230 {
lab=Y5}
N 470 24230 470 24240 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 24210 1 0 {name=M1765
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 24190 520 24190 {
lab=word403}
N 520 24190 560 24190 {
lab=word403}
N 490 24180 490 24230 {
lab=GND}
N 490 24230 490 24240 {
lab=GND}
N 550 24180 550 24230 {
lab=Y6}
N 550 24230 550 24240 {
lab=Y6}
N 560 24190 600 24190 {
lab=word403}
N 600 24190 640 24190 {
lab=word403}
N 570 24180 570 24230 {
lab=GND}
N 570 24230 570 24240 {
lab=GND}
N 630 24180 630 24230 {
lab=Y7}
N 630 24230 630 24240 {
lab=Y7}
C {devices/ipin.sym} 0 24250 0 0 {name=p427 lab=word404}
N 0 24250 40 24250 {
lab=word404}
N 40 24250 80 24250 {
lab=word404}
N 10 24240 10 24290 {
lab=GND}
N 10 24290 10 24300 {
lab=GND}
N 70 24240 70 24290 {
lab=Y0}
N 70 24290 70 24300 {
lab=Y0}
N 80 24250 120 24250 {
lab=word404}
N 120 24250 160 24250 {
lab=word404}
N 90 24240 90 24290 {
lab=GND}
N 90 24290 90 24300 {
lab=GND}
N 150 24240 150 24290 {
lab=Y1}
N 150 24290 150 24300 {
lab=Y1}

N 170 24300 200 24300 {
lab=GND}
N 200 24290 200 24300 {
lab=GND}
N 160 24250 200 24250 {
lab=word404}
N 200 24250 240 24250 {
lab=word404}
N 170 24240 170 24290 {
lab=GND}
N 170 24290 170 24300 {
lab=GND}
N 230 24240 230 24290 {
lab=Y2}
N 230 24290 230 24300 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 24270 1 0 {name=M1766
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 24300 280 24300 {
lab=GND}
N 280 24290 280 24300 {
lab=GND}
N 240 24250 280 24250 {
lab=word404}
N 280 24250 320 24250 {
lab=word404}
N 250 24240 250 24290 {
lab=GND}
N 250 24290 250 24300 {
lab=GND}
N 310 24240 310 24290 {
lab=Y3}
N 310 24290 310 24300 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 24270 1 0 {name=M1767
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 24300 360 24300 {
lab=GND}
N 360 24290 360 24300 {
lab=GND}
N 320 24250 360 24250 {
lab=word404}
N 360 24250 400 24250 {
lab=word404}
N 330 24240 330 24290 {
lab=GND}
N 330 24290 330 24300 {
lab=GND}
N 390 24240 390 24290 {
lab=Y4}
N 390 24290 390 24300 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 24270 1 0 {name=M1768
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 24250 440 24250 {
lab=word404}
N 440 24250 480 24250 {
lab=word404}
N 410 24240 410 24290 {
lab=GND}
N 410 24290 410 24300 {
lab=GND}
N 470 24240 470 24290 {
lab=Y5}
N 470 24290 470 24300 {
lab=Y5}
N 480 24250 520 24250 {
lab=word404}
N 520 24250 560 24250 {
lab=word404}
N 490 24240 490 24290 {
lab=GND}
N 490 24290 490 24300 {
lab=GND}
N 550 24240 550 24290 {
lab=Y6}
N 550 24290 550 24300 {
lab=Y6}

N 570 24300 600 24300 {
lab=GND}
N 600 24290 600 24300 {
lab=GND}
N 560 24250 600 24250 {
lab=word404}
N 600 24250 640 24250 {
lab=word404}
N 570 24240 570 24290 {
lab=GND}
N 570 24290 570 24300 {
lab=GND}
N 630 24240 630 24290 {
lab=Y7}
N 630 24290 630 24300 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 24270 1 0 {name=M1769
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24310 0 0 {name=p428 lab=word405}
N 0 24310 40 24310 {
lab=word405}
N 40 24310 80 24310 {
lab=word405}
N 10 24300 10 24350 {
lab=GND}
N 10 24350 10 24360 {
lab=GND}
N 70 24300 70 24350 {
lab=Y0}
N 70 24350 70 24360 {
lab=Y0}
N 80 24310 120 24310 {
lab=word405}
N 120 24310 160 24310 {
lab=word405}
N 90 24300 90 24350 {
lab=GND}
N 90 24350 90 24360 {
lab=GND}
N 150 24300 150 24350 {
lab=Y1}
N 150 24350 150 24360 {
lab=Y1}

N 170 24360 200 24360 {
lab=GND}
N 200 24350 200 24360 {
lab=GND}
N 160 24310 200 24310 {
lab=word405}
N 200 24310 240 24310 {
lab=word405}
N 170 24300 170 24350 {
lab=GND}
N 170 24350 170 24360 {
lab=GND}
N 230 24300 230 24350 {
lab=Y2}
N 230 24350 230 24360 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 24330 1 0 {name=M1770
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 24360 280 24360 {
lab=GND}
N 280 24350 280 24360 {
lab=GND}
N 240 24310 280 24310 {
lab=word405}
N 280 24310 320 24310 {
lab=word405}
N 250 24300 250 24350 {
lab=GND}
N 250 24350 250 24360 {
lab=GND}
N 310 24300 310 24350 {
lab=Y3}
N 310 24350 310 24360 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 24330 1 0 {name=M1771
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 24360 360 24360 {
lab=GND}
N 360 24350 360 24360 {
lab=GND}
N 320 24310 360 24310 {
lab=word405}
N 360 24310 400 24310 {
lab=word405}
N 330 24300 330 24350 {
lab=GND}
N 330 24350 330 24360 {
lab=GND}
N 390 24300 390 24350 {
lab=Y4}
N 390 24350 390 24360 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 24330 1 0 {name=M1772
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 24360 440 24360 {
lab=GND}
N 440 24350 440 24360 {
lab=GND}
N 400 24310 440 24310 {
lab=word405}
N 440 24310 480 24310 {
lab=word405}
N 410 24300 410 24350 {
lab=GND}
N 410 24350 410 24360 {
lab=GND}
N 470 24300 470 24350 {
lab=Y5}
N 470 24350 470 24360 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 24330 1 0 {name=M1773
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 24360 520 24360 {
lab=GND}
N 520 24350 520 24360 {
lab=GND}
N 480 24310 520 24310 {
lab=word405}
N 520 24310 560 24310 {
lab=word405}
N 490 24300 490 24350 {
lab=GND}
N 490 24350 490 24360 {
lab=GND}
N 550 24300 550 24350 {
lab=Y6}
N 550 24350 550 24360 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 24330 1 0 {name=M1774
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 24310 600 24310 {
lab=word405}
N 600 24310 640 24310 {
lab=word405}
N 570 24300 570 24350 {
lab=GND}
N 570 24350 570 24360 {
lab=GND}
N 630 24300 630 24350 {
lab=Y7}
N 630 24350 630 24360 {
lab=Y7}
C {devices/ipin.sym} 0 24370 0 0 {name=p429 lab=word406}
N 0 24370 40 24370 {
lab=word406}
N 40 24370 80 24370 {
lab=word406}
N 10 24360 10 24410 {
lab=GND}
N 10 24410 10 24420 {
lab=GND}
N 70 24360 70 24410 {
lab=Y0}
N 70 24410 70 24420 {
lab=Y0}

N 90 24420 120 24420 {
lab=GND}
N 120 24410 120 24420 {
lab=GND}
N 80 24370 120 24370 {
lab=word406}
N 120 24370 160 24370 {
lab=word406}
N 90 24360 90 24410 {
lab=GND}
N 90 24410 90 24420 {
lab=GND}
N 150 24360 150 24410 {
lab=Y1}
N 150 24410 150 24420 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 24390 1 0 {name=M1775
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 24370 200 24370 {
lab=word406}
N 200 24370 240 24370 {
lab=word406}
N 170 24360 170 24410 {
lab=GND}
N 170 24410 170 24420 {
lab=GND}
N 230 24360 230 24410 {
lab=Y2}
N 230 24410 230 24420 {
lab=Y2}
N 240 24370 280 24370 {
lab=word406}
N 280 24370 320 24370 {
lab=word406}
N 250 24360 250 24410 {
lab=GND}
N 250 24410 250 24420 {
lab=GND}
N 310 24360 310 24410 {
lab=Y3}
N 310 24410 310 24420 {
lab=Y3}
N 320 24370 360 24370 {
lab=word406}
N 360 24370 400 24370 {
lab=word406}
N 330 24360 330 24410 {
lab=GND}
N 330 24410 330 24420 {
lab=GND}
N 390 24360 390 24410 {
lab=Y4}
N 390 24410 390 24420 {
lab=Y4}
N 400 24370 440 24370 {
lab=word406}
N 440 24370 480 24370 {
lab=word406}
N 410 24360 410 24410 {
lab=GND}
N 410 24410 410 24420 {
lab=GND}
N 470 24360 470 24410 {
lab=Y5}
N 470 24410 470 24420 {
lab=Y5}

N 490 24420 520 24420 {
lab=GND}
N 520 24410 520 24420 {
lab=GND}
N 480 24370 520 24370 {
lab=word406}
N 520 24370 560 24370 {
lab=word406}
N 490 24360 490 24410 {
lab=GND}
N 490 24410 490 24420 {
lab=GND}
N 550 24360 550 24410 {
lab=Y6}
N 550 24410 550 24420 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 24390 1 0 {name=M1776
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 24420 600 24420 {
lab=GND}
N 600 24410 600 24420 {
lab=GND}
N 560 24370 600 24370 {
lab=word406}
N 600 24370 640 24370 {
lab=word406}
N 570 24360 570 24410 {
lab=GND}
N 570 24410 570 24420 {
lab=GND}
N 630 24360 630 24410 {
lab=Y7}
N 630 24410 630 24420 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 24390 1 0 {name=M1777
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24430 0 0 {name=p430 lab=word407}
N 0 24430 40 24430 {
lab=word407}
N 40 24430 80 24430 {
lab=word407}
N 10 24420 10 24470 {
lab=GND}
N 10 24470 10 24480 {
lab=GND}
N 70 24420 70 24470 {
lab=Y0}
N 70 24470 70 24480 {
lab=Y0}

N 90 24480 120 24480 {
lab=GND}
N 120 24470 120 24480 {
lab=GND}
N 80 24430 120 24430 {
lab=word407}
N 120 24430 160 24430 {
lab=word407}
N 90 24420 90 24470 {
lab=GND}
N 90 24470 90 24480 {
lab=GND}
N 150 24420 150 24470 {
lab=Y1}
N 150 24470 150 24480 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 24450 1 0 {name=M1778
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 24430 200 24430 {
lab=word407}
N 200 24430 240 24430 {
lab=word407}
N 170 24420 170 24470 {
lab=GND}
N 170 24470 170 24480 {
lab=GND}
N 230 24420 230 24470 {
lab=Y2}
N 230 24470 230 24480 {
lab=Y2}
N 240 24430 280 24430 {
lab=word407}
N 280 24430 320 24430 {
lab=word407}
N 250 24420 250 24470 {
lab=GND}
N 250 24470 250 24480 {
lab=GND}
N 310 24420 310 24470 {
lab=Y3}
N 310 24470 310 24480 {
lab=Y3}

N 330 24480 360 24480 {
lab=GND}
N 360 24470 360 24480 {
lab=GND}
N 320 24430 360 24430 {
lab=word407}
N 360 24430 400 24430 {
lab=word407}
N 330 24420 330 24470 {
lab=GND}
N 330 24470 330 24480 {
lab=GND}
N 390 24420 390 24470 {
lab=Y4}
N 390 24470 390 24480 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 24450 1 0 {name=M1779
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 24430 440 24430 {
lab=word407}
N 440 24430 480 24430 {
lab=word407}
N 410 24420 410 24470 {
lab=GND}
N 410 24470 410 24480 {
lab=GND}
N 470 24420 470 24470 {
lab=Y5}
N 470 24470 470 24480 {
lab=Y5}
N 480 24430 520 24430 {
lab=word407}
N 520 24430 560 24430 {
lab=word407}
N 490 24420 490 24470 {
lab=GND}
N 490 24470 490 24480 {
lab=GND}
N 550 24420 550 24470 {
lab=Y6}
N 550 24470 550 24480 {
lab=Y6}

N 570 24480 600 24480 {
lab=GND}
N 600 24470 600 24480 {
lab=GND}
N 560 24430 600 24430 {
lab=word407}
N 600 24430 640 24430 {
lab=word407}
N 570 24420 570 24470 {
lab=GND}
N 570 24470 570 24480 {
lab=GND}
N 630 24420 630 24470 {
lab=Y7}
N 630 24470 630 24480 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 24450 1 0 {name=M1780
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24490 0 0 {name=p431 lab=word408}
N 0 24490 40 24490 {
lab=word408}
N 40 24490 80 24490 {
lab=word408}
N 10 24480 10 24530 {
lab=GND}
N 10 24530 10 24540 {
lab=GND}
N 70 24480 70 24530 {
lab=Y0}
N 70 24530 70 24540 {
lab=Y0}

N 90 24540 120 24540 {
lab=GND}
N 120 24530 120 24540 {
lab=GND}
N 80 24490 120 24490 {
lab=word408}
N 120 24490 160 24490 {
lab=word408}
N 90 24480 90 24530 {
lab=GND}
N 90 24530 90 24540 {
lab=GND}
N 150 24480 150 24530 {
lab=Y1}
N 150 24530 150 24540 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 24510 1 0 {name=M1781
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 24490 200 24490 {
lab=word408}
N 200 24490 240 24490 {
lab=word408}
N 170 24480 170 24530 {
lab=GND}
N 170 24530 170 24540 {
lab=GND}
N 230 24480 230 24530 {
lab=Y2}
N 230 24530 230 24540 {
lab=Y2}
N 240 24490 280 24490 {
lab=word408}
N 280 24490 320 24490 {
lab=word408}
N 250 24480 250 24530 {
lab=GND}
N 250 24530 250 24540 {
lab=GND}
N 310 24480 310 24530 {
lab=Y3}
N 310 24530 310 24540 {
lab=Y3}

N 330 24540 360 24540 {
lab=GND}
N 360 24530 360 24540 {
lab=GND}
N 320 24490 360 24490 {
lab=word408}
N 360 24490 400 24490 {
lab=word408}
N 330 24480 330 24530 {
lab=GND}
N 330 24530 330 24540 {
lab=GND}
N 390 24480 390 24530 {
lab=Y4}
N 390 24530 390 24540 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 24510 1 0 {name=M1782
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 24540 440 24540 {
lab=GND}
N 440 24530 440 24540 {
lab=GND}
N 400 24490 440 24490 {
lab=word408}
N 440 24490 480 24490 {
lab=word408}
N 410 24480 410 24530 {
lab=GND}
N 410 24530 410 24540 {
lab=GND}
N 470 24480 470 24530 {
lab=Y5}
N 470 24530 470 24540 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 24510 1 0 {name=M1783
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 24540 520 24540 {
lab=GND}
N 520 24530 520 24540 {
lab=GND}
N 480 24490 520 24490 {
lab=word408}
N 520 24490 560 24490 {
lab=word408}
N 490 24480 490 24530 {
lab=GND}
N 490 24530 490 24540 {
lab=GND}
N 550 24480 550 24530 {
lab=Y6}
N 550 24530 550 24540 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 24510 1 0 {name=M1784
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 24540 600 24540 {
lab=GND}
N 600 24530 600 24540 {
lab=GND}
N 560 24490 600 24490 {
lab=word408}
N 600 24490 640 24490 {
lab=word408}
N 570 24480 570 24530 {
lab=GND}
N 570 24530 570 24540 {
lab=GND}
N 630 24480 630 24530 {
lab=Y7}
N 630 24530 630 24540 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 24510 1 0 {name=M1785
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24550 0 0 {name=p432 lab=word409}
N 0 24550 40 24550 {
lab=word409}
N 40 24550 80 24550 {
lab=word409}
N 10 24540 10 24590 {
lab=GND}
N 10 24590 10 24600 {
lab=GND}
N 70 24540 70 24590 {
lab=Y0}
N 70 24590 70 24600 {
lab=Y0}

N 90 24600 120 24600 {
lab=GND}
N 120 24590 120 24600 {
lab=GND}
N 80 24550 120 24550 {
lab=word409}
N 120 24550 160 24550 {
lab=word409}
N 90 24540 90 24590 {
lab=GND}
N 90 24590 90 24600 {
lab=GND}
N 150 24540 150 24590 {
lab=Y1}
N 150 24590 150 24600 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 24570 1 0 {name=M1786
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 24550 200 24550 {
lab=word409}
N 200 24550 240 24550 {
lab=word409}
N 170 24540 170 24590 {
lab=GND}
N 170 24590 170 24600 {
lab=GND}
N 230 24540 230 24590 {
lab=Y2}
N 230 24590 230 24600 {
lab=Y2}

N 250 24600 280 24600 {
lab=GND}
N 280 24590 280 24600 {
lab=GND}
N 240 24550 280 24550 {
lab=word409}
N 280 24550 320 24550 {
lab=word409}
N 250 24540 250 24590 {
lab=GND}
N 250 24590 250 24600 {
lab=GND}
N 310 24540 310 24590 {
lab=Y3}
N 310 24590 310 24600 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 24570 1 0 {name=M1787
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 24550 360 24550 {
lab=word409}
N 360 24550 400 24550 {
lab=word409}
N 330 24540 330 24590 {
lab=GND}
N 330 24590 330 24600 {
lab=GND}
N 390 24540 390 24590 {
lab=Y4}
N 390 24590 390 24600 {
lab=Y4}

N 410 24600 440 24600 {
lab=GND}
N 440 24590 440 24600 {
lab=GND}
N 400 24550 440 24550 {
lab=word409}
N 440 24550 480 24550 {
lab=word409}
N 410 24540 410 24590 {
lab=GND}
N 410 24590 410 24600 {
lab=GND}
N 470 24540 470 24590 {
lab=Y5}
N 470 24590 470 24600 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 24570 1 0 {name=M1788
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 24550 520 24550 {
lab=word409}
N 520 24550 560 24550 {
lab=word409}
N 490 24540 490 24590 {
lab=GND}
N 490 24590 490 24600 {
lab=GND}
N 550 24540 550 24590 {
lab=Y6}
N 550 24590 550 24600 {
lab=Y6}

N 570 24600 600 24600 {
lab=GND}
N 600 24590 600 24600 {
lab=GND}
N 560 24550 600 24550 {
lab=word409}
N 600 24550 640 24550 {
lab=word409}
N 570 24540 570 24590 {
lab=GND}
N 570 24590 570 24600 {
lab=GND}
N 630 24540 630 24590 {
lab=Y7}
N 630 24590 630 24600 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 24570 1 0 {name=M1789
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24610 0 0 {name=p433 lab=word410}
N 0 24610 40 24610 {
lab=word410}
N 40 24610 80 24610 {
lab=word410}
N 10 24600 10 24650 {
lab=GND}
N 10 24650 10 24660 {
lab=GND}
N 70 24600 70 24650 {
lab=Y0}
N 70 24650 70 24660 {
lab=Y0}

N 90 24660 120 24660 {
lab=GND}
N 120 24650 120 24660 {
lab=GND}
N 80 24610 120 24610 {
lab=word410}
N 120 24610 160 24610 {
lab=word410}
N 90 24600 90 24650 {
lab=GND}
N 90 24650 90 24660 {
lab=GND}
N 150 24600 150 24650 {
lab=Y1}
N 150 24650 150 24660 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 24630 1 0 {name=M1790
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 24610 200 24610 {
lab=word410}
N 200 24610 240 24610 {
lab=word410}
N 170 24600 170 24650 {
lab=GND}
N 170 24650 170 24660 {
lab=GND}
N 230 24600 230 24650 {
lab=Y2}
N 230 24650 230 24660 {
lab=Y2}

N 250 24660 280 24660 {
lab=GND}
N 280 24650 280 24660 {
lab=GND}
N 240 24610 280 24610 {
lab=word410}
N 280 24610 320 24610 {
lab=word410}
N 250 24600 250 24650 {
lab=GND}
N 250 24650 250 24660 {
lab=GND}
N 310 24600 310 24650 {
lab=Y3}
N 310 24650 310 24660 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 24630 1 0 {name=M1791
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 24660 360 24660 {
lab=GND}
N 360 24650 360 24660 {
lab=GND}
N 320 24610 360 24610 {
lab=word410}
N 360 24610 400 24610 {
lab=word410}
N 330 24600 330 24650 {
lab=GND}
N 330 24650 330 24660 {
lab=GND}
N 390 24600 390 24650 {
lab=Y4}
N 390 24650 390 24660 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 24630 1 0 {name=M1792
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 24610 440 24610 {
lab=word410}
N 440 24610 480 24610 {
lab=word410}
N 410 24600 410 24650 {
lab=GND}
N 410 24650 410 24660 {
lab=GND}
N 470 24600 470 24650 {
lab=Y5}
N 470 24650 470 24660 {
lab=Y5}

N 490 24660 520 24660 {
lab=GND}
N 520 24650 520 24660 {
lab=GND}
N 480 24610 520 24610 {
lab=word410}
N 520 24610 560 24610 {
lab=word410}
N 490 24600 490 24650 {
lab=GND}
N 490 24650 490 24660 {
lab=GND}
N 550 24600 550 24650 {
lab=Y6}
N 550 24650 550 24660 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 24630 1 0 {name=M1793
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 24610 600 24610 {
lab=word410}
N 600 24610 640 24610 {
lab=word410}
N 570 24600 570 24650 {
lab=GND}
N 570 24650 570 24660 {
lab=GND}
N 630 24600 630 24650 {
lab=Y7}
N 630 24650 630 24660 {
lab=Y7}
C {devices/ipin.sym} 0 24670 0 0 {name=p434 lab=word411}
N 0 24670 40 24670 {
lab=word411}
N 40 24670 80 24670 {
lab=word411}
N 10 24660 10 24710 {
lab=GND}
N 10 24710 10 24720 {
lab=GND}
N 70 24660 70 24710 {
lab=Y0}
N 70 24710 70 24720 {
lab=Y0}

N 90 24720 120 24720 {
lab=GND}
N 120 24710 120 24720 {
lab=GND}
N 80 24670 120 24670 {
lab=word411}
N 120 24670 160 24670 {
lab=word411}
N 90 24660 90 24710 {
lab=GND}
N 90 24710 90 24720 {
lab=GND}
N 150 24660 150 24710 {
lab=Y1}
N 150 24710 150 24720 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 24690 1 0 {name=M1794
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 24720 200 24720 {
lab=GND}
N 200 24710 200 24720 {
lab=GND}
N 160 24670 200 24670 {
lab=word411}
N 200 24670 240 24670 {
lab=word411}
N 170 24660 170 24710 {
lab=GND}
N 170 24710 170 24720 {
lab=GND}
N 230 24660 230 24710 {
lab=Y2}
N 230 24710 230 24720 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 24690 1 0 {name=M1795
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 24670 280 24670 {
lab=word411}
N 280 24670 320 24670 {
lab=word411}
N 250 24660 250 24710 {
lab=GND}
N 250 24710 250 24720 {
lab=GND}
N 310 24660 310 24710 {
lab=Y3}
N 310 24710 310 24720 {
lab=Y3}
N 320 24670 360 24670 {
lab=word411}
N 360 24670 400 24670 {
lab=word411}
N 330 24660 330 24710 {
lab=GND}
N 330 24710 330 24720 {
lab=GND}
N 390 24660 390 24710 {
lab=Y4}
N 390 24710 390 24720 {
lab=Y4}
N 400 24670 440 24670 {
lab=word411}
N 440 24670 480 24670 {
lab=word411}
N 410 24660 410 24710 {
lab=GND}
N 410 24710 410 24720 {
lab=GND}
N 470 24660 470 24710 {
lab=Y5}
N 470 24710 470 24720 {
lab=Y5}
N 480 24670 520 24670 {
lab=word411}
N 520 24670 560 24670 {
lab=word411}
N 490 24660 490 24710 {
lab=GND}
N 490 24710 490 24720 {
lab=GND}
N 550 24660 550 24710 {
lab=Y6}
N 550 24710 550 24720 {
lab=Y6}

N 570 24720 600 24720 {
lab=GND}
N 600 24710 600 24720 {
lab=GND}
N 560 24670 600 24670 {
lab=word411}
N 600 24670 640 24670 {
lab=word411}
N 570 24660 570 24710 {
lab=GND}
N 570 24710 570 24720 {
lab=GND}
N 630 24660 630 24710 {
lab=Y7}
N 630 24710 630 24720 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 24690 1 0 {name=M1796
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24730 0 0 {name=p435 lab=word412}
N 0 24730 40 24730 {
lab=word412}
N 40 24730 80 24730 {
lab=word412}
N 10 24720 10 24770 {
lab=GND}
N 10 24770 10 24780 {
lab=GND}
N 70 24720 70 24770 {
lab=Y0}
N 70 24770 70 24780 {
lab=Y0}

N 90 24780 120 24780 {
lab=GND}
N 120 24770 120 24780 {
lab=GND}
N 80 24730 120 24730 {
lab=word412}
N 120 24730 160 24730 {
lab=word412}
N 90 24720 90 24770 {
lab=GND}
N 90 24770 90 24780 {
lab=GND}
N 150 24720 150 24770 {
lab=Y1}
N 150 24770 150 24780 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 24750 1 0 {name=M1797
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 24780 200 24780 {
lab=GND}
N 200 24770 200 24780 {
lab=GND}
N 160 24730 200 24730 {
lab=word412}
N 200 24730 240 24730 {
lab=word412}
N 170 24720 170 24770 {
lab=GND}
N 170 24770 170 24780 {
lab=GND}
N 230 24720 230 24770 {
lab=Y2}
N 230 24770 230 24780 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 24750 1 0 {name=M1798
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 24730 280 24730 {
lab=word412}
N 280 24730 320 24730 {
lab=word412}
N 250 24720 250 24770 {
lab=GND}
N 250 24770 250 24780 {
lab=GND}
N 310 24720 310 24770 {
lab=Y3}
N 310 24770 310 24780 {
lab=Y3}
N 320 24730 360 24730 {
lab=word412}
N 360 24730 400 24730 {
lab=word412}
N 330 24720 330 24770 {
lab=GND}
N 330 24770 330 24780 {
lab=GND}
N 390 24720 390 24770 {
lab=Y4}
N 390 24770 390 24780 {
lab=Y4}

N 410 24780 440 24780 {
lab=GND}
N 440 24770 440 24780 {
lab=GND}
N 400 24730 440 24730 {
lab=word412}
N 440 24730 480 24730 {
lab=word412}
N 410 24720 410 24770 {
lab=GND}
N 410 24770 410 24780 {
lab=GND}
N 470 24720 470 24770 {
lab=Y5}
N 470 24770 470 24780 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 24750 1 0 {name=M1799
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 24780 520 24780 {
lab=GND}
N 520 24770 520 24780 {
lab=GND}
N 480 24730 520 24730 {
lab=word412}
N 520 24730 560 24730 {
lab=word412}
N 490 24720 490 24770 {
lab=GND}
N 490 24770 490 24780 {
lab=GND}
N 550 24720 550 24770 {
lab=Y6}
N 550 24770 550 24780 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 24750 1 0 {name=M1800
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 24780 600 24780 {
lab=GND}
N 600 24770 600 24780 {
lab=GND}
N 560 24730 600 24730 {
lab=word412}
N 600 24730 640 24730 {
lab=word412}
N 570 24720 570 24770 {
lab=GND}
N 570 24770 570 24780 {
lab=GND}
N 630 24720 630 24770 {
lab=Y7}
N 630 24770 630 24780 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 24750 1 0 {name=M1801
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24790 0 0 {name=p436 lab=word413}
N 0 24790 40 24790 {
lab=word413}
N 40 24790 80 24790 {
lab=word413}
N 10 24780 10 24830 {
lab=GND}
N 10 24830 10 24840 {
lab=GND}
N 70 24780 70 24830 {
lab=Y0}
N 70 24830 70 24840 {
lab=Y0}

N 90 24840 120 24840 {
lab=GND}
N 120 24830 120 24840 {
lab=GND}
N 80 24790 120 24790 {
lab=word413}
N 120 24790 160 24790 {
lab=word413}
N 90 24780 90 24830 {
lab=GND}
N 90 24830 90 24840 {
lab=GND}
N 150 24780 150 24830 {
lab=Y1}
N 150 24830 150 24840 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 24810 1 0 {name=M1802
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 24840 200 24840 {
lab=GND}
N 200 24830 200 24840 {
lab=GND}
N 160 24790 200 24790 {
lab=word413}
N 200 24790 240 24790 {
lab=word413}
N 170 24780 170 24830 {
lab=GND}
N 170 24830 170 24840 {
lab=GND}
N 230 24780 230 24830 {
lab=Y2}
N 230 24830 230 24840 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 24810 1 0 {name=M1803
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 24790 280 24790 {
lab=word413}
N 280 24790 320 24790 {
lab=word413}
N 250 24780 250 24830 {
lab=GND}
N 250 24830 250 24840 {
lab=GND}
N 310 24780 310 24830 {
lab=Y3}
N 310 24830 310 24840 {
lab=Y3}

N 330 24840 360 24840 {
lab=GND}
N 360 24830 360 24840 {
lab=GND}
N 320 24790 360 24790 {
lab=word413}
N 360 24790 400 24790 {
lab=word413}
N 330 24780 330 24830 {
lab=GND}
N 330 24830 330 24840 {
lab=GND}
N 390 24780 390 24830 {
lab=Y4}
N 390 24830 390 24840 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 24810 1 0 {name=M1804
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 24840 440 24840 {
lab=GND}
N 440 24830 440 24840 {
lab=GND}
N 400 24790 440 24790 {
lab=word413}
N 440 24790 480 24790 {
lab=word413}
N 410 24780 410 24830 {
lab=GND}
N 410 24830 410 24840 {
lab=GND}
N 470 24780 470 24830 {
lab=Y5}
N 470 24830 470 24840 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 24810 1 0 {name=M1805
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 24790 520 24790 {
lab=word413}
N 520 24790 560 24790 {
lab=word413}
N 490 24780 490 24830 {
lab=GND}
N 490 24830 490 24840 {
lab=GND}
N 550 24780 550 24830 {
lab=Y6}
N 550 24830 550 24840 {
lab=Y6}

N 570 24840 600 24840 {
lab=GND}
N 600 24830 600 24840 {
lab=GND}
N 560 24790 600 24790 {
lab=word413}
N 600 24790 640 24790 {
lab=word413}
N 570 24780 570 24830 {
lab=GND}
N 570 24830 570 24840 {
lab=GND}
N 630 24780 630 24830 {
lab=Y7}
N 630 24830 630 24840 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 24810 1 0 {name=M1806
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24850 0 0 {name=p437 lab=word414}
N 0 24850 40 24850 {
lab=word414}
N 40 24850 80 24850 {
lab=word414}
N 10 24840 10 24890 {
lab=GND}
N 10 24890 10 24900 {
lab=GND}
N 70 24840 70 24890 {
lab=Y0}
N 70 24890 70 24900 {
lab=Y0}

N 90 24900 120 24900 {
lab=GND}
N 120 24890 120 24900 {
lab=GND}
N 80 24850 120 24850 {
lab=word414}
N 120 24850 160 24850 {
lab=word414}
N 90 24840 90 24890 {
lab=GND}
N 90 24890 90 24900 {
lab=GND}
N 150 24840 150 24890 {
lab=Y1}
N 150 24890 150 24900 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 24870 1 0 {name=M1807
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 24900 200 24900 {
lab=GND}
N 200 24890 200 24900 {
lab=GND}
N 160 24850 200 24850 {
lab=word414}
N 200 24850 240 24850 {
lab=word414}
N 170 24840 170 24890 {
lab=GND}
N 170 24890 170 24900 {
lab=GND}
N 230 24840 230 24890 {
lab=Y2}
N 230 24890 230 24900 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 24870 1 0 {name=M1808
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 24900 280 24900 {
lab=GND}
N 280 24890 280 24900 {
lab=GND}
N 240 24850 280 24850 {
lab=word414}
N 280 24850 320 24850 {
lab=word414}
N 250 24840 250 24890 {
lab=GND}
N 250 24890 250 24900 {
lab=GND}
N 310 24840 310 24890 {
lab=Y3}
N 310 24890 310 24900 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 24870 1 0 {name=M1809
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 24850 360 24850 {
lab=word414}
N 360 24850 400 24850 {
lab=word414}
N 330 24840 330 24890 {
lab=GND}
N 330 24890 330 24900 {
lab=GND}
N 390 24840 390 24890 {
lab=Y4}
N 390 24890 390 24900 {
lab=Y4}
N 400 24850 440 24850 {
lab=word414}
N 440 24850 480 24850 {
lab=word414}
N 410 24840 410 24890 {
lab=GND}
N 410 24890 410 24900 {
lab=GND}
N 470 24840 470 24890 {
lab=Y5}
N 470 24890 470 24900 {
lab=Y5}

N 490 24900 520 24900 {
lab=GND}
N 520 24890 520 24900 {
lab=GND}
N 480 24850 520 24850 {
lab=word414}
N 520 24850 560 24850 {
lab=word414}
N 490 24840 490 24890 {
lab=GND}
N 490 24890 490 24900 {
lab=GND}
N 550 24840 550 24890 {
lab=Y6}
N 550 24890 550 24900 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 24870 1 0 {name=M1810
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 24900 600 24900 {
lab=GND}
N 600 24890 600 24900 {
lab=GND}
N 560 24850 600 24850 {
lab=word414}
N 600 24850 640 24850 {
lab=word414}
N 570 24840 570 24890 {
lab=GND}
N 570 24890 570 24900 {
lab=GND}
N 630 24840 630 24890 {
lab=Y7}
N 630 24890 630 24900 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 24870 1 0 {name=M1811
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24910 0 0 {name=p438 lab=word415}
N 0 24910 40 24910 {
lab=word415}
N 40 24910 80 24910 {
lab=word415}
N 10 24900 10 24950 {
lab=GND}
N 10 24950 10 24960 {
lab=GND}
N 70 24900 70 24950 {
lab=Y0}
N 70 24950 70 24960 {
lab=Y0}

N 90 24960 120 24960 {
lab=GND}
N 120 24950 120 24960 {
lab=GND}
N 80 24910 120 24910 {
lab=word415}
N 120 24910 160 24910 {
lab=word415}
N 90 24900 90 24950 {
lab=GND}
N 90 24950 90 24960 {
lab=GND}
N 150 24900 150 24950 {
lab=Y1}
N 150 24950 150 24960 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 24930 1 0 {name=M1812
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 24960 200 24960 {
lab=GND}
N 200 24950 200 24960 {
lab=GND}
N 160 24910 200 24910 {
lab=word415}
N 200 24910 240 24910 {
lab=word415}
N 170 24900 170 24950 {
lab=GND}
N 170 24950 170 24960 {
lab=GND}
N 230 24900 230 24950 {
lab=Y2}
N 230 24950 230 24960 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 24930 1 0 {name=M1813
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 24960 280 24960 {
lab=GND}
N 280 24950 280 24960 {
lab=GND}
N 240 24910 280 24910 {
lab=word415}
N 280 24910 320 24910 {
lab=word415}
N 250 24900 250 24950 {
lab=GND}
N 250 24950 250 24960 {
lab=GND}
N 310 24900 310 24950 {
lab=Y3}
N 310 24950 310 24960 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 24930 1 0 {name=M1814
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 24960 360 24960 {
lab=GND}
N 360 24950 360 24960 {
lab=GND}
N 320 24910 360 24910 {
lab=word415}
N 360 24910 400 24910 {
lab=word415}
N 330 24900 330 24950 {
lab=GND}
N 330 24950 330 24960 {
lab=GND}
N 390 24900 390 24950 {
lab=Y4}
N 390 24950 390 24960 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 24930 1 0 {name=M1815
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 24910 440 24910 {
lab=word415}
N 440 24910 480 24910 {
lab=word415}
N 410 24900 410 24950 {
lab=GND}
N 410 24950 410 24960 {
lab=GND}
N 470 24900 470 24950 {
lab=Y5}
N 470 24950 470 24960 {
lab=Y5}
N 480 24910 520 24910 {
lab=word415}
N 520 24910 560 24910 {
lab=word415}
N 490 24900 490 24950 {
lab=GND}
N 490 24950 490 24960 {
lab=GND}
N 550 24900 550 24950 {
lab=Y6}
N 550 24950 550 24960 {
lab=Y6}

N 570 24960 600 24960 {
lab=GND}
N 600 24950 600 24960 {
lab=GND}
N 560 24910 600 24910 {
lab=word415}
N 600 24910 640 24910 {
lab=word415}
N 570 24900 570 24950 {
lab=GND}
N 570 24950 570 24960 {
lab=GND}
N 630 24900 630 24950 {
lab=Y7}
N 630 24950 630 24960 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 24930 1 0 {name=M1816
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 24970 0 0 {name=p439 lab=word416}

N 10 25020 40 25020 {
lab=GND}
N 40 25010 40 25020 {
lab=GND}
N 0 24970 40 24970 {
lab=word416}
N 40 24970 80 24970 {
lab=word416}
N 10 24960 10 25010 {
lab=GND}
N 10 25010 10 25020 {
lab=GND}
N 70 24960 70 25010 {
lab=Y0}
N 70 25010 70 25020 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 24990 1 0 {name=M1817
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 24970 120 24970 {
lab=word416}
N 120 24970 160 24970 {
lab=word416}
N 90 24960 90 25010 {
lab=GND}
N 90 25010 90 25020 {
lab=GND}
N 150 24960 150 25010 {
lab=Y1}
N 150 25010 150 25020 {
lab=Y1}
N 160 24970 200 24970 {
lab=word416}
N 200 24970 240 24970 {
lab=word416}
N 170 24960 170 25010 {
lab=GND}
N 170 25010 170 25020 {
lab=GND}
N 230 24960 230 25010 {
lab=Y2}
N 230 25010 230 25020 {
lab=Y2}
N 240 24970 280 24970 {
lab=word416}
N 280 24970 320 24970 {
lab=word416}
N 250 24960 250 25010 {
lab=GND}
N 250 25010 250 25020 {
lab=GND}
N 310 24960 310 25010 {
lab=Y3}
N 310 25010 310 25020 {
lab=Y3}
N 320 24970 360 24970 {
lab=word416}
N 360 24970 400 24970 {
lab=word416}
N 330 24960 330 25010 {
lab=GND}
N 330 25010 330 25020 {
lab=GND}
N 390 24960 390 25010 {
lab=Y4}
N 390 25010 390 25020 {
lab=Y4}
N 400 24970 440 24970 {
lab=word416}
N 440 24970 480 24970 {
lab=word416}
N 410 24960 410 25010 {
lab=GND}
N 410 25010 410 25020 {
lab=GND}
N 470 24960 470 25010 {
lab=Y5}
N 470 25010 470 25020 {
lab=Y5}
N 480 24970 520 24970 {
lab=word416}
N 520 24970 560 24970 {
lab=word416}
N 490 24960 490 25010 {
lab=GND}
N 490 25010 490 25020 {
lab=GND}
N 550 24960 550 25010 {
lab=Y6}
N 550 25010 550 25020 {
lab=Y6}
N 560 24970 600 24970 {
lab=word416}
N 600 24970 640 24970 {
lab=word416}
N 570 24960 570 25010 {
lab=GND}
N 570 25010 570 25020 {
lab=GND}
N 630 24960 630 25010 {
lab=Y7}
N 630 25010 630 25020 {
lab=Y7}
C {devices/ipin.sym} 0 25030 0 0 {name=p440 lab=word417}

N 10 25080 40 25080 {
lab=GND}
N 40 25070 40 25080 {
lab=GND}
N 0 25030 40 25030 {
lab=word417}
N 40 25030 80 25030 {
lab=word417}
N 10 25020 10 25070 {
lab=GND}
N 10 25070 10 25080 {
lab=GND}
N 70 25020 70 25070 {
lab=Y0}
N 70 25070 70 25080 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25050 1 0 {name=M1818
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 25030 120 25030 {
lab=word417}
N 120 25030 160 25030 {
lab=word417}
N 90 25020 90 25070 {
lab=GND}
N 90 25070 90 25080 {
lab=GND}
N 150 25020 150 25070 {
lab=Y1}
N 150 25070 150 25080 {
lab=Y1}
N 160 25030 200 25030 {
lab=word417}
N 200 25030 240 25030 {
lab=word417}
N 170 25020 170 25070 {
lab=GND}
N 170 25070 170 25080 {
lab=GND}
N 230 25020 230 25070 {
lab=Y2}
N 230 25070 230 25080 {
lab=Y2}
N 240 25030 280 25030 {
lab=word417}
N 280 25030 320 25030 {
lab=word417}
N 250 25020 250 25070 {
lab=GND}
N 250 25070 250 25080 {
lab=GND}
N 310 25020 310 25070 {
lab=Y3}
N 310 25070 310 25080 {
lab=Y3}
N 320 25030 360 25030 {
lab=word417}
N 360 25030 400 25030 {
lab=word417}
N 330 25020 330 25070 {
lab=GND}
N 330 25070 330 25080 {
lab=GND}
N 390 25020 390 25070 {
lab=Y4}
N 390 25070 390 25080 {
lab=Y4}

N 410 25080 440 25080 {
lab=GND}
N 440 25070 440 25080 {
lab=GND}
N 400 25030 440 25030 {
lab=word417}
N 440 25030 480 25030 {
lab=word417}
N 410 25020 410 25070 {
lab=GND}
N 410 25070 410 25080 {
lab=GND}
N 470 25020 470 25070 {
lab=Y5}
N 470 25070 470 25080 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 25050 1 0 {name=M1819
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 25080 520 25080 {
lab=GND}
N 520 25070 520 25080 {
lab=GND}
N 480 25030 520 25030 {
lab=word417}
N 520 25030 560 25030 {
lab=word417}
N 490 25020 490 25070 {
lab=GND}
N 490 25070 490 25080 {
lab=GND}
N 550 25020 550 25070 {
lab=Y6}
N 550 25070 550 25080 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 25050 1 0 {name=M1820
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 25030 600 25030 {
lab=word417}
N 600 25030 640 25030 {
lab=word417}
N 570 25020 570 25070 {
lab=GND}
N 570 25070 570 25080 {
lab=GND}
N 630 25020 630 25070 {
lab=Y7}
N 630 25070 630 25080 {
lab=Y7}
C {devices/ipin.sym} 0 25090 0 0 {name=p441 lab=word418}

N 10 25140 40 25140 {
lab=GND}
N 40 25130 40 25140 {
lab=GND}
N 0 25090 40 25090 {
lab=word418}
N 40 25090 80 25090 {
lab=word418}
N 10 25080 10 25130 {
lab=GND}
N 10 25130 10 25140 {
lab=GND}
N 70 25080 70 25130 {
lab=Y0}
N 70 25130 70 25140 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25110 1 0 {name=M1821
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 25090 120 25090 {
lab=word418}
N 120 25090 160 25090 {
lab=word418}
N 90 25080 90 25130 {
lab=GND}
N 90 25130 90 25140 {
lab=GND}
N 150 25080 150 25130 {
lab=Y1}
N 150 25130 150 25140 {
lab=Y1}
N 160 25090 200 25090 {
lab=word418}
N 200 25090 240 25090 {
lab=word418}
N 170 25080 170 25130 {
lab=GND}
N 170 25130 170 25140 {
lab=GND}
N 230 25080 230 25130 {
lab=Y2}
N 230 25130 230 25140 {
lab=Y2}
N 240 25090 280 25090 {
lab=word418}
N 280 25090 320 25090 {
lab=word418}
N 250 25080 250 25130 {
lab=GND}
N 250 25130 250 25140 {
lab=GND}
N 310 25080 310 25130 {
lab=Y3}
N 310 25130 310 25140 {
lab=Y3}

N 330 25140 360 25140 {
lab=GND}
N 360 25130 360 25140 {
lab=GND}
N 320 25090 360 25090 {
lab=word418}
N 360 25090 400 25090 {
lab=word418}
N 330 25080 330 25130 {
lab=GND}
N 330 25130 330 25140 {
lab=GND}
N 390 25080 390 25130 {
lab=Y4}
N 390 25130 390 25140 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 25110 1 0 {name=M1822
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 25140 440 25140 {
lab=GND}
N 440 25130 440 25140 {
lab=GND}
N 400 25090 440 25090 {
lab=word418}
N 440 25090 480 25090 {
lab=word418}
N 410 25080 410 25130 {
lab=GND}
N 410 25130 410 25140 {
lab=GND}
N 470 25080 470 25130 {
lab=Y5}
N 470 25130 470 25140 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 25110 1 0 {name=M1823
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 25090 520 25090 {
lab=word418}
N 520 25090 560 25090 {
lab=word418}
N 490 25080 490 25130 {
lab=GND}
N 490 25130 490 25140 {
lab=GND}
N 550 25080 550 25130 {
lab=Y6}
N 550 25130 550 25140 {
lab=Y6}
N 560 25090 600 25090 {
lab=word418}
N 600 25090 640 25090 {
lab=word418}
N 570 25080 570 25130 {
lab=GND}
N 570 25130 570 25140 {
lab=GND}
N 630 25080 630 25130 {
lab=Y7}
N 630 25130 630 25140 {
lab=Y7}
C {devices/ipin.sym} 0 25150 0 0 {name=p442 lab=word419}

N 10 25200 40 25200 {
lab=GND}
N 40 25190 40 25200 {
lab=GND}
N 0 25150 40 25150 {
lab=word419}
N 40 25150 80 25150 {
lab=word419}
N 10 25140 10 25190 {
lab=GND}
N 10 25190 10 25200 {
lab=GND}
N 70 25140 70 25190 {
lab=Y0}
N 70 25190 70 25200 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25170 1 0 {name=M1824
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 25150 120 25150 {
lab=word419}
N 120 25150 160 25150 {
lab=word419}
N 90 25140 90 25190 {
lab=GND}
N 90 25190 90 25200 {
lab=GND}
N 150 25140 150 25190 {
lab=Y1}
N 150 25190 150 25200 {
lab=Y1}
N 160 25150 200 25150 {
lab=word419}
N 200 25150 240 25150 {
lab=word419}
N 170 25140 170 25190 {
lab=GND}
N 170 25190 170 25200 {
lab=GND}
N 230 25140 230 25190 {
lab=Y2}
N 230 25190 230 25200 {
lab=Y2}

N 250 25200 280 25200 {
lab=GND}
N 280 25190 280 25200 {
lab=GND}
N 240 25150 280 25150 {
lab=word419}
N 280 25150 320 25150 {
lab=word419}
N 250 25140 250 25190 {
lab=GND}
N 250 25190 250 25200 {
lab=GND}
N 310 25140 310 25190 {
lab=Y3}
N 310 25190 310 25200 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 25170 1 0 {name=M1825
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 25150 360 25150 {
lab=word419}
N 360 25150 400 25150 {
lab=word419}
N 330 25140 330 25190 {
lab=GND}
N 330 25190 330 25200 {
lab=GND}
N 390 25140 390 25190 {
lab=Y4}
N 390 25190 390 25200 {
lab=Y4}
N 400 25150 440 25150 {
lab=word419}
N 440 25150 480 25150 {
lab=word419}
N 410 25140 410 25190 {
lab=GND}
N 410 25190 410 25200 {
lab=GND}
N 470 25140 470 25190 {
lab=Y5}
N 470 25190 470 25200 {
lab=Y5}

N 490 25200 520 25200 {
lab=GND}
N 520 25190 520 25200 {
lab=GND}
N 480 25150 520 25150 {
lab=word419}
N 520 25150 560 25150 {
lab=word419}
N 490 25140 490 25190 {
lab=GND}
N 490 25190 490 25200 {
lab=GND}
N 550 25140 550 25190 {
lab=Y6}
N 550 25190 550 25200 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 25170 1 0 {name=M1826
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 25150 600 25150 {
lab=word419}
N 600 25150 640 25150 {
lab=word419}
N 570 25140 570 25190 {
lab=GND}
N 570 25190 570 25200 {
lab=GND}
N 630 25140 630 25190 {
lab=Y7}
N 630 25190 630 25200 {
lab=Y7}
C {devices/ipin.sym} 0 25210 0 0 {name=p443 lab=word420}

N 10 25260 40 25260 {
lab=GND}
N 40 25250 40 25260 {
lab=GND}
N 0 25210 40 25210 {
lab=word420}
N 40 25210 80 25210 {
lab=word420}
N 10 25200 10 25250 {
lab=GND}
N 10 25250 10 25260 {
lab=GND}
N 70 25200 70 25250 {
lab=Y0}
N 70 25250 70 25260 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25230 1 0 {name=M1827
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 25210 120 25210 {
lab=word420}
N 120 25210 160 25210 {
lab=word420}
N 90 25200 90 25250 {
lab=GND}
N 90 25250 90 25260 {
lab=GND}
N 150 25200 150 25250 {
lab=Y1}
N 150 25250 150 25260 {
lab=Y1}
N 160 25210 200 25210 {
lab=word420}
N 200 25210 240 25210 {
lab=word420}
N 170 25200 170 25250 {
lab=GND}
N 170 25250 170 25260 {
lab=GND}
N 230 25200 230 25250 {
lab=Y2}
N 230 25250 230 25260 {
lab=Y2}

N 250 25260 280 25260 {
lab=GND}
N 280 25250 280 25260 {
lab=GND}
N 240 25210 280 25210 {
lab=word420}
N 280 25210 320 25210 {
lab=word420}
N 250 25200 250 25250 {
lab=GND}
N 250 25250 250 25260 {
lab=GND}
N 310 25200 310 25250 {
lab=Y3}
N 310 25250 310 25260 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 25230 1 0 {name=M1828
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 25260 360 25260 {
lab=GND}
N 360 25250 360 25260 {
lab=GND}
N 320 25210 360 25210 {
lab=word420}
N 360 25210 400 25210 {
lab=word420}
N 330 25200 330 25250 {
lab=GND}
N 330 25250 330 25260 {
lab=GND}
N 390 25200 390 25250 {
lab=Y4}
N 390 25250 390 25260 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 25230 1 0 {name=M1829
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 25210 440 25210 {
lab=word420}
N 440 25210 480 25210 {
lab=word420}
N 410 25200 410 25250 {
lab=GND}
N 410 25250 410 25260 {
lab=GND}
N 470 25200 470 25250 {
lab=Y5}
N 470 25250 470 25260 {
lab=Y5}
N 480 25210 520 25210 {
lab=word420}
N 520 25210 560 25210 {
lab=word420}
N 490 25200 490 25250 {
lab=GND}
N 490 25250 490 25260 {
lab=GND}
N 550 25200 550 25250 {
lab=Y6}
N 550 25250 550 25260 {
lab=Y6}
N 560 25210 600 25210 {
lab=word420}
N 600 25210 640 25210 {
lab=word420}
N 570 25200 570 25250 {
lab=GND}
N 570 25250 570 25260 {
lab=GND}
N 630 25200 630 25250 {
lab=Y7}
N 630 25250 630 25260 {
lab=Y7}
C {devices/ipin.sym} 0 25270 0 0 {name=p444 lab=word421}

N 10 25320 40 25320 {
lab=GND}
N 40 25310 40 25320 {
lab=GND}
N 0 25270 40 25270 {
lab=word421}
N 40 25270 80 25270 {
lab=word421}
N 10 25260 10 25310 {
lab=GND}
N 10 25310 10 25320 {
lab=GND}
N 70 25260 70 25310 {
lab=Y0}
N 70 25310 70 25320 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25290 1 0 {name=M1830
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 25270 120 25270 {
lab=word421}
N 120 25270 160 25270 {
lab=word421}
N 90 25260 90 25310 {
lab=GND}
N 90 25310 90 25320 {
lab=GND}
N 150 25260 150 25310 {
lab=Y1}
N 150 25310 150 25320 {
lab=Y1}
N 160 25270 200 25270 {
lab=word421}
N 200 25270 240 25270 {
lab=word421}
N 170 25260 170 25310 {
lab=GND}
N 170 25310 170 25320 {
lab=GND}
N 230 25260 230 25310 {
lab=Y2}
N 230 25310 230 25320 {
lab=Y2}

N 250 25320 280 25320 {
lab=GND}
N 280 25310 280 25320 {
lab=GND}
N 240 25270 280 25270 {
lab=word421}
N 280 25270 320 25270 {
lab=word421}
N 250 25260 250 25310 {
lab=GND}
N 250 25310 250 25320 {
lab=GND}
N 310 25260 310 25310 {
lab=Y3}
N 310 25310 310 25320 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 25290 1 0 {name=M1831
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 25320 360 25320 {
lab=GND}
N 360 25310 360 25320 {
lab=GND}
N 320 25270 360 25270 {
lab=word421}
N 360 25270 400 25270 {
lab=word421}
N 330 25260 330 25310 {
lab=GND}
N 330 25310 330 25320 {
lab=GND}
N 390 25260 390 25310 {
lab=Y4}
N 390 25310 390 25320 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 25290 1 0 {name=M1832
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 25320 440 25320 {
lab=GND}
N 440 25310 440 25320 {
lab=GND}
N 400 25270 440 25270 {
lab=word421}
N 440 25270 480 25270 {
lab=word421}
N 410 25260 410 25310 {
lab=GND}
N 410 25310 410 25320 {
lab=GND}
N 470 25260 470 25310 {
lab=Y5}
N 470 25310 470 25320 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 25290 1 0 {name=M1833
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 25320 520 25320 {
lab=GND}
N 520 25310 520 25320 {
lab=GND}
N 480 25270 520 25270 {
lab=word421}
N 520 25270 560 25270 {
lab=word421}
N 490 25260 490 25310 {
lab=GND}
N 490 25310 490 25320 {
lab=GND}
N 550 25260 550 25310 {
lab=Y6}
N 550 25310 550 25320 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 25290 1 0 {name=M1834
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 25270 600 25270 {
lab=word421}
N 600 25270 640 25270 {
lab=word421}
N 570 25260 570 25310 {
lab=GND}
N 570 25310 570 25320 {
lab=GND}
N 630 25260 630 25310 {
lab=Y7}
N 630 25310 630 25320 {
lab=Y7}
C {devices/ipin.sym} 0 25330 0 0 {name=p445 lab=word422}

N 10 25380 40 25380 {
lab=GND}
N 40 25370 40 25380 {
lab=GND}
N 0 25330 40 25330 {
lab=word422}
N 40 25330 80 25330 {
lab=word422}
N 10 25320 10 25370 {
lab=GND}
N 10 25370 10 25380 {
lab=GND}
N 70 25320 70 25370 {
lab=Y0}
N 70 25370 70 25380 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25350 1 0 {name=M1835
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 25330 120 25330 {
lab=word422}
N 120 25330 160 25330 {
lab=word422}
N 90 25320 90 25370 {
lab=GND}
N 90 25370 90 25380 {
lab=GND}
N 150 25320 150 25370 {
lab=Y1}
N 150 25370 150 25380 {
lab=Y1}

N 170 25380 200 25380 {
lab=GND}
N 200 25370 200 25380 {
lab=GND}
N 160 25330 200 25330 {
lab=word422}
N 200 25330 240 25330 {
lab=word422}
N 170 25320 170 25370 {
lab=GND}
N 170 25370 170 25380 {
lab=GND}
N 230 25320 230 25370 {
lab=Y2}
N 230 25370 230 25380 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 25350 1 0 {name=M1836
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 25330 280 25330 {
lab=word422}
N 280 25330 320 25330 {
lab=word422}
N 250 25320 250 25370 {
lab=GND}
N 250 25370 250 25380 {
lab=GND}
N 310 25320 310 25370 {
lab=Y3}
N 310 25370 310 25380 {
lab=Y3}
N 320 25330 360 25330 {
lab=word422}
N 360 25330 400 25330 {
lab=word422}
N 330 25320 330 25370 {
lab=GND}
N 330 25370 330 25380 {
lab=GND}
N 390 25320 390 25370 {
lab=Y4}
N 390 25370 390 25380 {
lab=Y4}

N 410 25380 440 25380 {
lab=GND}
N 440 25370 440 25380 {
lab=GND}
N 400 25330 440 25330 {
lab=word422}
N 440 25330 480 25330 {
lab=word422}
N 410 25320 410 25370 {
lab=GND}
N 410 25370 410 25380 {
lab=GND}
N 470 25320 470 25370 {
lab=Y5}
N 470 25370 470 25380 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 25350 1 0 {name=M1837
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 25330 520 25330 {
lab=word422}
N 520 25330 560 25330 {
lab=word422}
N 490 25320 490 25370 {
lab=GND}
N 490 25370 490 25380 {
lab=GND}
N 550 25320 550 25370 {
lab=Y6}
N 550 25370 550 25380 {
lab=Y6}

N 570 25380 600 25380 {
lab=GND}
N 600 25370 600 25380 {
lab=GND}
N 560 25330 600 25330 {
lab=word422}
N 600 25330 640 25330 {
lab=word422}
N 570 25320 570 25370 {
lab=GND}
N 570 25370 570 25380 {
lab=GND}
N 630 25320 630 25370 {
lab=Y7}
N 630 25370 630 25380 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 25350 1 0 {name=M1838
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 25390 0 0 {name=p446 lab=word423}

N 10 25440 40 25440 {
lab=GND}
N 40 25430 40 25440 {
lab=GND}
N 0 25390 40 25390 {
lab=word423}
N 40 25390 80 25390 {
lab=word423}
N 10 25380 10 25430 {
lab=GND}
N 10 25430 10 25440 {
lab=GND}
N 70 25380 70 25430 {
lab=Y0}
N 70 25430 70 25440 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25410 1 0 {name=M1839
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 25390 120 25390 {
lab=word423}
N 120 25390 160 25390 {
lab=word423}
N 90 25380 90 25430 {
lab=GND}
N 90 25430 90 25440 {
lab=GND}
N 150 25380 150 25430 {
lab=Y1}
N 150 25430 150 25440 {
lab=Y1}

N 170 25440 200 25440 {
lab=GND}
N 200 25430 200 25440 {
lab=GND}
N 160 25390 200 25390 {
lab=word423}
N 200 25390 240 25390 {
lab=word423}
N 170 25380 170 25430 {
lab=GND}
N 170 25430 170 25440 {
lab=GND}
N 230 25380 230 25430 {
lab=Y2}
N 230 25430 230 25440 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 25410 1 0 {name=M1840
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 25390 280 25390 {
lab=word423}
N 280 25390 320 25390 {
lab=word423}
N 250 25380 250 25430 {
lab=GND}
N 250 25430 250 25440 {
lab=GND}
N 310 25380 310 25430 {
lab=Y3}
N 310 25430 310 25440 {
lab=Y3}

N 330 25440 360 25440 {
lab=GND}
N 360 25430 360 25440 {
lab=GND}
N 320 25390 360 25390 {
lab=word423}
N 360 25390 400 25390 {
lab=word423}
N 330 25380 330 25430 {
lab=GND}
N 330 25430 330 25440 {
lab=GND}
N 390 25380 390 25430 {
lab=Y4}
N 390 25430 390 25440 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 25410 1 0 {name=M1841
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 25390 440 25390 {
lab=word423}
N 440 25390 480 25390 {
lab=word423}
N 410 25380 410 25430 {
lab=GND}
N 410 25430 410 25440 {
lab=GND}
N 470 25380 470 25430 {
lab=Y5}
N 470 25430 470 25440 {
lab=Y5}

N 490 25440 520 25440 {
lab=GND}
N 520 25430 520 25440 {
lab=GND}
N 480 25390 520 25390 {
lab=word423}
N 520 25390 560 25390 {
lab=word423}
N 490 25380 490 25430 {
lab=GND}
N 490 25430 490 25440 {
lab=GND}
N 550 25380 550 25430 {
lab=Y6}
N 550 25430 550 25440 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 25410 1 0 {name=M1842
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 25390 600 25390 {
lab=word423}
N 600 25390 640 25390 {
lab=word423}
N 570 25380 570 25430 {
lab=GND}
N 570 25430 570 25440 {
lab=GND}
N 630 25380 630 25430 {
lab=Y7}
N 630 25430 630 25440 {
lab=Y7}
C {devices/ipin.sym} 0 25450 0 0 {name=p447 lab=word424}

N 10 25500 40 25500 {
lab=GND}
N 40 25490 40 25500 {
lab=GND}
N 0 25450 40 25450 {
lab=word424}
N 40 25450 80 25450 {
lab=word424}
N 10 25440 10 25490 {
lab=GND}
N 10 25490 10 25500 {
lab=GND}
N 70 25440 70 25490 {
lab=Y0}
N 70 25490 70 25500 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25470 1 0 {name=M1843
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 25450 120 25450 {
lab=word424}
N 120 25450 160 25450 {
lab=word424}
N 90 25440 90 25490 {
lab=GND}
N 90 25490 90 25500 {
lab=GND}
N 150 25440 150 25490 {
lab=Y1}
N 150 25490 150 25500 {
lab=Y1}

N 170 25500 200 25500 {
lab=GND}
N 200 25490 200 25500 {
lab=GND}
N 160 25450 200 25450 {
lab=word424}
N 200 25450 240 25450 {
lab=word424}
N 170 25440 170 25490 {
lab=GND}
N 170 25490 170 25500 {
lab=GND}
N 230 25440 230 25490 {
lab=Y2}
N 230 25490 230 25500 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 25470 1 0 {name=M1844
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 25500 280 25500 {
lab=GND}
N 280 25490 280 25500 {
lab=GND}
N 240 25450 280 25450 {
lab=word424}
N 280 25450 320 25450 {
lab=word424}
N 250 25440 250 25490 {
lab=GND}
N 250 25490 250 25500 {
lab=GND}
N 310 25440 310 25490 {
lab=Y3}
N 310 25490 310 25500 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 25470 1 0 {name=M1845
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 25450 360 25450 {
lab=word424}
N 360 25450 400 25450 {
lab=word424}
N 330 25440 330 25490 {
lab=GND}
N 330 25490 330 25500 {
lab=GND}
N 390 25440 390 25490 {
lab=Y4}
N 390 25490 390 25500 {
lab=Y4}
N 400 25450 440 25450 {
lab=word424}
N 440 25450 480 25450 {
lab=word424}
N 410 25440 410 25490 {
lab=GND}
N 410 25490 410 25500 {
lab=GND}
N 470 25440 470 25490 {
lab=Y5}
N 470 25490 470 25500 {
lab=Y5}
N 480 25450 520 25450 {
lab=word424}
N 520 25450 560 25450 {
lab=word424}
N 490 25440 490 25490 {
lab=GND}
N 490 25490 490 25500 {
lab=GND}
N 550 25440 550 25490 {
lab=Y6}
N 550 25490 550 25500 {
lab=Y6}
N 560 25450 600 25450 {
lab=word424}
N 600 25450 640 25450 {
lab=word424}
N 570 25440 570 25490 {
lab=GND}
N 570 25490 570 25500 {
lab=GND}
N 630 25440 630 25490 {
lab=Y7}
N 630 25490 630 25500 {
lab=Y7}
C {devices/ipin.sym} 0 25510 0 0 {name=p448 lab=word425}

N 10 25560 40 25560 {
lab=GND}
N 40 25550 40 25560 {
lab=GND}
N 0 25510 40 25510 {
lab=word425}
N 40 25510 80 25510 {
lab=word425}
N 10 25500 10 25550 {
lab=GND}
N 10 25550 10 25560 {
lab=GND}
N 70 25500 70 25550 {
lab=Y0}
N 70 25550 70 25560 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25530 1 0 {name=M1846
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 25510 120 25510 {
lab=word425}
N 120 25510 160 25510 {
lab=word425}
N 90 25500 90 25550 {
lab=GND}
N 90 25550 90 25560 {
lab=GND}
N 150 25500 150 25550 {
lab=Y1}
N 150 25550 150 25560 {
lab=Y1}

N 170 25560 200 25560 {
lab=GND}
N 200 25550 200 25560 {
lab=GND}
N 160 25510 200 25510 {
lab=word425}
N 200 25510 240 25510 {
lab=word425}
N 170 25500 170 25550 {
lab=GND}
N 170 25550 170 25560 {
lab=GND}
N 230 25500 230 25550 {
lab=Y2}
N 230 25550 230 25560 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 25530 1 0 {name=M1847
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 25560 280 25560 {
lab=GND}
N 280 25550 280 25560 {
lab=GND}
N 240 25510 280 25510 {
lab=word425}
N 280 25510 320 25510 {
lab=word425}
N 250 25500 250 25550 {
lab=GND}
N 250 25550 250 25560 {
lab=GND}
N 310 25500 310 25550 {
lab=Y3}
N 310 25550 310 25560 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 25530 1 0 {name=M1848
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 25510 360 25510 {
lab=word425}
N 360 25510 400 25510 {
lab=word425}
N 330 25500 330 25550 {
lab=GND}
N 330 25550 330 25560 {
lab=GND}
N 390 25500 390 25550 {
lab=Y4}
N 390 25550 390 25560 {
lab=Y4}

N 410 25560 440 25560 {
lab=GND}
N 440 25550 440 25560 {
lab=GND}
N 400 25510 440 25510 {
lab=word425}
N 440 25510 480 25510 {
lab=word425}
N 410 25500 410 25550 {
lab=GND}
N 410 25550 410 25560 {
lab=GND}
N 470 25500 470 25550 {
lab=Y5}
N 470 25550 470 25560 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 25530 1 0 {name=M1849
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 25560 520 25560 {
lab=GND}
N 520 25550 520 25560 {
lab=GND}
N 480 25510 520 25510 {
lab=word425}
N 520 25510 560 25510 {
lab=word425}
N 490 25500 490 25550 {
lab=GND}
N 490 25550 490 25560 {
lab=GND}
N 550 25500 550 25550 {
lab=Y6}
N 550 25550 550 25560 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 25530 1 0 {name=M1850
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 25510 600 25510 {
lab=word425}
N 600 25510 640 25510 {
lab=word425}
N 570 25500 570 25550 {
lab=GND}
N 570 25550 570 25560 {
lab=GND}
N 630 25500 630 25550 {
lab=Y7}
N 630 25550 630 25560 {
lab=Y7}
C {devices/ipin.sym} 0 25570 0 0 {name=p449 lab=word426}

N 10 25620 40 25620 {
lab=GND}
N 40 25610 40 25620 {
lab=GND}
N 0 25570 40 25570 {
lab=word426}
N 40 25570 80 25570 {
lab=word426}
N 10 25560 10 25610 {
lab=GND}
N 10 25610 10 25620 {
lab=GND}
N 70 25560 70 25610 {
lab=Y0}
N 70 25610 70 25620 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25590 1 0 {name=M1851
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 25570 120 25570 {
lab=word426}
N 120 25570 160 25570 {
lab=word426}
N 90 25560 90 25610 {
lab=GND}
N 90 25610 90 25620 {
lab=GND}
N 150 25560 150 25610 {
lab=Y1}
N 150 25610 150 25620 {
lab=Y1}

N 170 25620 200 25620 {
lab=GND}
N 200 25610 200 25620 {
lab=GND}
N 160 25570 200 25570 {
lab=word426}
N 200 25570 240 25570 {
lab=word426}
N 170 25560 170 25610 {
lab=GND}
N 170 25610 170 25620 {
lab=GND}
N 230 25560 230 25610 {
lab=Y2}
N 230 25610 230 25620 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 25590 1 0 {name=M1852
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 25620 280 25620 {
lab=GND}
N 280 25610 280 25620 {
lab=GND}
N 240 25570 280 25570 {
lab=word426}
N 280 25570 320 25570 {
lab=word426}
N 250 25560 250 25610 {
lab=GND}
N 250 25610 250 25620 {
lab=GND}
N 310 25560 310 25610 {
lab=Y3}
N 310 25610 310 25620 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 25590 1 0 {name=M1853
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 25620 360 25620 {
lab=GND}
N 360 25610 360 25620 {
lab=GND}
N 320 25570 360 25570 {
lab=word426}
N 360 25570 400 25570 {
lab=word426}
N 330 25560 330 25610 {
lab=GND}
N 330 25610 330 25620 {
lab=GND}
N 390 25560 390 25610 {
lab=Y4}
N 390 25610 390 25620 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 25590 1 0 {name=M1854
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 25620 440 25620 {
lab=GND}
N 440 25610 440 25620 {
lab=GND}
N 400 25570 440 25570 {
lab=word426}
N 440 25570 480 25570 {
lab=word426}
N 410 25560 410 25610 {
lab=GND}
N 410 25610 410 25620 {
lab=GND}
N 470 25560 470 25610 {
lab=Y5}
N 470 25610 470 25620 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 25590 1 0 {name=M1855
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 25570 520 25570 {
lab=word426}
N 520 25570 560 25570 {
lab=word426}
N 490 25560 490 25610 {
lab=GND}
N 490 25610 490 25620 {
lab=GND}
N 550 25560 550 25610 {
lab=Y6}
N 550 25610 550 25620 {
lab=Y6}
N 560 25570 600 25570 {
lab=word426}
N 600 25570 640 25570 {
lab=word426}
N 570 25560 570 25610 {
lab=GND}
N 570 25610 570 25620 {
lab=GND}
N 630 25560 630 25610 {
lab=Y7}
N 630 25610 630 25620 {
lab=Y7}
C {devices/ipin.sym} 0 25630 0 0 {name=p450 lab=word427}

N 10 25680 40 25680 {
lab=GND}
N 40 25670 40 25680 {
lab=GND}
N 0 25630 40 25630 {
lab=word427}
N 40 25630 80 25630 {
lab=word427}
N 10 25620 10 25670 {
lab=GND}
N 10 25670 10 25680 {
lab=GND}
N 70 25620 70 25670 {
lab=Y0}
N 70 25670 70 25680 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25650 1 0 {name=M1856
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 25680 120 25680 {
lab=GND}
N 120 25670 120 25680 {
lab=GND}
N 80 25630 120 25630 {
lab=word427}
N 120 25630 160 25630 {
lab=word427}
N 90 25620 90 25670 {
lab=GND}
N 90 25670 90 25680 {
lab=GND}
N 150 25620 150 25670 {
lab=Y1}
N 150 25670 150 25680 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 25650 1 0 {name=M1857
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 25630 200 25630 {
lab=word427}
N 200 25630 240 25630 {
lab=word427}
N 170 25620 170 25670 {
lab=GND}
N 170 25670 170 25680 {
lab=GND}
N 230 25620 230 25670 {
lab=Y2}
N 230 25670 230 25680 {
lab=Y2}
N 240 25630 280 25630 {
lab=word427}
N 280 25630 320 25630 {
lab=word427}
N 250 25620 250 25670 {
lab=GND}
N 250 25670 250 25680 {
lab=GND}
N 310 25620 310 25670 {
lab=Y3}
N 310 25670 310 25680 {
lab=Y3}
N 320 25630 360 25630 {
lab=word427}
N 360 25630 400 25630 {
lab=word427}
N 330 25620 330 25670 {
lab=GND}
N 330 25670 330 25680 {
lab=GND}
N 390 25620 390 25670 {
lab=Y4}
N 390 25670 390 25680 {
lab=Y4}
N 400 25630 440 25630 {
lab=word427}
N 440 25630 480 25630 {
lab=word427}
N 410 25620 410 25670 {
lab=GND}
N 410 25670 410 25680 {
lab=GND}
N 470 25620 470 25670 {
lab=Y5}
N 470 25670 470 25680 {
lab=Y5}
N 480 25630 520 25630 {
lab=word427}
N 520 25630 560 25630 {
lab=word427}
N 490 25620 490 25670 {
lab=GND}
N 490 25670 490 25680 {
lab=GND}
N 550 25620 550 25670 {
lab=Y6}
N 550 25670 550 25680 {
lab=Y6}

N 570 25680 600 25680 {
lab=GND}
N 600 25670 600 25680 {
lab=GND}
N 560 25630 600 25630 {
lab=word427}
N 600 25630 640 25630 {
lab=word427}
N 570 25620 570 25670 {
lab=GND}
N 570 25670 570 25680 {
lab=GND}
N 630 25620 630 25670 {
lab=Y7}
N 630 25670 630 25680 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 25650 1 0 {name=M1858
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 25690 0 0 {name=p451 lab=word428}

N 10 25740 40 25740 {
lab=GND}
N 40 25730 40 25740 {
lab=GND}
N 0 25690 40 25690 {
lab=word428}
N 40 25690 80 25690 {
lab=word428}
N 10 25680 10 25730 {
lab=GND}
N 10 25730 10 25740 {
lab=GND}
N 70 25680 70 25730 {
lab=Y0}
N 70 25730 70 25740 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25710 1 0 {name=M1859
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 25740 120 25740 {
lab=GND}
N 120 25730 120 25740 {
lab=GND}
N 80 25690 120 25690 {
lab=word428}
N 120 25690 160 25690 {
lab=word428}
N 90 25680 90 25730 {
lab=GND}
N 90 25730 90 25740 {
lab=GND}
N 150 25680 150 25730 {
lab=Y1}
N 150 25730 150 25740 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 25710 1 0 {name=M1860
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 25690 200 25690 {
lab=word428}
N 200 25690 240 25690 {
lab=word428}
N 170 25680 170 25730 {
lab=GND}
N 170 25730 170 25740 {
lab=GND}
N 230 25680 230 25730 {
lab=Y2}
N 230 25730 230 25740 {
lab=Y2}
N 240 25690 280 25690 {
lab=word428}
N 280 25690 320 25690 {
lab=word428}
N 250 25680 250 25730 {
lab=GND}
N 250 25730 250 25740 {
lab=GND}
N 310 25680 310 25730 {
lab=Y3}
N 310 25730 310 25740 {
lab=Y3}
N 320 25690 360 25690 {
lab=word428}
N 360 25690 400 25690 {
lab=word428}
N 330 25680 330 25730 {
lab=GND}
N 330 25730 330 25740 {
lab=GND}
N 390 25680 390 25730 {
lab=Y4}
N 390 25730 390 25740 {
lab=Y4}

N 410 25740 440 25740 {
lab=GND}
N 440 25730 440 25740 {
lab=GND}
N 400 25690 440 25690 {
lab=word428}
N 440 25690 480 25690 {
lab=word428}
N 410 25680 410 25730 {
lab=GND}
N 410 25730 410 25740 {
lab=GND}
N 470 25680 470 25730 {
lab=Y5}
N 470 25730 470 25740 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 25710 1 0 {name=M1861
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 25740 520 25740 {
lab=GND}
N 520 25730 520 25740 {
lab=GND}
N 480 25690 520 25690 {
lab=word428}
N 520 25690 560 25690 {
lab=word428}
N 490 25680 490 25730 {
lab=GND}
N 490 25730 490 25740 {
lab=GND}
N 550 25680 550 25730 {
lab=Y6}
N 550 25730 550 25740 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 25710 1 0 {name=M1862
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 25690 600 25690 {
lab=word428}
N 600 25690 640 25690 {
lab=word428}
N 570 25680 570 25730 {
lab=GND}
N 570 25730 570 25740 {
lab=GND}
N 630 25680 630 25730 {
lab=Y7}
N 630 25730 630 25740 {
lab=Y7}
C {devices/ipin.sym} 0 25750 0 0 {name=p452 lab=word429}

N 10 25800 40 25800 {
lab=GND}
N 40 25790 40 25800 {
lab=GND}
N 0 25750 40 25750 {
lab=word429}
N 40 25750 80 25750 {
lab=word429}
N 10 25740 10 25790 {
lab=GND}
N 10 25790 10 25800 {
lab=GND}
N 70 25740 70 25790 {
lab=Y0}
N 70 25790 70 25800 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25770 1 0 {name=M1863
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 25800 120 25800 {
lab=GND}
N 120 25790 120 25800 {
lab=GND}
N 80 25750 120 25750 {
lab=word429}
N 120 25750 160 25750 {
lab=word429}
N 90 25740 90 25790 {
lab=GND}
N 90 25790 90 25800 {
lab=GND}
N 150 25740 150 25790 {
lab=Y1}
N 150 25790 150 25800 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 25770 1 0 {name=M1864
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 25750 200 25750 {
lab=word429}
N 200 25750 240 25750 {
lab=word429}
N 170 25740 170 25790 {
lab=GND}
N 170 25790 170 25800 {
lab=GND}
N 230 25740 230 25790 {
lab=Y2}
N 230 25790 230 25800 {
lab=Y2}
N 240 25750 280 25750 {
lab=word429}
N 280 25750 320 25750 {
lab=word429}
N 250 25740 250 25790 {
lab=GND}
N 250 25790 250 25800 {
lab=GND}
N 310 25740 310 25790 {
lab=Y3}
N 310 25790 310 25800 {
lab=Y3}

N 330 25800 360 25800 {
lab=GND}
N 360 25790 360 25800 {
lab=GND}
N 320 25750 360 25750 {
lab=word429}
N 360 25750 400 25750 {
lab=word429}
N 330 25740 330 25790 {
lab=GND}
N 330 25790 330 25800 {
lab=GND}
N 390 25740 390 25790 {
lab=Y4}
N 390 25790 390 25800 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 25770 1 0 {name=M1865
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 25750 440 25750 {
lab=word429}
N 440 25750 480 25750 {
lab=word429}
N 410 25740 410 25790 {
lab=GND}
N 410 25790 410 25800 {
lab=GND}
N 470 25740 470 25790 {
lab=Y5}
N 470 25790 470 25800 {
lab=Y5}

N 490 25800 520 25800 {
lab=GND}
N 520 25790 520 25800 {
lab=GND}
N 480 25750 520 25750 {
lab=word429}
N 520 25750 560 25750 {
lab=word429}
N 490 25740 490 25790 {
lab=GND}
N 490 25790 490 25800 {
lab=GND}
N 550 25740 550 25790 {
lab=Y6}
N 550 25790 550 25800 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 25770 1 0 {name=M1866
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 25800 600 25800 {
lab=GND}
N 600 25790 600 25800 {
lab=GND}
N 560 25750 600 25750 {
lab=word429}
N 600 25750 640 25750 {
lab=word429}
N 570 25740 570 25790 {
lab=GND}
N 570 25790 570 25800 {
lab=GND}
N 630 25740 630 25790 {
lab=Y7}
N 630 25790 630 25800 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 25770 1 0 {name=M1867
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 25810 0 0 {name=p453 lab=word430}

N 10 25860 40 25860 {
lab=GND}
N 40 25850 40 25860 {
lab=GND}
N 0 25810 40 25810 {
lab=word430}
N 40 25810 80 25810 {
lab=word430}
N 10 25800 10 25850 {
lab=GND}
N 10 25850 10 25860 {
lab=GND}
N 70 25800 70 25850 {
lab=Y0}
N 70 25850 70 25860 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25830 1 0 {name=M1868
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 25860 120 25860 {
lab=GND}
N 120 25850 120 25860 {
lab=GND}
N 80 25810 120 25810 {
lab=word430}
N 120 25810 160 25810 {
lab=word430}
N 90 25800 90 25850 {
lab=GND}
N 90 25850 90 25860 {
lab=GND}
N 150 25800 150 25850 {
lab=Y1}
N 150 25850 150 25860 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 25830 1 0 {name=M1869
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 25810 200 25810 {
lab=word430}
N 200 25810 240 25810 {
lab=word430}
N 170 25800 170 25850 {
lab=GND}
N 170 25850 170 25860 {
lab=GND}
N 230 25800 230 25850 {
lab=Y2}
N 230 25850 230 25860 {
lab=Y2}

N 250 25860 280 25860 {
lab=GND}
N 280 25850 280 25860 {
lab=GND}
N 240 25810 280 25810 {
lab=word430}
N 280 25810 320 25810 {
lab=word430}
N 250 25800 250 25850 {
lab=GND}
N 250 25850 250 25860 {
lab=GND}
N 310 25800 310 25850 {
lab=Y3}
N 310 25850 310 25860 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 25830 1 0 {name=M1870
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 25810 360 25810 {
lab=word430}
N 360 25810 400 25810 {
lab=word430}
N 330 25800 330 25850 {
lab=GND}
N 330 25850 330 25860 {
lab=GND}
N 390 25800 390 25850 {
lab=Y4}
N 390 25850 390 25860 {
lab=Y4}
N 400 25810 440 25810 {
lab=word430}
N 440 25810 480 25810 {
lab=word430}
N 410 25800 410 25850 {
lab=GND}
N 410 25850 410 25860 {
lab=GND}
N 470 25800 470 25850 {
lab=Y5}
N 470 25850 470 25860 {
lab=Y5}
N 480 25810 520 25810 {
lab=word430}
N 520 25810 560 25810 {
lab=word430}
N 490 25800 490 25850 {
lab=GND}
N 490 25850 490 25860 {
lab=GND}
N 550 25800 550 25850 {
lab=Y6}
N 550 25850 550 25860 {
lab=Y6}
N 560 25810 600 25810 {
lab=word430}
N 600 25810 640 25810 {
lab=word430}
N 570 25800 570 25850 {
lab=GND}
N 570 25850 570 25860 {
lab=GND}
N 630 25800 630 25850 {
lab=Y7}
N 630 25850 630 25860 {
lab=Y7}
C {devices/ipin.sym} 0 25870 0 0 {name=p454 lab=word431}

N 10 25920 40 25920 {
lab=GND}
N 40 25910 40 25920 {
lab=GND}
N 0 25870 40 25870 {
lab=word431}
N 40 25870 80 25870 {
lab=word431}
N 10 25860 10 25910 {
lab=GND}
N 10 25910 10 25920 {
lab=GND}
N 70 25860 70 25910 {
lab=Y0}
N 70 25910 70 25920 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25890 1 0 {name=M1871
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 25920 120 25920 {
lab=GND}
N 120 25910 120 25920 {
lab=GND}
N 80 25870 120 25870 {
lab=word431}
N 120 25870 160 25870 {
lab=word431}
N 90 25860 90 25910 {
lab=GND}
N 90 25910 90 25920 {
lab=GND}
N 150 25860 150 25910 {
lab=Y1}
N 150 25910 150 25920 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 25890 1 0 {name=M1872
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 25870 200 25870 {
lab=word431}
N 200 25870 240 25870 {
lab=word431}
N 170 25860 170 25910 {
lab=GND}
N 170 25910 170 25920 {
lab=GND}
N 230 25860 230 25910 {
lab=Y2}
N 230 25910 230 25920 {
lab=Y2}

N 250 25920 280 25920 {
lab=GND}
N 280 25910 280 25920 {
lab=GND}
N 240 25870 280 25870 {
lab=word431}
N 280 25870 320 25870 {
lab=word431}
N 250 25860 250 25910 {
lab=GND}
N 250 25910 250 25920 {
lab=GND}
N 310 25860 310 25910 {
lab=Y3}
N 310 25910 310 25920 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 25890 1 0 {name=M1873
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 25870 360 25870 {
lab=word431}
N 360 25870 400 25870 {
lab=word431}
N 330 25860 330 25910 {
lab=GND}
N 330 25910 330 25920 {
lab=GND}
N 390 25860 390 25910 {
lab=Y4}
N 390 25910 390 25920 {
lab=Y4}

N 410 25920 440 25920 {
lab=GND}
N 440 25910 440 25920 {
lab=GND}
N 400 25870 440 25870 {
lab=word431}
N 440 25870 480 25870 {
lab=word431}
N 410 25860 410 25910 {
lab=GND}
N 410 25910 410 25920 {
lab=GND}
N 470 25860 470 25910 {
lab=Y5}
N 470 25910 470 25920 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 25890 1 0 {name=M1874
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 25870 520 25870 {
lab=word431}
N 520 25870 560 25870 {
lab=word431}
N 490 25860 490 25910 {
lab=GND}
N 490 25910 490 25920 {
lab=GND}
N 550 25860 550 25910 {
lab=Y6}
N 550 25910 550 25920 {
lab=Y6}

N 570 25920 600 25920 {
lab=GND}
N 600 25910 600 25920 {
lab=GND}
N 560 25870 600 25870 {
lab=word431}
N 600 25870 640 25870 {
lab=word431}
N 570 25860 570 25910 {
lab=GND}
N 570 25910 570 25920 {
lab=GND}
N 630 25860 630 25910 {
lab=Y7}
N 630 25910 630 25920 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 25890 1 0 {name=M1875
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 25930 0 0 {name=p455 lab=word432}

N 10 25980 40 25980 {
lab=GND}
N 40 25970 40 25980 {
lab=GND}
N 0 25930 40 25930 {
lab=word432}
N 40 25930 80 25930 {
lab=word432}
N 10 25920 10 25970 {
lab=GND}
N 10 25970 10 25980 {
lab=GND}
N 70 25920 70 25970 {
lab=Y0}
N 70 25970 70 25980 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 25950 1 0 {name=M1876
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 25980 120 25980 {
lab=GND}
N 120 25970 120 25980 {
lab=GND}
N 80 25930 120 25930 {
lab=word432}
N 120 25930 160 25930 {
lab=word432}
N 90 25920 90 25970 {
lab=GND}
N 90 25970 90 25980 {
lab=GND}
N 150 25920 150 25970 {
lab=Y1}
N 150 25970 150 25980 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 25950 1 0 {name=M1877
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 25930 200 25930 {
lab=word432}
N 200 25930 240 25930 {
lab=word432}
N 170 25920 170 25970 {
lab=GND}
N 170 25970 170 25980 {
lab=GND}
N 230 25920 230 25970 {
lab=Y2}
N 230 25970 230 25980 {
lab=Y2}

N 250 25980 280 25980 {
lab=GND}
N 280 25970 280 25980 {
lab=GND}
N 240 25930 280 25930 {
lab=word432}
N 280 25930 320 25930 {
lab=word432}
N 250 25920 250 25970 {
lab=GND}
N 250 25970 250 25980 {
lab=GND}
N 310 25920 310 25970 {
lab=Y3}
N 310 25970 310 25980 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 25950 1 0 {name=M1878
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 25980 360 25980 {
lab=GND}
N 360 25970 360 25980 {
lab=GND}
N 320 25930 360 25930 {
lab=word432}
N 360 25930 400 25930 {
lab=word432}
N 330 25920 330 25970 {
lab=GND}
N 330 25970 330 25980 {
lab=GND}
N 390 25920 390 25970 {
lab=Y4}
N 390 25970 390 25980 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 25950 1 0 {name=M1879
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 25930 440 25930 {
lab=word432}
N 440 25930 480 25930 {
lab=word432}
N 410 25920 410 25970 {
lab=GND}
N 410 25970 410 25980 {
lab=GND}
N 470 25920 470 25970 {
lab=Y5}
N 470 25970 470 25980 {
lab=Y5}

N 490 25980 520 25980 {
lab=GND}
N 520 25970 520 25980 {
lab=GND}
N 480 25930 520 25930 {
lab=word432}
N 520 25930 560 25930 {
lab=word432}
N 490 25920 490 25970 {
lab=GND}
N 490 25970 490 25980 {
lab=GND}
N 550 25920 550 25970 {
lab=Y6}
N 550 25970 550 25980 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 25950 1 0 {name=M1880
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 25930 600 25930 {
lab=word432}
N 600 25930 640 25930 {
lab=word432}
N 570 25920 570 25970 {
lab=GND}
N 570 25970 570 25980 {
lab=GND}
N 630 25920 630 25970 {
lab=Y7}
N 630 25970 630 25980 {
lab=Y7}
C {devices/ipin.sym} 0 25990 0 0 {name=p456 lab=word433}

N 10 26040 40 26040 {
lab=GND}
N 40 26030 40 26040 {
lab=GND}
N 0 25990 40 25990 {
lab=word433}
N 40 25990 80 25990 {
lab=word433}
N 10 25980 10 26030 {
lab=GND}
N 10 26030 10 26040 {
lab=GND}
N 70 25980 70 26030 {
lab=Y0}
N 70 26030 70 26040 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26010 1 0 {name=M1881
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26040 120 26040 {
lab=GND}
N 120 26030 120 26040 {
lab=GND}
N 80 25990 120 25990 {
lab=word433}
N 120 25990 160 25990 {
lab=word433}
N 90 25980 90 26030 {
lab=GND}
N 90 26030 90 26040 {
lab=GND}
N 150 25980 150 26030 {
lab=Y1}
N 150 26030 150 26040 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26010 1 0 {name=M1882
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 25990 200 25990 {
lab=word433}
N 200 25990 240 25990 {
lab=word433}
N 170 25980 170 26030 {
lab=GND}
N 170 26030 170 26040 {
lab=GND}
N 230 25980 230 26030 {
lab=Y2}
N 230 26030 230 26040 {
lab=Y2}

N 250 26040 280 26040 {
lab=GND}
N 280 26030 280 26040 {
lab=GND}
N 240 25990 280 25990 {
lab=word433}
N 280 25990 320 25990 {
lab=word433}
N 250 25980 250 26030 {
lab=GND}
N 250 26030 250 26040 {
lab=GND}
N 310 25980 310 26030 {
lab=Y3}
N 310 26030 310 26040 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26010 1 0 {name=M1883
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 26040 360 26040 {
lab=GND}
N 360 26030 360 26040 {
lab=GND}
N 320 25990 360 25990 {
lab=word433}
N 360 25990 400 25990 {
lab=word433}
N 330 25980 330 26030 {
lab=GND}
N 330 26030 330 26040 {
lab=GND}
N 390 25980 390 26030 {
lab=Y4}
N 390 26030 390 26040 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 26010 1 0 {name=M1884
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 26040 440 26040 {
lab=GND}
N 440 26030 440 26040 {
lab=GND}
N 400 25990 440 25990 {
lab=word433}
N 440 25990 480 25990 {
lab=word433}
N 410 25980 410 26030 {
lab=GND}
N 410 26030 410 26040 {
lab=GND}
N 470 25980 470 26030 {
lab=Y5}
N 470 26030 470 26040 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 26010 1 0 {name=M1885
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 26040 520 26040 {
lab=GND}
N 520 26030 520 26040 {
lab=GND}
N 480 25990 520 25990 {
lab=word433}
N 520 25990 560 25990 {
lab=word433}
N 490 25980 490 26030 {
lab=GND}
N 490 26030 490 26040 {
lab=GND}
N 550 25980 550 26030 {
lab=Y6}
N 550 26030 550 26040 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 26010 1 0 {name=M1886
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 25990 600 25990 {
lab=word433}
N 600 25990 640 25990 {
lab=word433}
N 570 25980 570 26030 {
lab=GND}
N 570 26030 570 26040 {
lab=GND}
N 630 25980 630 26030 {
lab=Y7}
N 630 26030 630 26040 {
lab=Y7}
C {devices/ipin.sym} 0 26050 0 0 {name=p457 lab=word434}

N 10 26100 40 26100 {
lab=GND}
N 40 26090 40 26100 {
lab=GND}
N 0 26050 40 26050 {
lab=word434}
N 40 26050 80 26050 {
lab=word434}
N 10 26040 10 26090 {
lab=GND}
N 10 26090 10 26100 {
lab=GND}
N 70 26040 70 26090 {
lab=Y0}
N 70 26090 70 26100 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26070 1 0 {name=M1887
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26100 120 26100 {
lab=GND}
N 120 26090 120 26100 {
lab=GND}
N 80 26050 120 26050 {
lab=word434}
N 120 26050 160 26050 {
lab=word434}
N 90 26040 90 26090 {
lab=GND}
N 90 26090 90 26100 {
lab=GND}
N 150 26040 150 26090 {
lab=Y1}
N 150 26090 150 26100 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26070 1 0 {name=M1888
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26100 200 26100 {
lab=GND}
N 200 26090 200 26100 {
lab=GND}
N 160 26050 200 26050 {
lab=word434}
N 200 26050 240 26050 {
lab=word434}
N 170 26040 170 26090 {
lab=GND}
N 170 26090 170 26100 {
lab=GND}
N 230 26040 230 26090 {
lab=Y2}
N 230 26090 230 26100 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26070 1 0 {name=M1889
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 26050 280 26050 {
lab=word434}
N 280 26050 320 26050 {
lab=word434}
N 250 26040 250 26090 {
lab=GND}
N 250 26090 250 26100 {
lab=GND}
N 310 26040 310 26090 {
lab=Y3}
N 310 26090 310 26100 {
lab=Y3}
N 320 26050 360 26050 {
lab=word434}
N 360 26050 400 26050 {
lab=word434}
N 330 26040 330 26090 {
lab=GND}
N 330 26090 330 26100 {
lab=GND}
N 390 26040 390 26090 {
lab=Y4}
N 390 26090 390 26100 {
lab=Y4}
N 400 26050 440 26050 {
lab=word434}
N 440 26050 480 26050 {
lab=word434}
N 410 26040 410 26090 {
lab=GND}
N 410 26090 410 26100 {
lab=GND}
N 470 26040 470 26090 {
lab=Y5}
N 470 26090 470 26100 {
lab=Y5}

N 490 26100 520 26100 {
lab=GND}
N 520 26090 520 26100 {
lab=GND}
N 480 26050 520 26050 {
lab=word434}
N 520 26050 560 26050 {
lab=word434}
N 490 26040 490 26090 {
lab=GND}
N 490 26090 490 26100 {
lab=GND}
N 550 26040 550 26090 {
lab=Y6}
N 550 26090 550 26100 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 26070 1 0 {name=M1890
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 26050 600 26050 {
lab=word434}
N 600 26050 640 26050 {
lab=word434}
N 570 26040 570 26090 {
lab=GND}
N 570 26090 570 26100 {
lab=GND}
N 630 26040 630 26090 {
lab=Y7}
N 630 26090 630 26100 {
lab=Y7}
C {devices/ipin.sym} 0 26110 0 0 {name=p458 lab=word435}

N 10 26160 40 26160 {
lab=GND}
N 40 26150 40 26160 {
lab=GND}
N 0 26110 40 26110 {
lab=word435}
N 40 26110 80 26110 {
lab=word435}
N 10 26100 10 26150 {
lab=GND}
N 10 26150 10 26160 {
lab=GND}
N 70 26100 70 26150 {
lab=Y0}
N 70 26150 70 26160 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26130 1 0 {name=M1891
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26160 120 26160 {
lab=GND}
N 120 26150 120 26160 {
lab=GND}
N 80 26110 120 26110 {
lab=word435}
N 120 26110 160 26110 {
lab=word435}
N 90 26100 90 26150 {
lab=GND}
N 90 26150 90 26160 {
lab=GND}
N 150 26100 150 26150 {
lab=Y1}
N 150 26150 150 26160 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26130 1 0 {name=M1892
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26160 200 26160 {
lab=GND}
N 200 26150 200 26160 {
lab=GND}
N 160 26110 200 26110 {
lab=word435}
N 200 26110 240 26110 {
lab=word435}
N 170 26100 170 26150 {
lab=GND}
N 170 26150 170 26160 {
lab=GND}
N 230 26100 230 26150 {
lab=Y2}
N 230 26150 230 26160 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26130 1 0 {name=M1893
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 26110 280 26110 {
lab=word435}
N 280 26110 320 26110 {
lab=word435}
N 250 26100 250 26150 {
lab=GND}
N 250 26150 250 26160 {
lab=GND}
N 310 26100 310 26150 {
lab=Y3}
N 310 26150 310 26160 {
lab=Y3}
N 320 26110 360 26110 {
lab=word435}
N 360 26110 400 26110 {
lab=word435}
N 330 26100 330 26150 {
lab=GND}
N 330 26150 330 26160 {
lab=GND}
N 390 26100 390 26150 {
lab=Y4}
N 390 26150 390 26160 {
lab=Y4}

N 410 26160 440 26160 {
lab=GND}
N 440 26150 440 26160 {
lab=GND}
N 400 26110 440 26110 {
lab=word435}
N 440 26110 480 26110 {
lab=word435}
N 410 26100 410 26150 {
lab=GND}
N 410 26150 410 26160 {
lab=GND}
N 470 26100 470 26150 {
lab=Y5}
N 470 26150 470 26160 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 26130 1 0 {name=M1894
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 26160 520 26160 {
lab=GND}
N 520 26150 520 26160 {
lab=GND}
N 480 26110 520 26110 {
lab=word435}
N 520 26110 560 26110 {
lab=word435}
N 490 26100 490 26150 {
lab=GND}
N 490 26150 490 26160 {
lab=GND}
N 550 26100 550 26150 {
lab=Y6}
N 550 26150 550 26160 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 26130 1 0 {name=M1895
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 26110 600 26110 {
lab=word435}
N 600 26110 640 26110 {
lab=word435}
N 570 26100 570 26150 {
lab=GND}
N 570 26150 570 26160 {
lab=GND}
N 630 26100 630 26150 {
lab=Y7}
N 630 26150 630 26160 {
lab=Y7}
C {devices/ipin.sym} 0 26170 0 0 {name=p459 lab=word436}

N 10 26220 40 26220 {
lab=GND}
N 40 26210 40 26220 {
lab=GND}
N 0 26170 40 26170 {
lab=word436}
N 40 26170 80 26170 {
lab=word436}
N 10 26160 10 26210 {
lab=GND}
N 10 26210 10 26220 {
lab=GND}
N 70 26160 70 26210 {
lab=Y0}
N 70 26210 70 26220 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26190 1 0 {name=M1896
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26220 120 26220 {
lab=GND}
N 120 26210 120 26220 {
lab=GND}
N 80 26170 120 26170 {
lab=word436}
N 120 26170 160 26170 {
lab=word436}
N 90 26160 90 26210 {
lab=GND}
N 90 26210 90 26220 {
lab=GND}
N 150 26160 150 26210 {
lab=Y1}
N 150 26210 150 26220 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26190 1 0 {name=M1897
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26220 200 26220 {
lab=GND}
N 200 26210 200 26220 {
lab=GND}
N 160 26170 200 26170 {
lab=word436}
N 200 26170 240 26170 {
lab=word436}
N 170 26160 170 26210 {
lab=GND}
N 170 26210 170 26220 {
lab=GND}
N 230 26160 230 26210 {
lab=Y2}
N 230 26210 230 26220 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26190 1 0 {name=M1898
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 26170 280 26170 {
lab=word436}
N 280 26170 320 26170 {
lab=word436}
N 250 26160 250 26210 {
lab=GND}
N 250 26210 250 26220 {
lab=GND}
N 310 26160 310 26210 {
lab=Y3}
N 310 26210 310 26220 {
lab=Y3}

N 330 26220 360 26220 {
lab=GND}
N 360 26210 360 26220 {
lab=GND}
N 320 26170 360 26170 {
lab=word436}
N 360 26170 400 26170 {
lab=word436}
N 330 26160 330 26210 {
lab=GND}
N 330 26210 330 26220 {
lab=GND}
N 390 26160 390 26210 {
lab=Y4}
N 390 26210 390 26220 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 26190 1 0 {name=M1899
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 26170 440 26170 {
lab=word436}
N 440 26170 480 26170 {
lab=word436}
N 410 26160 410 26210 {
lab=GND}
N 410 26210 410 26220 {
lab=GND}
N 470 26160 470 26210 {
lab=Y5}
N 470 26210 470 26220 {
lab=Y5}

N 490 26220 520 26220 {
lab=GND}
N 520 26210 520 26220 {
lab=GND}
N 480 26170 520 26170 {
lab=word436}
N 520 26170 560 26170 {
lab=word436}
N 490 26160 490 26210 {
lab=GND}
N 490 26210 490 26220 {
lab=GND}
N 550 26160 550 26210 {
lab=Y6}
N 550 26210 550 26220 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 26190 1 0 {name=M1900
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 26170 600 26170 {
lab=word436}
N 600 26170 640 26170 {
lab=word436}
N 570 26160 570 26210 {
lab=GND}
N 570 26210 570 26220 {
lab=GND}
N 630 26160 630 26210 {
lab=Y7}
N 630 26210 630 26220 {
lab=Y7}
C {devices/ipin.sym} 0 26230 0 0 {name=p460 lab=word437}

N 10 26280 40 26280 {
lab=GND}
N 40 26270 40 26280 {
lab=GND}
N 0 26230 40 26230 {
lab=word437}
N 40 26230 80 26230 {
lab=word437}
N 10 26220 10 26270 {
lab=GND}
N 10 26270 10 26280 {
lab=GND}
N 70 26220 70 26270 {
lab=Y0}
N 70 26270 70 26280 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26250 1 0 {name=M1901
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26280 120 26280 {
lab=GND}
N 120 26270 120 26280 {
lab=GND}
N 80 26230 120 26230 {
lab=word437}
N 120 26230 160 26230 {
lab=word437}
N 90 26220 90 26270 {
lab=GND}
N 90 26270 90 26280 {
lab=GND}
N 150 26220 150 26270 {
lab=Y1}
N 150 26270 150 26280 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26250 1 0 {name=M1902
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26280 200 26280 {
lab=GND}
N 200 26270 200 26280 {
lab=GND}
N 160 26230 200 26230 {
lab=word437}
N 200 26230 240 26230 {
lab=word437}
N 170 26220 170 26270 {
lab=GND}
N 170 26270 170 26280 {
lab=GND}
N 230 26220 230 26270 {
lab=Y2}
N 230 26270 230 26280 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26250 1 0 {name=M1903
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 26230 280 26230 {
lab=word437}
N 280 26230 320 26230 {
lab=word437}
N 250 26220 250 26270 {
lab=GND}
N 250 26270 250 26280 {
lab=GND}
N 310 26220 310 26270 {
lab=Y3}
N 310 26270 310 26280 {
lab=Y3}

N 330 26280 360 26280 {
lab=GND}
N 360 26270 360 26280 {
lab=GND}
N 320 26230 360 26230 {
lab=word437}
N 360 26230 400 26230 {
lab=word437}
N 330 26220 330 26270 {
lab=GND}
N 330 26270 330 26280 {
lab=GND}
N 390 26220 390 26270 {
lab=Y4}
N 390 26270 390 26280 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 26250 1 0 {name=M1904
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 26280 440 26280 {
lab=GND}
N 440 26270 440 26280 {
lab=GND}
N 400 26230 440 26230 {
lab=word437}
N 440 26230 480 26230 {
lab=word437}
N 410 26220 410 26270 {
lab=GND}
N 410 26270 410 26280 {
lab=GND}
N 470 26220 470 26270 {
lab=Y5}
N 470 26270 470 26280 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 26250 1 0 {name=M1905
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 26230 520 26230 {
lab=word437}
N 520 26230 560 26230 {
lab=word437}
N 490 26220 490 26270 {
lab=GND}
N 490 26270 490 26280 {
lab=GND}
N 550 26220 550 26270 {
lab=Y6}
N 550 26270 550 26280 {
lab=Y6}

N 570 26280 600 26280 {
lab=GND}
N 600 26270 600 26280 {
lab=GND}
N 560 26230 600 26230 {
lab=word437}
N 600 26230 640 26230 {
lab=word437}
N 570 26220 570 26270 {
lab=GND}
N 570 26270 570 26280 {
lab=GND}
N 630 26220 630 26270 {
lab=Y7}
N 630 26270 630 26280 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 26250 1 0 {name=M1906
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 26290 0 0 {name=p461 lab=word438}

N 10 26340 40 26340 {
lab=GND}
N 40 26330 40 26340 {
lab=GND}
N 0 26290 40 26290 {
lab=word438}
N 40 26290 80 26290 {
lab=word438}
N 10 26280 10 26330 {
lab=GND}
N 10 26330 10 26340 {
lab=GND}
N 70 26280 70 26330 {
lab=Y0}
N 70 26330 70 26340 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26310 1 0 {name=M1907
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26340 120 26340 {
lab=GND}
N 120 26330 120 26340 {
lab=GND}
N 80 26290 120 26290 {
lab=word438}
N 120 26290 160 26290 {
lab=word438}
N 90 26280 90 26330 {
lab=GND}
N 90 26330 90 26340 {
lab=GND}
N 150 26280 150 26330 {
lab=Y1}
N 150 26330 150 26340 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26310 1 0 {name=M1908
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26340 200 26340 {
lab=GND}
N 200 26330 200 26340 {
lab=GND}
N 160 26290 200 26290 {
lab=word438}
N 200 26290 240 26290 {
lab=word438}
N 170 26280 170 26330 {
lab=GND}
N 170 26330 170 26340 {
lab=GND}
N 230 26280 230 26330 {
lab=Y2}
N 230 26330 230 26340 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26310 1 0 {name=M1909
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 26340 280 26340 {
lab=GND}
N 280 26330 280 26340 {
lab=GND}
N 240 26290 280 26290 {
lab=word438}
N 280 26290 320 26290 {
lab=word438}
N 250 26280 250 26330 {
lab=GND}
N 250 26330 250 26340 {
lab=GND}
N 310 26280 310 26330 {
lab=Y3}
N 310 26330 310 26340 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26310 1 0 {name=M1910
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 26290 360 26290 {
lab=word438}
N 360 26290 400 26290 {
lab=word438}
N 330 26280 330 26330 {
lab=GND}
N 330 26330 330 26340 {
lab=GND}
N 390 26280 390 26330 {
lab=Y4}
N 390 26330 390 26340 {
lab=Y4}
N 400 26290 440 26290 {
lab=word438}
N 440 26290 480 26290 {
lab=word438}
N 410 26280 410 26330 {
lab=GND}
N 410 26330 410 26340 {
lab=GND}
N 470 26280 470 26330 {
lab=Y5}
N 470 26330 470 26340 {
lab=Y5}
N 480 26290 520 26290 {
lab=word438}
N 520 26290 560 26290 {
lab=word438}
N 490 26280 490 26330 {
lab=GND}
N 490 26330 490 26340 {
lab=GND}
N 550 26280 550 26330 {
lab=Y6}
N 550 26330 550 26340 {
lab=Y6}
N 560 26290 600 26290 {
lab=word438}
N 600 26290 640 26290 {
lab=word438}
N 570 26280 570 26330 {
lab=GND}
N 570 26330 570 26340 {
lab=GND}
N 630 26280 630 26330 {
lab=Y7}
N 630 26330 630 26340 {
lab=Y7}
C {devices/ipin.sym} 0 26350 0 0 {name=p462 lab=word439}

N 10 26400 40 26400 {
lab=GND}
N 40 26390 40 26400 {
lab=GND}
N 0 26350 40 26350 {
lab=word439}
N 40 26350 80 26350 {
lab=word439}
N 10 26340 10 26390 {
lab=GND}
N 10 26390 10 26400 {
lab=GND}
N 70 26340 70 26390 {
lab=Y0}
N 70 26390 70 26400 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26370 1 0 {name=M1911
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26400 120 26400 {
lab=GND}
N 120 26390 120 26400 {
lab=GND}
N 80 26350 120 26350 {
lab=word439}
N 120 26350 160 26350 {
lab=word439}
N 90 26340 90 26390 {
lab=GND}
N 90 26390 90 26400 {
lab=GND}
N 150 26340 150 26390 {
lab=Y1}
N 150 26390 150 26400 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26370 1 0 {name=M1912
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26400 200 26400 {
lab=GND}
N 200 26390 200 26400 {
lab=GND}
N 160 26350 200 26350 {
lab=word439}
N 200 26350 240 26350 {
lab=word439}
N 170 26340 170 26390 {
lab=GND}
N 170 26390 170 26400 {
lab=GND}
N 230 26340 230 26390 {
lab=Y2}
N 230 26390 230 26400 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26370 1 0 {name=M1913
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 26400 280 26400 {
lab=GND}
N 280 26390 280 26400 {
lab=GND}
N 240 26350 280 26350 {
lab=word439}
N 280 26350 320 26350 {
lab=word439}
N 250 26340 250 26390 {
lab=GND}
N 250 26390 250 26400 {
lab=GND}
N 310 26340 310 26390 {
lab=Y3}
N 310 26390 310 26400 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26370 1 0 {name=M1914
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 26350 360 26350 {
lab=word439}
N 360 26350 400 26350 {
lab=word439}
N 330 26340 330 26390 {
lab=GND}
N 330 26390 330 26400 {
lab=GND}
N 390 26340 390 26390 {
lab=Y4}
N 390 26390 390 26400 {
lab=Y4}
N 400 26350 440 26350 {
lab=word439}
N 440 26350 480 26350 {
lab=word439}
N 410 26340 410 26390 {
lab=GND}
N 410 26390 410 26400 {
lab=GND}
N 470 26340 470 26390 {
lab=Y5}
N 470 26390 470 26400 {
lab=Y5}

N 490 26400 520 26400 {
lab=GND}
N 520 26390 520 26400 {
lab=GND}
N 480 26350 520 26350 {
lab=word439}
N 520 26350 560 26350 {
lab=word439}
N 490 26340 490 26390 {
lab=GND}
N 490 26390 490 26400 {
lab=GND}
N 550 26340 550 26390 {
lab=Y6}
N 550 26390 550 26400 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 26370 1 0 {name=M1915
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 26400 600 26400 {
lab=GND}
N 600 26390 600 26400 {
lab=GND}
N 560 26350 600 26350 {
lab=word439}
N 600 26350 640 26350 {
lab=word439}
N 570 26340 570 26390 {
lab=GND}
N 570 26390 570 26400 {
lab=GND}
N 630 26340 630 26390 {
lab=Y7}
N 630 26390 630 26400 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 26370 1 0 {name=M1916
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 26410 0 0 {name=p463 lab=word440}

N 10 26460 40 26460 {
lab=GND}
N 40 26450 40 26460 {
lab=GND}
N 0 26410 40 26410 {
lab=word440}
N 40 26410 80 26410 {
lab=word440}
N 10 26400 10 26450 {
lab=GND}
N 10 26450 10 26460 {
lab=GND}
N 70 26400 70 26450 {
lab=Y0}
N 70 26450 70 26460 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26430 1 0 {name=M1917
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26460 120 26460 {
lab=GND}
N 120 26450 120 26460 {
lab=GND}
N 80 26410 120 26410 {
lab=word440}
N 120 26410 160 26410 {
lab=word440}
N 90 26400 90 26450 {
lab=GND}
N 90 26450 90 26460 {
lab=GND}
N 150 26400 150 26450 {
lab=Y1}
N 150 26450 150 26460 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26430 1 0 {name=M1918
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26460 200 26460 {
lab=GND}
N 200 26450 200 26460 {
lab=GND}
N 160 26410 200 26410 {
lab=word440}
N 200 26410 240 26410 {
lab=word440}
N 170 26400 170 26450 {
lab=GND}
N 170 26450 170 26460 {
lab=GND}
N 230 26400 230 26450 {
lab=Y2}
N 230 26450 230 26460 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26430 1 0 {name=M1919
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 26460 280 26460 {
lab=GND}
N 280 26450 280 26460 {
lab=GND}
N 240 26410 280 26410 {
lab=word440}
N 280 26410 320 26410 {
lab=word440}
N 250 26400 250 26450 {
lab=GND}
N 250 26450 250 26460 {
lab=GND}
N 310 26400 310 26450 {
lab=Y3}
N 310 26450 310 26460 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26430 1 0 {name=M1920
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 26410 360 26410 {
lab=word440}
N 360 26410 400 26410 {
lab=word440}
N 330 26400 330 26450 {
lab=GND}
N 330 26450 330 26460 {
lab=GND}
N 390 26400 390 26450 {
lab=Y4}
N 390 26450 390 26460 {
lab=Y4}

N 410 26460 440 26460 {
lab=GND}
N 440 26450 440 26460 {
lab=GND}
N 400 26410 440 26410 {
lab=word440}
N 440 26410 480 26410 {
lab=word440}
N 410 26400 410 26450 {
lab=GND}
N 410 26450 410 26460 {
lab=GND}
N 470 26400 470 26450 {
lab=Y5}
N 470 26450 470 26460 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 26430 1 0 {name=M1921
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 26410 520 26410 {
lab=word440}
N 520 26410 560 26410 {
lab=word440}
N 490 26400 490 26450 {
lab=GND}
N 490 26450 490 26460 {
lab=GND}
N 550 26400 550 26450 {
lab=Y6}
N 550 26450 550 26460 {
lab=Y6}

N 570 26460 600 26460 {
lab=GND}
N 600 26450 600 26460 {
lab=GND}
N 560 26410 600 26410 {
lab=word440}
N 600 26410 640 26410 {
lab=word440}
N 570 26400 570 26450 {
lab=GND}
N 570 26450 570 26460 {
lab=GND}
N 630 26400 630 26450 {
lab=Y7}
N 630 26450 630 26460 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 26430 1 0 {name=M1922
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 26470 0 0 {name=p464 lab=word441}

N 10 26520 40 26520 {
lab=GND}
N 40 26510 40 26520 {
lab=GND}
N 0 26470 40 26470 {
lab=word441}
N 40 26470 80 26470 {
lab=word441}
N 10 26460 10 26510 {
lab=GND}
N 10 26510 10 26520 {
lab=GND}
N 70 26460 70 26510 {
lab=Y0}
N 70 26510 70 26520 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26490 1 0 {name=M1923
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26520 120 26520 {
lab=GND}
N 120 26510 120 26520 {
lab=GND}
N 80 26470 120 26470 {
lab=word441}
N 120 26470 160 26470 {
lab=word441}
N 90 26460 90 26510 {
lab=GND}
N 90 26510 90 26520 {
lab=GND}
N 150 26460 150 26510 {
lab=Y1}
N 150 26510 150 26520 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26490 1 0 {name=M1924
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26520 200 26520 {
lab=GND}
N 200 26510 200 26520 {
lab=GND}
N 160 26470 200 26470 {
lab=word441}
N 200 26470 240 26470 {
lab=word441}
N 170 26460 170 26510 {
lab=GND}
N 170 26510 170 26520 {
lab=GND}
N 230 26460 230 26510 {
lab=Y2}
N 230 26510 230 26520 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26490 1 0 {name=M1925
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 26520 280 26520 {
lab=GND}
N 280 26510 280 26520 {
lab=GND}
N 240 26470 280 26470 {
lab=word441}
N 280 26470 320 26470 {
lab=word441}
N 250 26460 250 26510 {
lab=GND}
N 250 26510 250 26520 {
lab=GND}
N 310 26460 310 26510 {
lab=Y3}
N 310 26510 310 26520 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26490 1 0 {name=M1926
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 26520 360 26520 {
lab=GND}
N 360 26510 360 26520 {
lab=GND}
N 320 26470 360 26470 {
lab=word441}
N 360 26470 400 26470 {
lab=word441}
N 330 26460 330 26510 {
lab=GND}
N 330 26510 330 26520 {
lab=GND}
N 390 26460 390 26510 {
lab=Y4}
N 390 26510 390 26520 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 26490 1 0 {name=M1927
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 26470 440 26470 {
lab=word441}
N 440 26470 480 26470 {
lab=word441}
N 410 26460 410 26510 {
lab=GND}
N 410 26510 410 26520 {
lab=GND}
N 470 26460 470 26510 {
lab=Y5}
N 470 26510 470 26520 {
lab=Y5}
N 480 26470 520 26470 {
lab=word441}
N 520 26470 560 26470 {
lab=word441}
N 490 26460 490 26510 {
lab=GND}
N 490 26510 490 26520 {
lab=GND}
N 550 26460 550 26510 {
lab=Y6}
N 550 26510 550 26520 {
lab=Y6}
N 560 26470 600 26470 {
lab=word441}
N 600 26470 640 26470 {
lab=word441}
N 570 26460 570 26510 {
lab=GND}
N 570 26510 570 26520 {
lab=GND}
N 630 26460 630 26510 {
lab=Y7}
N 630 26510 630 26520 {
lab=Y7}
C {devices/ipin.sym} 0 26530 0 0 {name=p465 lab=word442}

N 10 26580 40 26580 {
lab=GND}
N 40 26570 40 26580 {
lab=GND}
N 0 26530 40 26530 {
lab=word442}
N 40 26530 80 26530 {
lab=word442}
N 10 26520 10 26570 {
lab=GND}
N 10 26570 10 26580 {
lab=GND}
N 70 26520 70 26570 {
lab=Y0}
N 70 26570 70 26580 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26550 1 0 {name=M1928
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26580 120 26580 {
lab=GND}
N 120 26570 120 26580 {
lab=GND}
N 80 26530 120 26530 {
lab=word442}
N 120 26530 160 26530 {
lab=word442}
N 90 26520 90 26570 {
lab=GND}
N 90 26570 90 26580 {
lab=GND}
N 150 26520 150 26570 {
lab=Y1}
N 150 26570 150 26580 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26550 1 0 {name=M1929
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26580 200 26580 {
lab=GND}
N 200 26570 200 26580 {
lab=GND}
N 160 26530 200 26530 {
lab=word442}
N 200 26530 240 26530 {
lab=word442}
N 170 26520 170 26570 {
lab=GND}
N 170 26570 170 26580 {
lab=GND}
N 230 26520 230 26570 {
lab=Y2}
N 230 26570 230 26580 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26550 1 0 {name=M1930
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 26580 280 26580 {
lab=GND}
N 280 26570 280 26580 {
lab=GND}
N 240 26530 280 26530 {
lab=word442}
N 280 26530 320 26530 {
lab=word442}
N 250 26520 250 26570 {
lab=GND}
N 250 26570 250 26580 {
lab=GND}
N 310 26520 310 26570 {
lab=Y3}
N 310 26570 310 26580 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26550 1 0 {name=M1931
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 26580 360 26580 {
lab=GND}
N 360 26570 360 26580 {
lab=GND}
N 320 26530 360 26530 {
lab=word442}
N 360 26530 400 26530 {
lab=word442}
N 330 26520 330 26570 {
lab=GND}
N 330 26570 330 26580 {
lab=GND}
N 390 26520 390 26570 {
lab=Y4}
N 390 26570 390 26580 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 26550 1 0 {name=M1932
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 26530 440 26530 {
lab=word442}
N 440 26530 480 26530 {
lab=word442}
N 410 26520 410 26570 {
lab=GND}
N 410 26570 410 26580 {
lab=GND}
N 470 26520 470 26570 {
lab=Y5}
N 470 26570 470 26580 {
lab=Y5}

N 490 26580 520 26580 {
lab=GND}
N 520 26570 520 26580 {
lab=GND}
N 480 26530 520 26530 {
lab=word442}
N 520 26530 560 26530 {
lab=word442}
N 490 26520 490 26570 {
lab=GND}
N 490 26570 490 26580 {
lab=GND}
N 550 26520 550 26570 {
lab=Y6}
N 550 26570 550 26580 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 26550 1 0 {name=M1933
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 26530 600 26530 {
lab=word442}
N 600 26530 640 26530 {
lab=word442}
N 570 26520 570 26570 {
lab=GND}
N 570 26570 570 26580 {
lab=GND}
N 630 26520 630 26570 {
lab=Y7}
N 630 26570 630 26580 {
lab=Y7}
C {devices/ipin.sym} 0 26590 0 0 {name=p466 lab=word443}

N 10 26640 40 26640 {
lab=GND}
N 40 26630 40 26640 {
lab=GND}
N 0 26590 40 26590 {
lab=word443}
N 40 26590 80 26590 {
lab=word443}
N 10 26580 10 26630 {
lab=GND}
N 10 26630 10 26640 {
lab=GND}
N 70 26580 70 26630 {
lab=Y0}
N 70 26630 70 26640 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26610 1 0 {name=M1934
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26640 120 26640 {
lab=GND}
N 120 26630 120 26640 {
lab=GND}
N 80 26590 120 26590 {
lab=word443}
N 120 26590 160 26590 {
lab=word443}
N 90 26580 90 26630 {
lab=GND}
N 90 26630 90 26640 {
lab=GND}
N 150 26580 150 26630 {
lab=Y1}
N 150 26630 150 26640 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26610 1 0 {name=M1935
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26640 200 26640 {
lab=GND}
N 200 26630 200 26640 {
lab=GND}
N 160 26590 200 26590 {
lab=word443}
N 200 26590 240 26590 {
lab=word443}
N 170 26580 170 26630 {
lab=GND}
N 170 26630 170 26640 {
lab=GND}
N 230 26580 230 26630 {
lab=Y2}
N 230 26630 230 26640 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26610 1 0 {name=M1936
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 26640 280 26640 {
lab=GND}
N 280 26630 280 26640 {
lab=GND}
N 240 26590 280 26590 {
lab=word443}
N 280 26590 320 26590 {
lab=word443}
N 250 26580 250 26630 {
lab=GND}
N 250 26630 250 26640 {
lab=GND}
N 310 26580 310 26630 {
lab=Y3}
N 310 26630 310 26640 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26610 1 0 {name=M1937
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 26640 360 26640 {
lab=GND}
N 360 26630 360 26640 {
lab=GND}
N 320 26590 360 26590 {
lab=word443}
N 360 26590 400 26590 {
lab=word443}
N 330 26580 330 26630 {
lab=GND}
N 330 26630 330 26640 {
lab=GND}
N 390 26580 390 26630 {
lab=Y4}
N 390 26630 390 26640 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 26610 1 0 {name=M1938
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 26590 440 26590 {
lab=word443}
N 440 26590 480 26590 {
lab=word443}
N 410 26580 410 26630 {
lab=GND}
N 410 26630 410 26640 {
lab=GND}
N 470 26580 470 26630 {
lab=Y5}
N 470 26630 470 26640 {
lab=Y5}

N 490 26640 520 26640 {
lab=GND}
N 520 26630 520 26640 {
lab=GND}
N 480 26590 520 26590 {
lab=word443}
N 520 26590 560 26590 {
lab=word443}
N 490 26580 490 26630 {
lab=GND}
N 490 26630 490 26640 {
lab=GND}
N 550 26580 550 26630 {
lab=Y6}
N 550 26630 550 26640 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 26610 1 0 {name=M1939
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 26640 600 26640 {
lab=GND}
N 600 26630 600 26640 {
lab=GND}
N 560 26590 600 26590 {
lab=word443}
N 600 26590 640 26590 {
lab=word443}
N 570 26580 570 26630 {
lab=GND}
N 570 26630 570 26640 {
lab=GND}
N 630 26580 630 26630 {
lab=Y7}
N 630 26630 630 26640 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 26610 1 0 {name=M1940
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 26650 0 0 {name=p467 lab=word444}

N 10 26700 40 26700 {
lab=GND}
N 40 26690 40 26700 {
lab=GND}
N 0 26650 40 26650 {
lab=word444}
N 40 26650 80 26650 {
lab=word444}
N 10 26640 10 26690 {
lab=GND}
N 10 26690 10 26700 {
lab=GND}
N 70 26640 70 26690 {
lab=Y0}
N 70 26690 70 26700 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26670 1 0 {name=M1941
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26700 120 26700 {
lab=GND}
N 120 26690 120 26700 {
lab=GND}
N 80 26650 120 26650 {
lab=word444}
N 120 26650 160 26650 {
lab=word444}
N 90 26640 90 26690 {
lab=GND}
N 90 26690 90 26700 {
lab=GND}
N 150 26640 150 26690 {
lab=Y1}
N 150 26690 150 26700 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26670 1 0 {name=M1942
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26700 200 26700 {
lab=GND}
N 200 26690 200 26700 {
lab=GND}
N 160 26650 200 26650 {
lab=word444}
N 200 26650 240 26650 {
lab=word444}
N 170 26640 170 26690 {
lab=GND}
N 170 26690 170 26700 {
lab=GND}
N 230 26640 230 26690 {
lab=Y2}
N 230 26690 230 26700 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26670 1 0 {name=M1943
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 26700 280 26700 {
lab=GND}
N 280 26690 280 26700 {
lab=GND}
N 240 26650 280 26650 {
lab=word444}
N 280 26650 320 26650 {
lab=word444}
N 250 26640 250 26690 {
lab=GND}
N 250 26690 250 26700 {
lab=GND}
N 310 26640 310 26690 {
lab=Y3}
N 310 26690 310 26700 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26670 1 0 {name=M1944
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 26700 360 26700 {
lab=GND}
N 360 26690 360 26700 {
lab=GND}
N 320 26650 360 26650 {
lab=word444}
N 360 26650 400 26650 {
lab=word444}
N 330 26640 330 26690 {
lab=GND}
N 330 26690 330 26700 {
lab=GND}
N 390 26640 390 26690 {
lab=Y4}
N 390 26690 390 26700 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 26670 1 0 {name=M1945
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 26700 440 26700 {
lab=GND}
N 440 26690 440 26700 {
lab=GND}
N 400 26650 440 26650 {
lab=word444}
N 440 26650 480 26650 {
lab=word444}
N 410 26640 410 26690 {
lab=GND}
N 410 26690 410 26700 {
lab=GND}
N 470 26640 470 26690 {
lab=Y5}
N 470 26690 470 26700 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 26670 1 0 {name=M1946
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 26650 520 26650 {
lab=word444}
N 520 26650 560 26650 {
lab=word444}
N 490 26640 490 26690 {
lab=GND}
N 490 26690 490 26700 {
lab=GND}
N 550 26640 550 26690 {
lab=Y6}
N 550 26690 550 26700 {
lab=Y6}

N 570 26700 600 26700 {
lab=GND}
N 600 26690 600 26700 {
lab=GND}
N 560 26650 600 26650 {
lab=word444}
N 600 26650 640 26650 {
lab=word444}
N 570 26640 570 26690 {
lab=GND}
N 570 26690 570 26700 {
lab=GND}
N 630 26640 630 26690 {
lab=Y7}
N 630 26690 630 26700 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 26670 1 0 {name=M1947
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 26710 0 0 {name=p468 lab=word445}

N 10 26760 40 26760 {
lab=GND}
N 40 26750 40 26760 {
lab=GND}
N 0 26710 40 26710 {
lab=word445}
N 40 26710 80 26710 {
lab=word445}
N 10 26700 10 26750 {
lab=GND}
N 10 26750 10 26760 {
lab=GND}
N 70 26700 70 26750 {
lab=Y0}
N 70 26750 70 26760 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26730 1 0 {name=M1948
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26760 120 26760 {
lab=GND}
N 120 26750 120 26760 {
lab=GND}
N 80 26710 120 26710 {
lab=word445}
N 120 26710 160 26710 {
lab=word445}
N 90 26700 90 26750 {
lab=GND}
N 90 26750 90 26760 {
lab=GND}
N 150 26700 150 26750 {
lab=Y1}
N 150 26750 150 26760 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26730 1 0 {name=M1949
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26760 200 26760 {
lab=GND}
N 200 26750 200 26760 {
lab=GND}
N 160 26710 200 26710 {
lab=word445}
N 200 26710 240 26710 {
lab=word445}
N 170 26700 170 26750 {
lab=GND}
N 170 26750 170 26760 {
lab=GND}
N 230 26700 230 26750 {
lab=Y2}
N 230 26750 230 26760 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26730 1 0 {name=M1950
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 26760 280 26760 {
lab=GND}
N 280 26750 280 26760 {
lab=GND}
N 240 26710 280 26710 {
lab=word445}
N 280 26710 320 26710 {
lab=word445}
N 250 26700 250 26750 {
lab=GND}
N 250 26750 250 26760 {
lab=GND}
N 310 26700 310 26750 {
lab=Y3}
N 310 26750 310 26760 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26730 1 0 {name=M1951
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 26760 360 26760 {
lab=GND}
N 360 26750 360 26760 {
lab=GND}
N 320 26710 360 26710 {
lab=word445}
N 360 26710 400 26710 {
lab=word445}
N 330 26700 330 26750 {
lab=GND}
N 330 26750 330 26760 {
lab=GND}
N 390 26700 390 26750 {
lab=Y4}
N 390 26750 390 26760 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 26730 1 0 {name=M1952
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 26760 440 26760 {
lab=GND}
N 440 26750 440 26760 {
lab=GND}
N 400 26710 440 26710 {
lab=word445}
N 440 26710 480 26710 {
lab=word445}
N 410 26700 410 26750 {
lab=GND}
N 410 26750 410 26760 {
lab=GND}
N 470 26700 470 26750 {
lab=Y5}
N 470 26750 470 26760 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 26730 1 0 {name=M1953
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 26760 520 26760 {
lab=GND}
N 520 26750 520 26760 {
lab=GND}
N 480 26710 520 26710 {
lab=word445}
N 520 26710 560 26710 {
lab=word445}
N 490 26700 490 26750 {
lab=GND}
N 490 26750 490 26760 {
lab=GND}
N 550 26700 550 26750 {
lab=Y6}
N 550 26750 550 26760 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 26730 1 0 {name=M1954
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 26710 600 26710 {
lab=word445}
N 600 26710 640 26710 {
lab=word445}
N 570 26700 570 26750 {
lab=GND}
N 570 26750 570 26760 {
lab=GND}
N 630 26700 630 26750 {
lab=Y7}
N 630 26750 630 26760 {
lab=Y7}
C {devices/ipin.sym} 0 26770 0 0 {name=p469 lab=word446}

N 10 26820 40 26820 {
lab=GND}
N 40 26810 40 26820 {
lab=GND}
N 0 26770 40 26770 {
lab=word446}
N 40 26770 80 26770 {
lab=word446}
N 10 26760 10 26810 {
lab=GND}
N 10 26810 10 26820 {
lab=GND}
N 70 26760 70 26810 {
lab=Y0}
N 70 26810 70 26820 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26790 1 0 {name=M1955
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26820 120 26820 {
lab=GND}
N 120 26810 120 26820 {
lab=GND}
N 80 26770 120 26770 {
lab=word446}
N 120 26770 160 26770 {
lab=word446}
N 90 26760 90 26810 {
lab=GND}
N 90 26810 90 26820 {
lab=GND}
N 150 26760 150 26810 {
lab=Y1}
N 150 26810 150 26820 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26790 1 0 {name=M1956
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26820 200 26820 {
lab=GND}
N 200 26810 200 26820 {
lab=GND}
N 160 26770 200 26770 {
lab=word446}
N 200 26770 240 26770 {
lab=word446}
N 170 26760 170 26810 {
lab=GND}
N 170 26810 170 26820 {
lab=GND}
N 230 26760 230 26810 {
lab=Y2}
N 230 26810 230 26820 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26790 1 0 {name=M1957
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 26820 280 26820 {
lab=GND}
N 280 26810 280 26820 {
lab=GND}
N 240 26770 280 26770 {
lab=word446}
N 280 26770 320 26770 {
lab=word446}
N 250 26760 250 26810 {
lab=GND}
N 250 26810 250 26820 {
lab=GND}
N 310 26760 310 26810 {
lab=Y3}
N 310 26810 310 26820 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26790 1 0 {name=M1958
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 26820 360 26820 {
lab=GND}
N 360 26810 360 26820 {
lab=GND}
N 320 26770 360 26770 {
lab=word446}
N 360 26770 400 26770 {
lab=word446}
N 330 26760 330 26810 {
lab=GND}
N 330 26810 330 26820 {
lab=GND}
N 390 26760 390 26810 {
lab=Y4}
N 390 26810 390 26820 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 26790 1 0 {name=M1959
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 26820 440 26820 {
lab=GND}
N 440 26810 440 26820 {
lab=GND}
N 400 26770 440 26770 {
lab=word446}
N 440 26770 480 26770 {
lab=word446}
N 410 26760 410 26810 {
lab=GND}
N 410 26810 410 26820 {
lab=GND}
N 470 26760 470 26810 {
lab=Y5}
N 470 26810 470 26820 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 26790 1 0 {name=M1960
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 26820 520 26820 {
lab=GND}
N 520 26810 520 26820 {
lab=GND}
N 480 26770 520 26770 {
lab=word446}
N 520 26770 560 26770 {
lab=word446}
N 490 26760 490 26810 {
lab=GND}
N 490 26810 490 26820 {
lab=GND}
N 550 26760 550 26810 {
lab=Y6}
N 550 26810 550 26820 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 26790 1 0 {name=M1961
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 26770 600 26770 {
lab=word446}
N 600 26770 640 26770 {
lab=word446}
N 570 26760 570 26810 {
lab=GND}
N 570 26810 570 26820 {
lab=GND}
N 630 26760 630 26810 {
lab=Y7}
N 630 26810 630 26820 {
lab=Y7}
C {devices/ipin.sym} 0 26830 0 0 {name=p470 lab=word447}

N 10 26880 40 26880 {
lab=GND}
N 40 26870 40 26880 {
lab=GND}
N 0 26830 40 26830 {
lab=word447}
N 40 26830 80 26830 {
lab=word447}
N 10 26820 10 26870 {
lab=GND}
N 10 26870 10 26880 {
lab=GND}
N 70 26820 70 26870 {
lab=Y0}
N 70 26870 70 26880 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26850 1 0 {name=M1962
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26880 120 26880 {
lab=GND}
N 120 26870 120 26880 {
lab=GND}
N 80 26830 120 26830 {
lab=word447}
N 120 26830 160 26830 {
lab=word447}
N 90 26820 90 26870 {
lab=GND}
N 90 26870 90 26880 {
lab=GND}
N 150 26820 150 26870 {
lab=Y1}
N 150 26870 150 26880 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26850 1 0 {name=M1963
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26880 200 26880 {
lab=GND}
N 200 26870 200 26880 {
lab=GND}
N 160 26830 200 26830 {
lab=word447}
N 200 26830 240 26830 {
lab=word447}
N 170 26820 170 26870 {
lab=GND}
N 170 26870 170 26880 {
lab=GND}
N 230 26820 230 26870 {
lab=Y2}
N 230 26870 230 26880 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26850 1 0 {name=M1964
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 26880 280 26880 {
lab=GND}
N 280 26870 280 26880 {
lab=GND}
N 240 26830 280 26830 {
lab=word447}
N 280 26830 320 26830 {
lab=word447}
N 250 26820 250 26870 {
lab=GND}
N 250 26870 250 26880 {
lab=GND}
N 310 26820 310 26870 {
lab=Y3}
N 310 26870 310 26880 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26850 1 0 {name=M1965
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 26880 360 26880 {
lab=GND}
N 360 26870 360 26880 {
lab=GND}
N 320 26830 360 26830 {
lab=word447}
N 360 26830 400 26830 {
lab=word447}
N 330 26820 330 26870 {
lab=GND}
N 330 26870 330 26880 {
lab=GND}
N 390 26820 390 26870 {
lab=Y4}
N 390 26870 390 26880 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 26850 1 0 {name=M1966
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 26880 440 26880 {
lab=GND}
N 440 26870 440 26880 {
lab=GND}
N 400 26830 440 26830 {
lab=word447}
N 440 26830 480 26830 {
lab=word447}
N 410 26820 410 26870 {
lab=GND}
N 410 26870 410 26880 {
lab=GND}
N 470 26820 470 26870 {
lab=Y5}
N 470 26870 470 26880 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 26850 1 0 {name=M1967
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 26880 520 26880 {
lab=GND}
N 520 26870 520 26880 {
lab=GND}
N 480 26830 520 26830 {
lab=word447}
N 520 26830 560 26830 {
lab=word447}
N 490 26820 490 26870 {
lab=GND}
N 490 26870 490 26880 {
lab=GND}
N 550 26820 550 26870 {
lab=Y6}
N 550 26870 550 26880 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 26850 1 0 {name=M1968
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 26880 600 26880 {
lab=GND}
N 600 26870 600 26880 {
lab=GND}
N 560 26830 600 26830 {
lab=word447}
N 600 26830 640 26830 {
lab=word447}
N 570 26820 570 26870 {
lab=GND}
N 570 26870 570 26880 {
lab=GND}
N 630 26820 630 26870 {
lab=Y7}
N 630 26870 630 26880 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 26850 1 0 {name=M1969
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 26890 0 0 {name=p471 lab=word448}

N 10 26940 40 26940 {
lab=GND}
N 40 26930 40 26940 {
lab=GND}
N 0 26890 40 26890 {
lab=word448}
N 40 26890 80 26890 {
lab=word448}
N 10 26880 10 26930 {
lab=GND}
N 10 26930 10 26940 {
lab=GND}
N 70 26880 70 26930 {
lab=Y0}
N 70 26930 70 26940 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26910 1 0 {name=M1970
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 26940 120 26940 {
lab=GND}
N 120 26930 120 26940 {
lab=GND}
N 80 26890 120 26890 {
lab=word448}
N 120 26890 160 26890 {
lab=word448}
N 90 26880 90 26930 {
lab=GND}
N 90 26930 90 26940 {
lab=GND}
N 150 26880 150 26930 {
lab=Y1}
N 150 26930 150 26940 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26910 1 0 {name=M1971
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 26940 200 26940 {
lab=GND}
N 200 26930 200 26940 {
lab=GND}
N 160 26890 200 26890 {
lab=word448}
N 200 26890 240 26890 {
lab=word448}
N 170 26880 170 26930 {
lab=GND}
N 170 26930 170 26940 {
lab=GND}
N 230 26880 230 26930 {
lab=Y2}
N 230 26930 230 26940 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26910 1 0 {name=M1972
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 26940 280 26940 {
lab=GND}
N 280 26930 280 26940 {
lab=GND}
N 240 26890 280 26890 {
lab=word448}
N 280 26890 320 26890 {
lab=word448}
N 250 26880 250 26930 {
lab=GND}
N 250 26930 250 26940 {
lab=GND}
N 310 26880 310 26930 {
lab=Y3}
N 310 26930 310 26940 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26910 1 0 {name=M1973
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 26940 360 26940 {
lab=GND}
N 360 26930 360 26940 {
lab=GND}
N 320 26890 360 26890 {
lab=word448}
N 360 26890 400 26890 {
lab=word448}
N 330 26880 330 26930 {
lab=GND}
N 330 26930 330 26940 {
lab=GND}
N 390 26880 390 26930 {
lab=Y4}
N 390 26930 390 26940 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 26910 1 0 {name=M1974
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 26940 440 26940 {
lab=GND}
N 440 26930 440 26940 {
lab=GND}
N 400 26890 440 26890 {
lab=word448}
N 440 26890 480 26890 {
lab=word448}
N 410 26880 410 26930 {
lab=GND}
N 410 26930 410 26940 {
lab=GND}
N 470 26880 470 26930 {
lab=Y5}
N 470 26930 470 26940 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 26910 1 0 {name=M1975
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 26940 520 26940 {
lab=GND}
N 520 26930 520 26940 {
lab=GND}
N 480 26890 520 26890 {
lab=word448}
N 520 26890 560 26890 {
lab=word448}
N 490 26880 490 26930 {
lab=GND}
N 490 26930 490 26940 {
lab=GND}
N 550 26880 550 26930 {
lab=Y6}
N 550 26930 550 26940 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 26910 1 0 {name=M1976
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 26940 600 26940 {
lab=GND}
N 600 26930 600 26940 {
lab=GND}
N 560 26890 600 26890 {
lab=word448}
N 600 26890 640 26890 {
lab=word448}
N 570 26880 570 26930 {
lab=GND}
N 570 26930 570 26940 {
lab=GND}
N 630 26880 630 26930 {
lab=Y7}
N 630 26930 630 26940 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 26910 1 0 {name=M1977
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 26950 0 0 {name=p472 lab=word449}

N 10 27000 40 27000 {
lab=GND}
N 40 26990 40 27000 {
lab=GND}
N 0 26950 40 26950 {
lab=word449}
N 40 26950 80 26950 {
lab=word449}
N 10 26940 10 26990 {
lab=GND}
N 10 26990 10 27000 {
lab=GND}
N 70 26940 70 26990 {
lab=Y0}
N 70 26990 70 27000 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 26970 1 0 {name=M1978
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27000 120 27000 {
lab=GND}
N 120 26990 120 27000 {
lab=GND}
N 80 26950 120 26950 {
lab=word449}
N 120 26950 160 26950 {
lab=word449}
N 90 26940 90 26990 {
lab=GND}
N 90 26990 90 27000 {
lab=GND}
N 150 26940 150 26990 {
lab=Y1}
N 150 26990 150 27000 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 26970 1 0 {name=M1979
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27000 200 27000 {
lab=GND}
N 200 26990 200 27000 {
lab=GND}
N 160 26950 200 26950 {
lab=word449}
N 200 26950 240 26950 {
lab=word449}
N 170 26940 170 26990 {
lab=GND}
N 170 26990 170 27000 {
lab=GND}
N 230 26940 230 26990 {
lab=Y2}
N 230 26990 230 27000 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 26970 1 0 {name=M1980
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 27000 280 27000 {
lab=GND}
N 280 26990 280 27000 {
lab=GND}
N 240 26950 280 26950 {
lab=word449}
N 280 26950 320 26950 {
lab=word449}
N 250 26940 250 26990 {
lab=GND}
N 250 26990 250 27000 {
lab=GND}
N 310 26940 310 26990 {
lab=Y3}
N 310 26990 310 27000 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 26970 1 0 {name=M1981
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 27000 360 27000 {
lab=GND}
N 360 26990 360 27000 {
lab=GND}
N 320 26950 360 26950 {
lab=word449}
N 360 26950 400 26950 {
lab=word449}
N 330 26940 330 26990 {
lab=GND}
N 330 26990 330 27000 {
lab=GND}
N 390 26940 390 26990 {
lab=Y4}
N 390 26990 390 27000 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 26970 1 0 {name=M1982
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 27000 440 27000 {
lab=GND}
N 440 26990 440 27000 {
lab=GND}
N 400 26950 440 26950 {
lab=word449}
N 440 26950 480 26950 {
lab=word449}
N 410 26940 410 26990 {
lab=GND}
N 410 26990 410 27000 {
lab=GND}
N 470 26940 470 26990 {
lab=Y5}
N 470 26990 470 27000 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 26970 1 0 {name=M1983
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 27000 520 27000 {
lab=GND}
N 520 26990 520 27000 {
lab=GND}
N 480 26950 520 26950 {
lab=word449}
N 520 26950 560 26950 {
lab=word449}
N 490 26940 490 26990 {
lab=GND}
N 490 26990 490 27000 {
lab=GND}
N 550 26940 550 26990 {
lab=Y6}
N 550 26990 550 27000 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 26970 1 0 {name=M1984
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 27000 600 27000 {
lab=GND}
N 600 26990 600 27000 {
lab=GND}
N 560 26950 600 26950 {
lab=word449}
N 600 26950 640 26950 {
lab=word449}
N 570 26940 570 26990 {
lab=GND}
N 570 26990 570 27000 {
lab=GND}
N 630 26940 630 26990 {
lab=Y7}
N 630 26990 630 27000 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 26970 1 0 {name=M1985
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 27010 0 0 {name=p473 lab=word450}

N 10 27060 40 27060 {
lab=GND}
N 40 27050 40 27060 {
lab=GND}
N 0 27010 40 27010 {
lab=word450}
N 40 27010 80 27010 {
lab=word450}
N 10 27000 10 27050 {
lab=GND}
N 10 27050 10 27060 {
lab=GND}
N 70 27000 70 27050 {
lab=Y0}
N 70 27050 70 27060 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27030 1 0 {name=M1986
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27060 120 27060 {
lab=GND}
N 120 27050 120 27060 {
lab=GND}
N 80 27010 120 27010 {
lab=word450}
N 120 27010 160 27010 {
lab=word450}
N 90 27000 90 27050 {
lab=GND}
N 90 27050 90 27060 {
lab=GND}
N 150 27000 150 27050 {
lab=Y1}
N 150 27050 150 27060 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27030 1 0 {name=M1987
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27060 200 27060 {
lab=GND}
N 200 27050 200 27060 {
lab=GND}
N 160 27010 200 27010 {
lab=word450}
N 200 27010 240 27010 {
lab=word450}
N 170 27000 170 27050 {
lab=GND}
N 170 27050 170 27060 {
lab=GND}
N 230 27000 230 27050 {
lab=Y2}
N 230 27050 230 27060 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27030 1 0 {name=M1988
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 27060 280 27060 {
lab=GND}
N 280 27050 280 27060 {
lab=GND}
N 240 27010 280 27010 {
lab=word450}
N 280 27010 320 27010 {
lab=word450}
N 250 27000 250 27050 {
lab=GND}
N 250 27050 250 27060 {
lab=GND}
N 310 27000 310 27050 {
lab=Y3}
N 310 27050 310 27060 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27030 1 0 {name=M1989
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 27060 360 27060 {
lab=GND}
N 360 27050 360 27060 {
lab=GND}
N 320 27010 360 27010 {
lab=word450}
N 360 27010 400 27010 {
lab=word450}
N 330 27000 330 27050 {
lab=GND}
N 330 27050 330 27060 {
lab=GND}
N 390 27000 390 27050 {
lab=Y4}
N 390 27050 390 27060 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 27030 1 0 {name=M1990
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 27060 440 27060 {
lab=GND}
N 440 27050 440 27060 {
lab=GND}
N 400 27010 440 27010 {
lab=word450}
N 440 27010 480 27010 {
lab=word450}
N 410 27000 410 27050 {
lab=GND}
N 410 27050 410 27060 {
lab=GND}
N 470 27000 470 27050 {
lab=Y5}
N 470 27050 470 27060 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 27030 1 0 {name=M1991
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 27060 520 27060 {
lab=GND}
N 520 27050 520 27060 {
lab=GND}
N 480 27010 520 27010 {
lab=word450}
N 520 27010 560 27010 {
lab=word450}
N 490 27000 490 27050 {
lab=GND}
N 490 27050 490 27060 {
lab=GND}
N 550 27000 550 27050 {
lab=Y6}
N 550 27050 550 27060 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 27030 1 0 {name=M1992
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 27010 600 27010 {
lab=word450}
N 600 27010 640 27010 {
lab=word450}
N 570 27000 570 27050 {
lab=GND}
N 570 27050 570 27060 {
lab=GND}
N 630 27000 630 27050 {
lab=Y7}
N 630 27050 630 27060 {
lab=Y7}
C {devices/ipin.sym} 0 27070 0 0 {name=p474 lab=word451}

N 10 27120 40 27120 {
lab=GND}
N 40 27110 40 27120 {
lab=GND}
N 0 27070 40 27070 {
lab=word451}
N 40 27070 80 27070 {
lab=word451}
N 10 27060 10 27110 {
lab=GND}
N 10 27110 10 27120 {
lab=GND}
N 70 27060 70 27110 {
lab=Y0}
N 70 27110 70 27120 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27090 1 0 {name=M1993
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27120 120 27120 {
lab=GND}
N 120 27110 120 27120 {
lab=GND}
N 80 27070 120 27070 {
lab=word451}
N 120 27070 160 27070 {
lab=word451}
N 90 27060 90 27110 {
lab=GND}
N 90 27110 90 27120 {
lab=GND}
N 150 27060 150 27110 {
lab=Y1}
N 150 27110 150 27120 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27090 1 0 {name=M1994
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27120 200 27120 {
lab=GND}
N 200 27110 200 27120 {
lab=GND}
N 160 27070 200 27070 {
lab=word451}
N 200 27070 240 27070 {
lab=word451}
N 170 27060 170 27110 {
lab=GND}
N 170 27110 170 27120 {
lab=GND}
N 230 27060 230 27110 {
lab=Y2}
N 230 27110 230 27120 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27090 1 0 {name=M1995
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 27120 280 27120 {
lab=GND}
N 280 27110 280 27120 {
lab=GND}
N 240 27070 280 27070 {
lab=word451}
N 280 27070 320 27070 {
lab=word451}
N 250 27060 250 27110 {
lab=GND}
N 250 27110 250 27120 {
lab=GND}
N 310 27060 310 27110 {
lab=Y3}
N 310 27110 310 27120 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27090 1 0 {name=M1996
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 27120 360 27120 {
lab=GND}
N 360 27110 360 27120 {
lab=GND}
N 320 27070 360 27070 {
lab=word451}
N 360 27070 400 27070 {
lab=word451}
N 330 27060 330 27110 {
lab=GND}
N 330 27110 330 27120 {
lab=GND}
N 390 27060 390 27110 {
lab=Y4}
N 390 27110 390 27120 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 27090 1 0 {name=M1997
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 27120 440 27120 {
lab=GND}
N 440 27110 440 27120 {
lab=GND}
N 400 27070 440 27070 {
lab=word451}
N 440 27070 480 27070 {
lab=word451}
N 410 27060 410 27110 {
lab=GND}
N 410 27110 410 27120 {
lab=GND}
N 470 27060 470 27110 {
lab=Y5}
N 470 27110 470 27120 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 27090 1 0 {name=M1998
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 27120 520 27120 {
lab=GND}
N 520 27110 520 27120 {
lab=GND}
N 480 27070 520 27070 {
lab=word451}
N 520 27070 560 27070 {
lab=word451}
N 490 27060 490 27110 {
lab=GND}
N 490 27110 490 27120 {
lab=GND}
N 550 27060 550 27110 {
lab=Y6}
N 550 27110 550 27120 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 27090 1 0 {name=M1999
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 27070 600 27070 {
lab=word451}
N 600 27070 640 27070 {
lab=word451}
N 570 27060 570 27110 {
lab=GND}
N 570 27110 570 27120 {
lab=GND}
N 630 27060 630 27110 {
lab=Y7}
N 630 27110 630 27120 {
lab=Y7}
C {devices/ipin.sym} 0 27130 0 0 {name=p475 lab=word452}

N 10 27180 40 27180 {
lab=GND}
N 40 27170 40 27180 {
lab=GND}
N 0 27130 40 27130 {
lab=word452}
N 40 27130 80 27130 {
lab=word452}
N 10 27120 10 27170 {
lab=GND}
N 10 27170 10 27180 {
lab=GND}
N 70 27120 70 27170 {
lab=Y0}
N 70 27170 70 27180 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27150 1 0 {name=M2000
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27180 120 27180 {
lab=GND}
N 120 27170 120 27180 {
lab=GND}
N 80 27130 120 27130 {
lab=word452}
N 120 27130 160 27130 {
lab=word452}
N 90 27120 90 27170 {
lab=GND}
N 90 27170 90 27180 {
lab=GND}
N 150 27120 150 27170 {
lab=Y1}
N 150 27170 150 27180 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27150 1 0 {name=M2001
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27180 200 27180 {
lab=GND}
N 200 27170 200 27180 {
lab=GND}
N 160 27130 200 27130 {
lab=word452}
N 200 27130 240 27130 {
lab=word452}
N 170 27120 170 27170 {
lab=GND}
N 170 27170 170 27180 {
lab=GND}
N 230 27120 230 27170 {
lab=Y2}
N 230 27170 230 27180 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27150 1 0 {name=M2002
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 27180 280 27180 {
lab=GND}
N 280 27170 280 27180 {
lab=GND}
N 240 27130 280 27130 {
lab=word452}
N 280 27130 320 27130 {
lab=word452}
N 250 27120 250 27170 {
lab=GND}
N 250 27170 250 27180 {
lab=GND}
N 310 27120 310 27170 {
lab=Y3}
N 310 27170 310 27180 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27150 1 0 {name=M2003
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 27180 360 27180 {
lab=GND}
N 360 27170 360 27180 {
lab=GND}
N 320 27130 360 27130 {
lab=word452}
N 360 27130 400 27130 {
lab=word452}
N 330 27120 330 27170 {
lab=GND}
N 330 27170 330 27180 {
lab=GND}
N 390 27120 390 27170 {
lab=Y4}
N 390 27170 390 27180 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 27150 1 0 {name=M2004
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 27180 440 27180 {
lab=GND}
N 440 27170 440 27180 {
lab=GND}
N 400 27130 440 27130 {
lab=word452}
N 440 27130 480 27130 {
lab=word452}
N 410 27120 410 27170 {
lab=GND}
N 410 27170 410 27180 {
lab=GND}
N 470 27120 470 27170 {
lab=Y5}
N 470 27170 470 27180 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 27150 1 0 {name=M2005
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 27130 520 27130 {
lab=word452}
N 520 27130 560 27130 {
lab=word452}
N 490 27120 490 27170 {
lab=GND}
N 490 27170 490 27180 {
lab=GND}
N 550 27120 550 27170 {
lab=Y6}
N 550 27170 550 27180 {
lab=Y6}

N 570 27180 600 27180 {
lab=GND}
N 600 27170 600 27180 {
lab=GND}
N 560 27130 600 27130 {
lab=word452}
N 600 27130 640 27130 {
lab=word452}
N 570 27120 570 27170 {
lab=GND}
N 570 27170 570 27180 {
lab=GND}
N 630 27120 630 27170 {
lab=Y7}
N 630 27170 630 27180 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 27150 1 0 {name=M2006
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 27190 0 0 {name=p476 lab=word453}

N 10 27240 40 27240 {
lab=GND}
N 40 27230 40 27240 {
lab=GND}
N 0 27190 40 27190 {
lab=word453}
N 40 27190 80 27190 {
lab=word453}
N 10 27180 10 27230 {
lab=GND}
N 10 27230 10 27240 {
lab=GND}
N 70 27180 70 27230 {
lab=Y0}
N 70 27230 70 27240 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27210 1 0 {name=M2007
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27240 120 27240 {
lab=GND}
N 120 27230 120 27240 {
lab=GND}
N 80 27190 120 27190 {
lab=word453}
N 120 27190 160 27190 {
lab=word453}
N 90 27180 90 27230 {
lab=GND}
N 90 27230 90 27240 {
lab=GND}
N 150 27180 150 27230 {
lab=Y1}
N 150 27230 150 27240 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27210 1 0 {name=M2008
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27240 200 27240 {
lab=GND}
N 200 27230 200 27240 {
lab=GND}
N 160 27190 200 27190 {
lab=word453}
N 200 27190 240 27190 {
lab=word453}
N 170 27180 170 27230 {
lab=GND}
N 170 27230 170 27240 {
lab=GND}
N 230 27180 230 27230 {
lab=Y2}
N 230 27230 230 27240 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27210 1 0 {name=M2009
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 27240 280 27240 {
lab=GND}
N 280 27230 280 27240 {
lab=GND}
N 240 27190 280 27190 {
lab=word453}
N 280 27190 320 27190 {
lab=word453}
N 250 27180 250 27230 {
lab=GND}
N 250 27230 250 27240 {
lab=GND}
N 310 27180 310 27230 {
lab=Y3}
N 310 27230 310 27240 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27210 1 0 {name=M2010
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 27240 360 27240 {
lab=GND}
N 360 27230 360 27240 {
lab=GND}
N 320 27190 360 27190 {
lab=word453}
N 360 27190 400 27190 {
lab=word453}
N 330 27180 330 27230 {
lab=GND}
N 330 27230 330 27240 {
lab=GND}
N 390 27180 390 27230 {
lab=Y4}
N 390 27230 390 27240 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 27210 1 0 {name=M2011
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 27190 440 27190 {
lab=word453}
N 440 27190 480 27190 {
lab=word453}
N 410 27180 410 27230 {
lab=GND}
N 410 27230 410 27240 {
lab=GND}
N 470 27180 470 27230 {
lab=Y5}
N 470 27230 470 27240 {
lab=Y5}

N 490 27240 520 27240 {
lab=GND}
N 520 27230 520 27240 {
lab=GND}
N 480 27190 520 27190 {
lab=word453}
N 520 27190 560 27190 {
lab=word453}
N 490 27180 490 27230 {
lab=GND}
N 490 27230 490 27240 {
lab=GND}
N 550 27180 550 27230 {
lab=Y6}
N 550 27230 550 27240 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 27210 1 0 {name=M2012
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 27240 600 27240 {
lab=GND}
N 600 27230 600 27240 {
lab=GND}
N 560 27190 600 27190 {
lab=word453}
N 600 27190 640 27190 {
lab=word453}
N 570 27180 570 27230 {
lab=GND}
N 570 27230 570 27240 {
lab=GND}
N 630 27180 630 27230 {
lab=Y7}
N 630 27230 630 27240 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 27210 1 0 {name=M2013
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 27250 0 0 {name=p477 lab=word454}

N 10 27300 40 27300 {
lab=GND}
N 40 27290 40 27300 {
lab=GND}
N 0 27250 40 27250 {
lab=word454}
N 40 27250 80 27250 {
lab=word454}
N 10 27240 10 27290 {
lab=GND}
N 10 27290 10 27300 {
lab=GND}
N 70 27240 70 27290 {
lab=Y0}
N 70 27290 70 27300 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27270 1 0 {name=M2014
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27300 120 27300 {
lab=GND}
N 120 27290 120 27300 {
lab=GND}
N 80 27250 120 27250 {
lab=word454}
N 120 27250 160 27250 {
lab=word454}
N 90 27240 90 27290 {
lab=GND}
N 90 27290 90 27300 {
lab=GND}
N 150 27240 150 27290 {
lab=Y1}
N 150 27290 150 27300 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27270 1 0 {name=M2015
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27300 200 27300 {
lab=GND}
N 200 27290 200 27300 {
lab=GND}
N 160 27250 200 27250 {
lab=word454}
N 200 27250 240 27250 {
lab=word454}
N 170 27240 170 27290 {
lab=GND}
N 170 27290 170 27300 {
lab=GND}
N 230 27240 230 27290 {
lab=Y2}
N 230 27290 230 27300 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27270 1 0 {name=M2016
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 27300 280 27300 {
lab=GND}
N 280 27290 280 27300 {
lab=GND}
N 240 27250 280 27250 {
lab=word454}
N 280 27250 320 27250 {
lab=word454}
N 250 27240 250 27290 {
lab=GND}
N 250 27290 250 27300 {
lab=GND}
N 310 27240 310 27290 {
lab=Y3}
N 310 27290 310 27300 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27270 1 0 {name=M2017
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 27300 360 27300 {
lab=GND}
N 360 27290 360 27300 {
lab=GND}
N 320 27250 360 27250 {
lab=word454}
N 360 27250 400 27250 {
lab=word454}
N 330 27240 330 27290 {
lab=GND}
N 330 27290 330 27300 {
lab=GND}
N 390 27240 390 27290 {
lab=Y4}
N 390 27290 390 27300 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 27270 1 0 {name=M2018
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 27250 440 27250 {
lab=word454}
N 440 27250 480 27250 {
lab=word454}
N 410 27240 410 27290 {
lab=GND}
N 410 27290 410 27300 {
lab=GND}
N 470 27240 470 27290 {
lab=Y5}
N 470 27290 470 27300 {
lab=Y5}

N 490 27300 520 27300 {
lab=GND}
N 520 27290 520 27300 {
lab=GND}
N 480 27250 520 27250 {
lab=word454}
N 520 27250 560 27250 {
lab=word454}
N 490 27240 490 27290 {
lab=GND}
N 490 27290 490 27300 {
lab=GND}
N 550 27240 550 27290 {
lab=Y6}
N 550 27290 550 27300 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 27270 1 0 {name=M2019
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 27250 600 27250 {
lab=word454}
N 600 27250 640 27250 {
lab=word454}
N 570 27240 570 27290 {
lab=GND}
N 570 27290 570 27300 {
lab=GND}
N 630 27240 630 27290 {
lab=Y7}
N 630 27290 630 27300 {
lab=Y7}
C {devices/ipin.sym} 0 27310 0 0 {name=p478 lab=word455}

N 10 27360 40 27360 {
lab=GND}
N 40 27350 40 27360 {
lab=GND}
N 0 27310 40 27310 {
lab=word455}
N 40 27310 80 27310 {
lab=word455}
N 10 27300 10 27350 {
lab=GND}
N 10 27350 10 27360 {
lab=GND}
N 70 27300 70 27350 {
lab=Y0}
N 70 27350 70 27360 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27330 1 0 {name=M2020
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27360 120 27360 {
lab=GND}
N 120 27350 120 27360 {
lab=GND}
N 80 27310 120 27310 {
lab=word455}
N 120 27310 160 27310 {
lab=word455}
N 90 27300 90 27350 {
lab=GND}
N 90 27350 90 27360 {
lab=GND}
N 150 27300 150 27350 {
lab=Y1}
N 150 27350 150 27360 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27330 1 0 {name=M2021
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27360 200 27360 {
lab=GND}
N 200 27350 200 27360 {
lab=GND}
N 160 27310 200 27310 {
lab=word455}
N 200 27310 240 27310 {
lab=word455}
N 170 27300 170 27350 {
lab=GND}
N 170 27350 170 27360 {
lab=GND}
N 230 27300 230 27350 {
lab=Y2}
N 230 27350 230 27360 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27330 1 0 {name=M2022
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 27360 280 27360 {
lab=GND}
N 280 27350 280 27360 {
lab=GND}
N 240 27310 280 27310 {
lab=word455}
N 280 27310 320 27310 {
lab=word455}
N 250 27300 250 27350 {
lab=GND}
N 250 27350 250 27360 {
lab=GND}
N 310 27300 310 27350 {
lab=Y3}
N 310 27350 310 27360 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27330 1 0 {name=M2023
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 27360 360 27360 {
lab=GND}
N 360 27350 360 27360 {
lab=GND}
N 320 27310 360 27310 {
lab=word455}
N 360 27310 400 27310 {
lab=word455}
N 330 27300 330 27350 {
lab=GND}
N 330 27350 330 27360 {
lab=GND}
N 390 27300 390 27350 {
lab=Y4}
N 390 27350 390 27360 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 27330 1 0 {name=M2024
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 27310 440 27310 {
lab=word455}
N 440 27310 480 27310 {
lab=word455}
N 410 27300 410 27350 {
lab=GND}
N 410 27350 410 27360 {
lab=GND}
N 470 27300 470 27350 {
lab=Y5}
N 470 27350 470 27360 {
lab=Y5}
N 480 27310 520 27310 {
lab=word455}
N 520 27310 560 27310 {
lab=word455}
N 490 27300 490 27350 {
lab=GND}
N 490 27350 490 27360 {
lab=GND}
N 550 27300 550 27350 {
lab=Y6}
N 550 27350 550 27360 {
lab=Y6}
N 560 27310 600 27310 {
lab=word455}
N 600 27310 640 27310 {
lab=word455}
N 570 27300 570 27350 {
lab=GND}
N 570 27350 570 27360 {
lab=GND}
N 630 27300 630 27350 {
lab=Y7}
N 630 27350 630 27360 {
lab=Y7}
C {devices/ipin.sym} 0 27370 0 0 {name=p479 lab=word456}

N 10 27420 40 27420 {
lab=GND}
N 40 27410 40 27420 {
lab=GND}
N 0 27370 40 27370 {
lab=word456}
N 40 27370 80 27370 {
lab=word456}
N 10 27360 10 27410 {
lab=GND}
N 10 27410 10 27420 {
lab=GND}
N 70 27360 70 27410 {
lab=Y0}
N 70 27410 70 27420 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27390 1 0 {name=M2025
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27420 120 27420 {
lab=GND}
N 120 27410 120 27420 {
lab=GND}
N 80 27370 120 27370 {
lab=word456}
N 120 27370 160 27370 {
lab=word456}
N 90 27360 90 27410 {
lab=GND}
N 90 27410 90 27420 {
lab=GND}
N 150 27360 150 27410 {
lab=Y1}
N 150 27410 150 27420 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27390 1 0 {name=M2026
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27420 200 27420 {
lab=GND}
N 200 27410 200 27420 {
lab=GND}
N 160 27370 200 27370 {
lab=word456}
N 200 27370 240 27370 {
lab=word456}
N 170 27360 170 27410 {
lab=GND}
N 170 27410 170 27420 {
lab=GND}
N 230 27360 230 27410 {
lab=Y2}
N 230 27410 230 27420 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27390 1 0 {name=M2027
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 27420 280 27420 {
lab=GND}
N 280 27410 280 27420 {
lab=GND}
N 240 27370 280 27370 {
lab=word456}
N 280 27370 320 27370 {
lab=word456}
N 250 27360 250 27410 {
lab=GND}
N 250 27410 250 27420 {
lab=GND}
N 310 27360 310 27410 {
lab=Y3}
N 310 27410 310 27420 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27390 1 0 {name=M2028
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 27370 360 27370 {
lab=word456}
N 360 27370 400 27370 {
lab=word456}
N 330 27360 330 27410 {
lab=GND}
N 330 27410 330 27420 {
lab=GND}
N 390 27360 390 27410 {
lab=Y4}
N 390 27410 390 27420 {
lab=Y4}

N 410 27420 440 27420 {
lab=GND}
N 440 27410 440 27420 {
lab=GND}
N 400 27370 440 27370 {
lab=word456}
N 440 27370 480 27370 {
lab=word456}
N 410 27360 410 27410 {
lab=GND}
N 410 27410 410 27420 {
lab=GND}
N 470 27360 470 27410 {
lab=Y5}
N 470 27410 470 27420 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 27390 1 0 {name=M2029
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 27370 520 27370 {
lab=word456}
N 520 27370 560 27370 {
lab=word456}
N 490 27360 490 27410 {
lab=GND}
N 490 27410 490 27420 {
lab=GND}
N 550 27360 550 27410 {
lab=Y6}
N 550 27410 550 27420 {
lab=Y6}

N 570 27420 600 27420 {
lab=GND}
N 600 27410 600 27420 {
lab=GND}
N 560 27370 600 27370 {
lab=word456}
N 600 27370 640 27370 {
lab=word456}
N 570 27360 570 27410 {
lab=GND}
N 570 27410 570 27420 {
lab=GND}
N 630 27360 630 27410 {
lab=Y7}
N 630 27410 630 27420 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 27390 1 0 {name=M2030
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 27430 0 0 {name=p480 lab=word457}

N 10 27480 40 27480 {
lab=GND}
N 40 27470 40 27480 {
lab=GND}
N 0 27430 40 27430 {
lab=word457}
N 40 27430 80 27430 {
lab=word457}
N 10 27420 10 27470 {
lab=GND}
N 10 27470 10 27480 {
lab=GND}
N 70 27420 70 27470 {
lab=Y0}
N 70 27470 70 27480 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27450 1 0 {name=M2031
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27480 120 27480 {
lab=GND}
N 120 27470 120 27480 {
lab=GND}
N 80 27430 120 27430 {
lab=word457}
N 120 27430 160 27430 {
lab=word457}
N 90 27420 90 27470 {
lab=GND}
N 90 27470 90 27480 {
lab=GND}
N 150 27420 150 27470 {
lab=Y1}
N 150 27470 150 27480 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27450 1 0 {name=M2032
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27480 200 27480 {
lab=GND}
N 200 27470 200 27480 {
lab=GND}
N 160 27430 200 27430 {
lab=word457}
N 200 27430 240 27430 {
lab=word457}
N 170 27420 170 27470 {
lab=GND}
N 170 27470 170 27480 {
lab=GND}
N 230 27420 230 27470 {
lab=Y2}
N 230 27470 230 27480 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27450 1 0 {name=M2033
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 27480 280 27480 {
lab=GND}
N 280 27470 280 27480 {
lab=GND}
N 240 27430 280 27430 {
lab=word457}
N 280 27430 320 27430 {
lab=word457}
N 250 27420 250 27470 {
lab=GND}
N 250 27470 250 27480 {
lab=GND}
N 310 27420 310 27470 {
lab=Y3}
N 310 27470 310 27480 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27450 1 0 {name=M2034
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 27430 360 27430 {
lab=word457}
N 360 27430 400 27430 {
lab=word457}
N 330 27420 330 27470 {
lab=GND}
N 330 27470 330 27480 {
lab=GND}
N 390 27420 390 27470 {
lab=Y4}
N 390 27470 390 27480 {
lab=Y4}
N 400 27430 440 27430 {
lab=word457}
N 440 27430 480 27430 {
lab=word457}
N 410 27420 410 27470 {
lab=GND}
N 410 27470 410 27480 {
lab=GND}
N 470 27420 470 27470 {
lab=Y5}
N 470 27470 470 27480 {
lab=Y5}

N 490 27480 520 27480 {
lab=GND}
N 520 27470 520 27480 {
lab=GND}
N 480 27430 520 27430 {
lab=word457}
N 520 27430 560 27430 {
lab=word457}
N 490 27420 490 27470 {
lab=GND}
N 490 27470 490 27480 {
lab=GND}
N 550 27420 550 27470 {
lab=Y6}
N 550 27470 550 27480 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 27450 1 0 {name=M2035
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 27480 600 27480 {
lab=GND}
N 600 27470 600 27480 {
lab=GND}
N 560 27430 600 27430 {
lab=word457}
N 600 27430 640 27430 {
lab=word457}
N 570 27420 570 27470 {
lab=GND}
N 570 27470 570 27480 {
lab=GND}
N 630 27420 630 27470 {
lab=Y7}
N 630 27470 630 27480 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 27450 1 0 {name=M2036
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 27490 0 0 {name=p481 lab=word458}

N 10 27540 40 27540 {
lab=GND}
N 40 27530 40 27540 {
lab=GND}
N 0 27490 40 27490 {
lab=word458}
N 40 27490 80 27490 {
lab=word458}
N 10 27480 10 27530 {
lab=GND}
N 10 27530 10 27540 {
lab=GND}
N 70 27480 70 27530 {
lab=Y0}
N 70 27530 70 27540 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27510 1 0 {name=M2037
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27540 120 27540 {
lab=GND}
N 120 27530 120 27540 {
lab=GND}
N 80 27490 120 27490 {
lab=word458}
N 120 27490 160 27490 {
lab=word458}
N 90 27480 90 27530 {
lab=GND}
N 90 27530 90 27540 {
lab=GND}
N 150 27480 150 27530 {
lab=Y1}
N 150 27530 150 27540 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27510 1 0 {name=M2038
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27540 200 27540 {
lab=GND}
N 200 27530 200 27540 {
lab=GND}
N 160 27490 200 27490 {
lab=word458}
N 200 27490 240 27490 {
lab=word458}
N 170 27480 170 27530 {
lab=GND}
N 170 27530 170 27540 {
lab=GND}
N 230 27480 230 27530 {
lab=Y2}
N 230 27530 230 27540 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27510 1 0 {name=M2039
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 27540 280 27540 {
lab=GND}
N 280 27530 280 27540 {
lab=GND}
N 240 27490 280 27490 {
lab=word458}
N 280 27490 320 27490 {
lab=word458}
N 250 27480 250 27530 {
lab=GND}
N 250 27530 250 27540 {
lab=GND}
N 310 27480 310 27530 {
lab=Y3}
N 310 27530 310 27540 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27510 1 0 {name=M2040
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 27490 360 27490 {
lab=word458}
N 360 27490 400 27490 {
lab=word458}
N 330 27480 330 27530 {
lab=GND}
N 330 27530 330 27540 {
lab=GND}
N 390 27480 390 27530 {
lab=Y4}
N 390 27530 390 27540 {
lab=Y4}
N 400 27490 440 27490 {
lab=word458}
N 440 27490 480 27490 {
lab=word458}
N 410 27480 410 27530 {
lab=GND}
N 410 27530 410 27540 {
lab=GND}
N 470 27480 470 27530 {
lab=Y5}
N 470 27530 470 27540 {
lab=Y5}
N 480 27490 520 27490 {
lab=word458}
N 520 27490 560 27490 {
lab=word458}
N 490 27480 490 27530 {
lab=GND}
N 490 27530 490 27540 {
lab=GND}
N 550 27480 550 27530 {
lab=Y6}
N 550 27530 550 27540 {
lab=Y6}
N 560 27490 600 27490 {
lab=word458}
N 600 27490 640 27490 {
lab=word458}
N 570 27480 570 27530 {
lab=GND}
N 570 27530 570 27540 {
lab=GND}
N 630 27480 630 27530 {
lab=Y7}
N 630 27530 630 27540 {
lab=Y7}
C {devices/ipin.sym} 0 27550 0 0 {name=p482 lab=word459}

N 10 27600 40 27600 {
lab=GND}
N 40 27590 40 27600 {
lab=GND}
N 0 27550 40 27550 {
lab=word459}
N 40 27550 80 27550 {
lab=word459}
N 10 27540 10 27590 {
lab=GND}
N 10 27590 10 27600 {
lab=GND}
N 70 27540 70 27590 {
lab=Y0}
N 70 27590 70 27600 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27570 1 0 {name=M2041
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27600 120 27600 {
lab=GND}
N 120 27590 120 27600 {
lab=GND}
N 80 27550 120 27550 {
lab=word459}
N 120 27550 160 27550 {
lab=word459}
N 90 27540 90 27590 {
lab=GND}
N 90 27590 90 27600 {
lab=GND}
N 150 27540 150 27590 {
lab=Y1}
N 150 27590 150 27600 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27570 1 0 {name=M2042
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27600 200 27600 {
lab=GND}
N 200 27590 200 27600 {
lab=GND}
N 160 27550 200 27550 {
lab=word459}
N 200 27550 240 27550 {
lab=word459}
N 170 27540 170 27590 {
lab=GND}
N 170 27590 170 27600 {
lab=GND}
N 230 27540 230 27590 {
lab=Y2}
N 230 27590 230 27600 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27570 1 0 {name=M2043
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 27550 280 27550 {
lab=word459}
N 280 27550 320 27550 {
lab=word459}
N 250 27540 250 27590 {
lab=GND}
N 250 27590 250 27600 {
lab=GND}
N 310 27540 310 27590 {
lab=Y3}
N 310 27590 310 27600 {
lab=Y3}

N 330 27600 360 27600 {
lab=GND}
N 360 27590 360 27600 {
lab=GND}
N 320 27550 360 27550 {
lab=word459}
N 360 27550 400 27550 {
lab=word459}
N 330 27540 330 27590 {
lab=GND}
N 330 27590 330 27600 {
lab=GND}
N 390 27540 390 27590 {
lab=Y4}
N 390 27590 390 27600 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 27570 1 0 {name=M2044
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 27600 440 27600 {
lab=GND}
N 440 27590 440 27600 {
lab=GND}
N 400 27550 440 27550 {
lab=word459}
N 440 27550 480 27550 {
lab=word459}
N 410 27540 410 27590 {
lab=GND}
N 410 27590 410 27600 {
lab=GND}
N 470 27540 470 27590 {
lab=Y5}
N 470 27590 470 27600 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 27570 1 0 {name=M2045
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 27550 520 27550 {
lab=word459}
N 520 27550 560 27550 {
lab=word459}
N 490 27540 490 27590 {
lab=GND}
N 490 27590 490 27600 {
lab=GND}
N 550 27540 550 27590 {
lab=Y6}
N 550 27590 550 27600 {
lab=Y6}

N 570 27600 600 27600 {
lab=GND}
N 600 27590 600 27600 {
lab=GND}
N 560 27550 600 27550 {
lab=word459}
N 600 27550 640 27550 {
lab=word459}
N 570 27540 570 27590 {
lab=GND}
N 570 27590 570 27600 {
lab=GND}
N 630 27540 630 27590 {
lab=Y7}
N 630 27590 630 27600 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 27570 1 0 {name=M2046
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 27610 0 0 {name=p483 lab=word460}

N 10 27660 40 27660 {
lab=GND}
N 40 27650 40 27660 {
lab=GND}
N 0 27610 40 27610 {
lab=word460}
N 40 27610 80 27610 {
lab=word460}
N 10 27600 10 27650 {
lab=GND}
N 10 27650 10 27660 {
lab=GND}
N 70 27600 70 27650 {
lab=Y0}
N 70 27650 70 27660 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27630 1 0 {name=M2047
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27660 120 27660 {
lab=GND}
N 120 27650 120 27660 {
lab=GND}
N 80 27610 120 27610 {
lab=word460}
N 120 27610 160 27610 {
lab=word460}
N 90 27600 90 27650 {
lab=GND}
N 90 27650 90 27660 {
lab=GND}
N 150 27600 150 27650 {
lab=Y1}
N 150 27650 150 27660 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27630 1 0 {name=M2048
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27660 200 27660 {
lab=GND}
N 200 27650 200 27660 {
lab=GND}
N 160 27610 200 27610 {
lab=word460}
N 200 27610 240 27610 {
lab=word460}
N 170 27600 170 27650 {
lab=GND}
N 170 27650 170 27660 {
lab=GND}
N 230 27600 230 27650 {
lab=Y2}
N 230 27650 230 27660 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27630 1 0 {name=M2049
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 27610 280 27610 {
lab=word460}
N 280 27610 320 27610 {
lab=word460}
N 250 27600 250 27650 {
lab=GND}
N 250 27650 250 27660 {
lab=GND}
N 310 27600 310 27650 {
lab=Y3}
N 310 27650 310 27660 {
lab=Y3}

N 330 27660 360 27660 {
lab=GND}
N 360 27650 360 27660 {
lab=GND}
N 320 27610 360 27610 {
lab=word460}
N 360 27610 400 27610 {
lab=word460}
N 330 27600 330 27650 {
lab=GND}
N 330 27650 330 27660 {
lab=GND}
N 390 27600 390 27650 {
lab=Y4}
N 390 27650 390 27660 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 27630 1 0 {name=M2050
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 27610 440 27610 {
lab=word460}
N 440 27610 480 27610 {
lab=word460}
N 410 27600 410 27650 {
lab=GND}
N 410 27650 410 27660 {
lab=GND}
N 470 27600 470 27650 {
lab=Y5}
N 470 27650 470 27660 {
lab=Y5}

N 490 27660 520 27660 {
lab=GND}
N 520 27650 520 27660 {
lab=GND}
N 480 27610 520 27610 {
lab=word460}
N 520 27610 560 27610 {
lab=word460}
N 490 27600 490 27650 {
lab=GND}
N 490 27650 490 27660 {
lab=GND}
N 550 27600 550 27650 {
lab=Y6}
N 550 27650 550 27660 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 27630 1 0 {name=M2051
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 27610 600 27610 {
lab=word460}
N 600 27610 640 27610 {
lab=word460}
N 570 27600 570 27650 {
lab=GND}
N 570 27650 570 27660 {
lab=GND}
N 630 27600 630 27650 {
lab=Y7}
N 630 27650 630 27660 {
lab=Y7}
C {devices/ipin.sym} 0 27670 0 0 {name=p484 lab=word461}

N 10 27720 40 27720 {
lab=GND}
N 40 27710 40 27720 {
lab=GND}
N 0 27670 40 27670 {
lab=word461}
N 40 27670 80 27670 {
lab=word461}
N 10 27660 10 27710 {
lab=GND}
N 10 27710 10 27720 {
lab=GND}
N 70 27660 70 27710 {
lab=Y0}
N 70 27710 70 27720 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27690 1 0 {name=M2052
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27720 120 27720 {
lab=GND}
N 120 27710 120 27720 {
lab=GND}
N 80 27670 120 27670 {
lab=word461}
N 120 27670 160 27670 {
lab=word461}
N 90 27660 90 27710 {
lab=GND}
N 90 27710 90 27720 {
lab=GND}
N 150 27660 150 27710 {
lab=Y1}
N 150 27710 150 27720 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27690 1 0 {name=M2053
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27720 200 27720 {
lab=GND}
N 200 27710 200 27720 {
lab=GND}
N 160 27670 200 27670 {
lab=word461}
N 200 27670 240 27670 {
lab=word461}
N 170 27660 170 27710 {
lab=GND}
N 170 27710 170 27720 {
lab=GND}
N 230 27660 230 27710 {
lab=Y2}
N 230 27710 230 27720 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27690 1 0 {name=M2054
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 27670 280 27670 {
lab=word461}
N 280 27670 320 27670 {
lab=word461}
N 250 27660 250 27710 {
lab=GND}
N 250 27710 250 27720 {
lab=GND}
N 310 27660 310 27710 {
lab=Y3}
N 310 27710 310 27720 {
lab=Y3}
N 320 27670 360 27670 {
lab=word461}
N 360 27670 400 27670 {
lab=word461}
N 330 27660 330 27710 {
lab=GND}
N 330 27710 330 27720 {
lab=GND}
N 390 27660 390 27710 {
lab=Y4}
N 390 27710 390 27720 {
lab=Y4}

N 410 27720 440 27720 {
lab=GND}
N 440 27710 440 27720 {
lab=GND}
N 400 27670 440 27670 {
lab=word461}
N 440 27670 480 27670 {
lab=word461}
N 410 27660 410 27710 {
lab=GND}
N 410 27710 410 27720 {
lab=GND}
N 470 27660 470 27710 {
lab=Y5}
N 470 27710 470 27720 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 27690 1 0 {name=M2055
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 27720 520 27720 {
lab=GND}
N 520 27710 520 27720 {
lab=GND}
N 480 27670 520 27670 {
lab=word461}
N 520 27670 560 27670 {
lab=word461}
N 490 27660 490 27710 {
lab=GND}
N 490 27710 490 27720 {
lab=GND}
N 550 27660 550 27710 {
lab=Y6}
N 550 27710 550 27720 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 27690 1 0 {name=M2056
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 27670 600 27670 {
lab=word461}
N 600 27670 640 27670 {
lab=word461}
N 570 27660 570 27710 {
lab=GND}
N 570 27710 570 27720 {
lab=GND}
N 630 27660 630 27710 {
lab=Y7}
N 630 27710 630 27720 {
lab=Y7}
C {devices/ipin.sym} 0 27730 0 0 {name=p485 lab=word462}

N 10 27780 40 27780 {
lab=GND}
N 40 27770 40 27780 {
lab=GND}
N 0 27730 40 27730 {
lab=word462}
N 40 27730 80 27730 {
lab=word462}
N 10 27720 10 27770 {
lab=GND}
N 10 27770 10 27780 {
lab=GND}
N 70 27720 70 27770 {
lab=Y0}
N 70 27770 70 27780 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27750 1 0 {name=M2057
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27780 120 27780 {
lab=GND}
N 120 27770 120 27780 {
lab=GND}
N 80 27730 120 27730 {
lab=word462}
N 120 27730 160 27730 {
lab=word462}
N 90 27720 90 27770 {
lab=GND}
N 90 27770 90 27780 {
lab=GND}
N 150 27720 150 27770 {
lab=Y1}
N 150 27770 150 27780 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27750 1 0 {name=M2058
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 27780 200 27780 {
lab=GND}
N 200 27770 200 27780 {
lab=GND}
N 160 27730 200 27730 {
lab=word462}
N 200 27730 240 27730 {
lab=word462}
N 170 27720 170 27770 {
lab=GND}
N 170 27770 170 27780 {
lab=GND}
N 230 27720 230 27770 {
lab=Y2}
N 230 27770 230 27780 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 27750 1 0 {name=M2059
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 27730 280 27730 {
lab=word462}
N 280 27730 320 27730 {
lab=word462}
N 250 27720 250 27770 {
lab=GND}
N 250 27770 250 27780 {
lab=GND}
N 310 27720 310 27770 {
lab=Y3}
N 310 27770 310 27780 {
lab=Y3}
N 320 27730 360 27730 {
lab=word462}
N 360 27730 400 27730 {
lab=word462}
N 330 27720 330 27770 {
lab=GND}
N 330 27770 330 27780 {
lab=GND}
N 390 27720 390 27770 {
lab=Y4}
N 390 27770 390 27780 {
lab=Y4}
N 400 27730 440 27730 {
lab=word462}
N 440 27730 480 27730 {
lab=word462}
N 410 27720 410 27770 {
lab=GND}
N 410 27770 410 27780 {
lab=GND}
N 470 27720 470 27770 {
lab=Y5}
N 470 27770 470 27780 {
lab=Y5}

N 490 27780 520 27780 {
lab=GND}
N 520 27770 520 27780 {
lab=GND}
N 480 27730 520 27730 {
lab=word462}
N 520 27730 560 27730 {
lab=word462}
N 490 27720 490 27770 {
lab=GND}
N 490 27770 490 27780 {
lab=GND}
N 550 27720 550 27770 {
lab=Y6}
N 550 27770 550 27780 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 27750 1 0 {name=M2060
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 27730 600 27730 {
lab=word462}
N 600 27730 640 27730 {
lab=word462}
N 570 27720 570 27770 {
lab=GND}
N 570 27770 570 27780 {
lab=GND}
N 630 27720 630 27770 {
lab=Y7}
N 630 27770 630 27780 {
lab=Y7}
C {devices/ipin.sym} 0 27790 0 0 {name=p486 lab=word463}

N 10 27840 40 27840 {
lab=GND}
N 40 27830 40 27840 {
lab=GND}
N 0 27790 40 27790 {
lab=word463}
N 40 27790 80 27790 {
lab=word463}
N 10 27780 10 27830 {
lab=GND}
N 10 27830 10 27840 {
lab=GND}
N 70 27780 70 27830 {
lab=Y0}
N 70 27830 70 27840 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27810 1 0 {name=M2061
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27840 120 27840 {
lab=GND}
N 120 27830 120 27840 {
lab=GND}
N 80 27790 120 27790 {
lab=word463}
N 120 27790 160 27790 {
lab=word463}
N 90 27780 90 27830 {
lab=GND}
N 90 27830 90 27840 {
lab=GND}
N 150 27780 150 27830 {
lab=Y1}
N 150 27830 150 27840 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27810 1 0 {name=M2062
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 27790 200 27790 {
lab=word463}
N 200 27790 240 27790 {
lab=word463}
N 170 27780 170 27830 {
lab=GND}
N 170 27830 170 27840 {
lab=GND}
N 230 27780 230 27830 {
lab=Y2}
N 230 27830 230 27840 {
lab=Y2}

N 250 27840 280 27840 {
lab=GND}
N 280 27830 280 27840 {
lab=GND}
N 240 27790 280 27790 {
lab=word463}
N 280 27790 320 27790 {
lab=word463}
N 250 27780 250 27830 {
lab=GND}
N 250 27830 250 27840 {
lab=GND}
N 310 27780 310 27830 {
lab=Y3}
N 310 27830 310 27840 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27810 1 0 {name=M2063
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 27840 360 27840 {
lab=GND}
N 360 27830 360 27840 {
lab=GND}
N 320 27790 360 27790 {
lab=word463}
N 360 27790 400 27790 {
lab=word463}
N 330 27780 330 27830 {
lab=GND}
N 330 27830 330 27840 {
lab=GND}
N 390 27780 390 27830 {
lab=Y4}
N 390 27830 390 27840 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 27810 1 0 {name=M2064
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 27840 440 27840 {
lab=GND}
N 440 27830 440 27840 {
lab=GND}
N 400 27790 440 27790 {
lab=word463}
N 440 27790 480 27790 {
lab=word463}
N 410 27780 410 27830 {
lab=GND}
N 410 27830 410 27840 {
lab=GND}
N 470 27780 470 27830 {
lab=Y5}
N 470 27830 470 27840 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 27810 1 0 {name=M2065
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 27840 520 27840 {
lab=GND}
N 520 27830 520 27840 {
lab=GND}
N 480 27790 520 27790 {
lab=word463}
N 520 27790 560 27790 {
lab=word463}
N 490 27780 490 27830 {
lab=GND}
N 490 27830 490 27840 {
lab=GND}
N 550 27780 550 27830 {
lab=Y6}
N 550 27830 550 27840 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 27810 1 0 {name=M2066
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 27790 600 27790 {
lab=word463}
N 600 27790 640 27790 {
lab=word463}
N 570 27780 570 27830 {
lab=GND}
N 570 27830 570 27840 {
lab=GND}
N 630 27780 630 27830 {
lab=Y7}
N 630 27830 630 27840 {
lab=Y7}
C {devices/ipin.sym} 0 27850 0 0 {name=p487 lab=word464}

N 10 27900 40 27900 {
lab=GND}
N 40 27890 40 27900 {
lab=GND}
N 0 27850 40 27850 {
lab=word464}
N 40 27850 80 27850 {
lab=word464}
N 10 27840 10 27890 {
lab=GND}
N 10 27890 10 27900 {
lab=GND}
N 70 27840 70 27890 {
lab=Y0}
N 70 27890 70 27900 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27870 1 0 {name=M2067
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27900 120 27900 {
lab=GND}
N 120 27890 120 27900 {
lab=GND}
N 80 27850 120 27850 {
lab=word464}
N 120 27850 160 27850 {
lab=word464}
N 90 27840 90 27890 {
lab=GND}
N 90 27890 90 27900 {
lab=GND}
N 150 27840 150 27890 {
lab=Y1}
N 150 27890 150 27900 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27870 1 0 {name=M2068
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 27850 200 27850 {
lab=word464}
N 200 27850 240 27850 {
lab=word464}
N 170 27840 170 27890 {
lab=GND}
N 170 27890 170 27900 {
lab=GND}
N 230 27840 230 27890 {
lab=Y2}
N 230 27890 230 27900 {
lab=Y2}

N 250 27900 280 27900 {
lab=GND}
N 280 27890 280 27900 {
lab=GND}
N 240 27850 280 27850 {
lab=word464}
N 280 27850 320 27850 {
lab=word464}
N 250 27840 250 27890 {
lab=GND}
N 250 27890 250 27900 {
lab=GND}
N 310 27840 310 27890 {
lab=Y3}
N 310 27890 310 27900 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27870 1 0 {name=M2069
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 27900 360 27900 {
lab=GND}
N 360 27890 360 27900 {
lab=GND}
N 320 27850 360 27850 {
lab=word464}
N 360 27850 400 27850 {
lab=word464}
N 330 27840 330 27890 {
lab=GND}
N 330 27890 330 27900 {
lab=GND}
N 390 27840 390 27890 {
lab=Y4}
N 390 27890 390 27900 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 27870 1 0 {name=M2070
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 27850 440 27850 {
lab=word464}
N 440 27850 480 27850 {
lab=word464}
N 410 27840 410 27890 {
lab=GND}
N 410 27890 410 27900 {
lab=GND}
N 470 27840 470 27890 {
lab=Y5}
N 470 27890 470 27900 {
lab=Y5}

N 490 27900 520 27900 {
lab=GND}
N 520 27890 520 27900 {
lab=GND}
N 480 27850 520 27850 {
lab=word464}
N 520 27850 560 27850 {
lab=word464}
N 490 27840 490 27890 {
lab=GND}
N 490 27890 490 27900 {
lab=GND}
N 550 27840 550 27890 {
lab=Y6}
N 550 27890 550 27900 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 27870 1 0 {name=M2071
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 27850 600 27850 {
lab=word464}
N 600 27850 640 27850 {
lab=word464}
N 570 27840 570 27890 {
lab=GND}
N 570 27890 570 27900 {
lab=GND}
N 630 27840 630 27890 {
lab=Y7}
N 630 27890 630 27900 {
lab=Y7}
C {devices/ipin.sym} 0 27910 0 0 {name=p488 lab=word465}

N 10 27960 40 27960 {
lab=GND}
N 40 27950 40 27960 {
lab=GND}
N 0 27910 40 27910 {
lab=word465}
N 40 27910 80 27910 {
lab=word465}
N 10 27900 10 27950 {
lab=GND}
N 10 27950 10 27960 {
lab=GND}
N 70 27900 70 27950 {
lab=Y0}
N 70 27950 70 27960 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27930 1 0 {name=M2072
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 27960 120 27960 {
lab=GND}
N 120 27950 120 27960 {
lab=GND}
N 80 27910 120 27910 {
lab=word465}
N 120 27910 160 27910 {
lab=word465}
N 90 27900 90 27950 {
lab=GND}
N 90 27950 90 27960 {
lab=GND}
N 150 27900 150 27950 {
lab=Y1}
N 150 27950 150 27960 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27930 1 0 {name=M2073
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 27910 200 27910 {
lab=word465}
N 200 27910 240 27910 {
lab=word465}
N 170 27900 170 27950 {
lab=GND}
N 170 27950 170 27960 {
lab=GND}
N 230 27900 230 27950 {
lab=Y2}
N 230 27950 230 27960 {
lab=Y2}

N 250 27960 280 27960 {
lab=GND}
N 280 27950 280 27960 {
lab=GND}
N 240 27910 280 27910 {
lab=word465}
N 280 27910 320 27910 {
lab=word465}
N 250 27900 250 27950 {
lab=GND}
N 250 27950 250 27960 {
lab=GND}
N 310 27900 310 27950 {
lab=Y3}
N 310 27950 310 27960 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27930 1 0 {name=M2074
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 27910 360 27910 {
lab=word465}
N 360 27910 400 27910 {
lab=word465}
N 330 27900 330 27950 {
lab=GND}
N 330 27950 330 27960 {
lab=GND}
N 390 27900 390 27950 {
lab=Y4}
N 390 27950 390 27960 {
lab=Y4}

N 410 27960 440 27960 {
lab=GND}
N 440 27950 440 27960 {
lab=GND}
N 400 27910 440 27910 {
lab=word465}
N 440 27910 480 27910 {
lab=word465}
N 410 27900 410 27950 {
lab=GND}
N 410 27950 410 27960 {
lab=GND}
N 470 27900 470 27950 {
lab=Y5}
N 470 27950 470 27960 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 27930 1 0 {name=M2075
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 27910 520 27910 {
lab=word465}
N 520 27910 560 27910 {
lab=word465}
N 490 27900 490 27950 {
lab=GND}
N 490 27950 490 27960 {
lab=GND}
N 550 27900 550 27950 {
lab=Y6}
N 550 27950 550 27960 {
lab=Y6}

N 570 27960 600 27960 {
lab=GND}
N 600 27950 600 27960 {
lab=GND}
N 560 27910 600 27910 {
lab=word465}
N 600 27910 640 27910 {
lab=word465}
N 570 27900 570 27950 {
lab=GND}
N 570 27950 570 27960 {
lab=GND}
N 630 27900 630 27950 {
lab=Y7}
N 630 27950 630 27960 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 27930 1 0 {name=M2076
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 27970 0 0 {name=p489 lab=word466}

N 10 28020 40 28020 {
lab=GND}
N 40 28010 40 28020 {
lab=GND}
N 0 27970 40 27970 {
lab=word466}
N 40 27970 80 27970 {
lab=word466}
N 10 27960 10 28010 {
lab=GND}
N 10 28010 10 28020 {
lab=GND}
N 70 27960 70 28010 {
lab=Y0}
N 70 28010 70 28020 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 27990 1 0 {name=M2077
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 28020 120 28020 {
lab=GND}
N 120 28010 120 28020 {
lab=GND}
N 80 27970 120 27970 {
lab=word466}
N 120 27970 160 27970 {
lab=word466}
N 90 27960 90 28010 {
lab=GND}
N 90 28010 90 28020 {
lab=GND}
N 150 27960 150 28010 {
lab=Y1}
N 150 28010 150 28020 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 27990 1 0 {name=M2078
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 27970 200 27970 {
lab=word466}
N 200 27970 240 27970 {
lab=word466}
N 170 27960 170 28010 {
lab=GND}
N 170 28010 170 28020 {
lab=GND}
N 230 27960 230 28010 {
lab=Y2}
N 230 28010 230 28020 {
lab=Y2}

N 250 28020 280 28020 {
lab=GND}
N 280 28010 280 28020 {
lab=GND}
N 240 27970 280 27970 {
lab=word466}
N 280 27970 320 27970 {
lab=word466}
N 250 27960 250 28010 {
lab=GND}
N 250 28010 250 28020 {
lab=GND}
N 310 27960 310 28010 {
lab=Y3}
N 310 28010 310 28020 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 27990 1 0 {name=M2079
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 27970 360 27970 {
lab=word466}
N 360 27970 400 27970 {
lab=word466}
N 330 27960 330 28010 {
lab=GND}
N 330 28010 330 28020 {
lab=GND}
N 390 27960 390 28010 {
lab=Y4}
N 390 28010 390 28020 {
lab=Y4}
N 400 27970 440 27970 {
lab=word466}
N 440 27970 480 27970 {
lab=word466}
N 410 27960 410 28010 {
lab=GND}
N 410 28010 410 28020 {
lab=GND}
N 470 27960 470 28010 {
lab=Y5}
N 470 28010 470 28020 {
lab=Y5}
N 480 27970 520 27970 {
lab=word466}
N 520 27970 560 27970 {
lab=word466}
N 490 27960 490 28010 {
lab=GND}
N 490 28010 490 28020 {
lab=GND}
N 550 27960 550 28010 {
lab=Y6}
N 550 28010 550 28020 {
lab=Y6}
N 560 27970 600 27970 {
lab=word466}
N 600 27970 640 27970 {
lab=word466}
N 570 27960 570 28010 {
lab=GND}
N 570 28010 570 28020 {
lab=GND}
N 630 27960 630 28010 {
lab=Y7}
N 630 28010 630 28020 {
lab=Y7}
C {devices/ipin.sym} 0 28030 0 0 {name=p490 lab=word467}

N 10 28080 40 28080 {
lab=GND}
N 40 28070 40 28080 {
lab=GND}
N 0 28030 40 28030 {
lab=word467}
N 40 28030 80 28030 {
lab=word467}
N 10 28020 10 28070 {
lab=GND}
N 10 28070 10 28080 {
lab=GND}
N 70 28020 70 28070 {
lab=Y0}
N 70 28070 70 28080 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28050 1 0 {name=M2080
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 28080 120 28080 {
lab=GND}
N 120 28070 120 28080 {
lab=GND}
N 80 28030 120 28030 {
lab=word467}
N 120 28030 160 28030 {
lab=word467}
N 90 28020 90 28070 {
lab=GND}
N 90 28070 90 28080 {
lab=GND}
N 150 28020 150 28070 {
lab=Y1}
N 150 28070 150 28080 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 28050 1 0 {name=M2081
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 28030 200 28030 {
lab=word467}
N 200 28030 240 28030 {
lab=word467}
N 170 28020 170 28070 {
lab=GND}
N 170 28070 170 28080 {
lab=GND}
N 230 28020 230 28070 {
lab=Y2}
N 230 28070 230 28080 {
lab=Y2}
N 240 28030 280 28030 {
lab=word467}
N 280 28030 320 28030 {
lab=word467}
N 250 28020 250 28070 {
lab=GND}
N 250 28070 250 28080 {
lab=GND}
N 310 28020 310 28070 {
lab=Y3}
N 310 28070 310 28080 {
lab=Y3}

N 330 28080 360 28080 {
lab=GND}
N 360 28070 360 28080 {
lab=GND}
N 320 28030 360 28030 {
lab=word467}
N 360 28030 400 28030 {
lab=word467}
N 330 28020 330 28070 {
lab=GND}
N 330 28070 330 28080 {
lab=GND}
N 390 28020 390 28070 {
lab=Y4}
N 390 28070 390 28080 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 28050 1 0 {name=M2082
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 28030 440 28030 {
lab=word467}
N 440 28030 480 28030 {
lab=word467}
N 410 28020 410 28070 {
lab=GND}
N 410 28070 410 28080 {
lab=GND}
N 470 28020 470 28070 {
lab=Y5}
N 470 28070 470 28080 {
lab=Y5}

N 490 28080 520 28080 {
lab=GND}
N 520 28070 520 28080 {
lab=GND}
N 480 28030 520 28030 {
lab=word467}
N 520 28030 560 28030 {
lab=word467}
N 490 28020 490 28070 {
lab=GND}
N 490 28070 490 28080 {
lab=GND}
N 550 28020 550 28070 {
lab=Y6}
N 550 28070 550 28080 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 28050 1 0 {name=M2083
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 28080 600 28080 {
lab=GND}
N 600 28070 600 28080 {
lab=GND}
N 560 28030 600 28030 {
lab=word467}
N 600 28030 640 28030 {
lab=word467}
N 570 28020 570 28070 {
lab=GND}
N 570 28070 570 28080 {
lab=GND}
N 630 28020 630 28070 {
lab=Y7}
N 630 28070 630 28080 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 28050 1 0 {name=M2084
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 28090 0 0 {name=p491 lab=word468}

N 10 28140 40 28140 {
lab=GND}
N 40 28130 40 28140 {
lab=GND}
N 0 28090 40 28090 {
lab=word468}
N 40 28090 80 28090 {
lab=word468}
N 10 28080 10 28130 {
lab=GND}
N 10 28130 10 28140 {
lab=GND}
N 70 28080 70 28130 {
lab=Y0}
N 70 28130 70 28140 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28110 1 0 {name=M2085
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 28140 120 28140 {
lab=GND}
N 120 28130 120 28140 {
lab=GND}
N 80 28090 120 28090 {
lab=word468}
N 120 28090 160 28090 {
lab=word468}
N 90 28080 90 28130 {
lab=GND}
N 90 28130 90 28140 {
lab=GND}
N 150 28080 150 28130 {
lab=Y1}
N 150 28130 150 28140 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 28110 1 0 {name=M2086
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 28090 200 28090 {
lab=word468}
N 200 28090 240 28090 {
lab=word468}
N 170 28080 170 28130 {
lab=GND}
N 170 28130 170 28140 {
lab=GND}
N 230 28080 230 28130 {
lab=Y2}
N 230 28130 230 28140 {
lab=Y2}
N 240 28090 280 28090 {
lab=word468}
N 280 28090 320 28090 {
lab=word468}
N 250 28080 250 28130 {
lab=GND}
N 250 28130 250 28140 {
lab=GND}
N 310 28080 310 28130 {
lab=Y3}
N 310 28130 310 28140 {
lab=Y3}
N 320 28090 360 28090 {
lab=word468}
N 360 28090 400 28090 {
lab=word468}
N 330 28080 330 28130 {
lab=GND}
N 330 28130 330 28140 {
lab=GND}
N 390 28080 390 28130 {
lab=Y4}
N 390 28130 390 28140 {
lab=Y4}

N 410 28140 440 28140 {
lab=GND}
N 440 28130 440 28140 {
lab=GND}
N 400 28090 440 28090 {
lab=word468}
N 440 28090 480 28090 {
lab=word468}
N 410 28080 410 28130 {
lab=GND}
N 410 28130 410 28140 {
lab=GND}
N 470 28080 470 28130 {
lab=Y5}
N 470 28130 470 28140 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 28110 1 0 {name=M2087
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 28140 520 28140 {
lab=GND}
N 520 28130 520 28140 {
lab=GND}
N 480 28090 520 28090 {
lab=word468}
N 520 28090 560 28090 {
lab=word468}
N 490 28080 490 28130 {
lab=GND}
N 490 28130 490 28140 {
lab=GND}
N 550 28080 550 28130 {
lab=Y6}
N 550 28130 550 28140 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 28110 1 0 {name=M2088
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 28090 600 28090 {
lab=word468}
N 600 28090 640 28090 {
lab=word468}
N 570 28080 570 28130 {
lab=GND}
N 570 28130 570 28140 {
lab=GND}
N 630 28080 630 28130 {
lab=Y7}
N 630 28130 630 28140 {
lab=Y7}
C {devices/ipin.sym} 0 28150 0 0 {name=p492 lab=word469}

N 10 28200 40 28200 {
lab=GND}
N 40 28190 40 28200 {
lab=GND}
N 0 28150 40 28150 {
lab=word469}
N 40 28150 80 28150 {
lab=word469}
N 10 28140 10 28190 {
lab=GND}
N 10 28190 10 28200 {
lab=GND}
N 70 28140 70 28190 {
lab=Y0}
N 70 28190 70 28200 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28170 1 0 {name=M2089
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 28200 120 28200 {
lab=GND}
N 120 28190 120 28200 {
lab=GND}
N 80 28150 120 28150 {
lab=word469}
N 120 28150 160 28150 {
lab=word469}
N 90 28140 90 28190 {
lab=GND}
N 90 28190 90 28200 {
lab=GND}
N 150 28140 150 28190 {
lab=Y1}
N 150 28190 150 28200 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 28170 1 0 {name=M2090
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 28150 200 28150 {
lab=word469}
N 200 28150 240 28150 {
lab=word469}
N 170 28140 170 28190 {
lab=GND}
N 170 28190 170 28200 {
lab=GND}
N 230 28140 230 28190 {
lab=Y2}
N 230 28190 230 28200 {
lab=Y2}
N 240 28150 280 28150 {
lab=word469}
N 280 28150 320 28150 {
lab=word469}
N 250 28140 250 28190 {
lab=GND}
N 250 28190 250 28200 {
lab=GND}
N 310 28140 310 28190 {
lab=Y3}
N 310 28190 310 28200 {
lab=Y3}
N 320 28150 360 28150 {
lab=word469}
N 360 28150 400 28150 {
lab=word469}
N 330 28140 330 28190 {
lab=GND}
N 330 28190 330 28200 {
lab=GND}
N 390 28140 390 28190 {
lab=Y4}
N 390 28190 390 28200 {
lab=Y4}
N 400 28150 440 28150 {
lab=word469}
N 440 28150 480 28150 {
lab=word469}
N 410 28140 410 28190 {
lab=GND}
N 410 28190 410 28200 {
lab=GND}
N 470 28140 470 28190 {
lab=Y5}
N 470 28190 470 28200 {
lab=Y5}
N 480 28150 520 28150 {
lab=word469}
N 520 28150 560 28150 {
lab=word469}
N 490 28140 490 28190 {
lab=GND}
N 490 28190 490 28200 {
lab=GND}
N 550 28140 550 28190 {
lab=Y6}
N 550 28190 550 28200 {
lab=Y6}

N 570 28200 600 28200 {
lab=GND}
N 600 28190 600 28200 {
lab=GND}
N 560 28150 600 28150 {
lab=word469}
N 600 28150 640 28150 {
lab=word469}
N 570 28140 570 28190 {
lab=GND}
N 570 28190 570 28200 {
lab=GND}
N 630 28140 630 28190 {
lab=Y7}
N 630 28190 630 28200 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 28170 1 0 {name=M2091
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 28210 0 0 {name=p493 lab=word470}

N 10 28260 40 28260 {
lab=GND}
N 40 28250 40 28260 {
lab=GND}
N 0 28210 40 28210 {
lab=word470}
N 40 28210 80 28210 {
lab=word470}
N 10 28200 10 28250 {
lab=GND}
N 10 28250 10 28260 {
lab=GND}
N 70 28200 70 28250 {
lab=Y0}
N 70 28250 70 28260 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28230 1 0 {name=M2092
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 28210 120 28210 {
lab=word470}
N 120 28210 160 28210 {
lab=word470}
N 90 28200 90 28250 {
lab=GND}
N 90 28250 90 28260 {
lab=GND}
N 150 28200 150 28250 {
lab=Y1}
N 150 28250 150 28260 {
lab=Y1}

N 170 28260 200 28260 {
lab=GND}
N 200 28250 200 28260 {
lab=GND}
N 160 28210 200 28210 {
lab=word470}
N 200 28210 240 28210 {
lab=word470}
N 170 28200 170 28250 {
lab=GND}
N 170 28250 170 28260 {
lab=GND}
N 230 28200 230 28250 {
lab=Y2}
N 230 28250 230 28260 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 28230 1 0 {name=M2093
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 28260 280 28260 {
lab=GND}
N 280 28250 280 28260 {
lab=GND}
N 240 28210 280 28210 {
lab=word470}
N 280 28210 320 28210 {
lab=word470}
N 250 28200 250 28250 {
lab=GND}
N 250 28250 250 28260 {
lab=GND}
N 310 28200 310 28250 {
lab=Y3}
N 310 28250 310 28260 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 28230 1 0 {name=M2094
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 28260 360 28260 {
lab=GND}
N 360 28250 360 28260 {
lab=GND}
N 320 28210 360 28210 {
lab=word470}
N 360 28210 400 28210 {
lab=word470}
N 330 28200 330 28250 {
lab=GND}
N 330 28250 330 28260 {
lab=GND}
N 390 28200 390 28250 {
lab=Y4}
N 390 28250 390 28260 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 28230 1 0 {name=M2095
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 28260 440 28260 {
lab=GND}
N 440 28250 440 28260 {
lab=GND}
N 400 28210 440 28210 {
lab=word470}
N 440 28210 480 28210 {
lab=word470}
N 410 28200 410 28250 {
lab=GND}
N 410 28250 410 28260 {
lab=GND}
N 470 28200 470 28250 {
lab=Y5}
N 470 28250 470 28260 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 28230 1 0 {name=M2096
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 28210 520 28210 {
lab=word470}
N 520 28210 560 28210 {
lab=word470}
N 490 28200 490 28250 {
lab=GND}
N 490 28250 490 28260 {
lab=GND}
N 550 28200 550 28250 {
lab=Y6}
N 550 28250 550 28260 {
lab=Y6}
N 560 28210 600 28210 {
lab=word470}
N 600 28210 640 28210 {
lab=word470}
N 570 28200 570 28250 {
lab=GND}
N 570 28250 570 28260 {
lab=GND}
N 630 28200 630 28250 {
lab=Y7}
N 630 28250 630 28260 {
lab=Y7}
C {devices/ipin.sym} 0 28270 0 0 {name=p494 lab=word471}

N 10 28320 40 28320 {
lab=GND}
N 40 28310 40 28320 {
lab=GND}
N 0 28270 40 28270 {
lab=word471}
N 40 28270 80 28270 {
lab=word471}
N 10 28260 10 28310 {
lab=GND}
N 10 28310 10 28320 {
lab=GND}
N 70 28260 70 28310 {
lab=Y0}
N 70 28310 70 28320 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28290 1 0 {name=M2097
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 28270 120 28270 {
lab=word471}
N 120 28270 160 28270 {
lab=word471}
N 90 28260 90 28310 {
lab=GND}
N 90 28310 90 28320 {
lab=GND}
N 150 28260 150 28310 {
lab=Y1}
N 150 28310 150 28320 {
lab=Y1}

N 170 28320 200 28320 {
lab=GND}
N 200 28310 200 28320 {
lab=GND}
N 160 28270 200 28270 {
lab=word471}
N 200 28270 240 28270 {
lab=word471}
N 170 28260 170 28310 {
lab=GND}
N 170 28310 170 28320 {
lab=GND}
N 230 28260 230 28310 {
lab=Y2}
N 230 28310 230 28320 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 28290 1 0 {name=M2098
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 28320 280 28320 {
lab=GND}
N 280 28310 280 28320 {
lab=GND}
N 240 28270 280 28270 {
lab=word471}
N 280 28270 320 28270 {
lab=word471}
N 250 28260 250 28310 {
lab=GND}
N 250 28310 250 28320 {
lab=GND}
N 310 28260 310 28310 {
lab=Y3}
N 310 28310 310 28320 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 28290 1 0 {name=M2099
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 28270 360 28270 {
lab=word471}
N 360 28270 400 28270 {
lab=word471}
N 330 28260 330 28310 {
lab=GND}
N 330 28310 330 28320 {
lab=GND}
N 390 28260 390 28310 {
lab=Y4}
N 390 28310 390 28320 {
lab=Y4}

N 410 28320 440 28320 {
lab=GND}
N 440 28310 440 28320 {
lab=GND}
N 400 28270 440 28270 {
lab=word471}
N 440 28270 480 28270 {
lab=word471}
N 410 28260 410 28310 {
lab=GND}
N 410 28310 410 28320 {
lab=GND}
N 470 28260 470 28310 {
lab=Y5}
N 470 28310 470 28320 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 28290 1 0 {name=M2100
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 28320 520 28320 {
lab=GND}
N 520 28310 520 28320 {
lab=GND}
N 480 28270 520 28270 {
lab=word471}
N 520 28270 560 28270 {
lab=word471}
N 490 28260 490 28310 {
lab=GND}
N 490 28310 490 28320 {
lab=GND}
N 550 28260 550 28310 {
lab=Y6}
N 550 28310 550 28320 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 28290 1 0 {name=M2101
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 28270 600 28270 {
lab=word471}
N 600 28270 640 28270 {
lab=word471}
N 570 28260 570 28310 {
lab=GND}
N 570 28310 570 28320 {
lab=GND}
N 630 28260 630 28310 {
lab=Y7}
N 630 28310 630 28320 {
lab=Y7}
C {devices/ipin.sym} 0 28330 0 0 {name=p495 lab=word472}

N 10 28380 40 28380 {
lab=GND}
N 40 28370 40 28380 {
lab=GND}
N 0 28330 40 28330 {
lab=word472}
N 40 28330 80 28330 {
lab=word472}
N 10 28320 10 28370 {
lab=GND}
N 10 28370 10 28380 {
lab=GND}
N 70 28320 70 28370 {
lab=Y0}
N 70 28370 70 28380 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28350 1 0 {name=M2102
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 28330 120 28330 {
lab=word472}
N 120 28330 160 28330 {
lab=word472}
N 90 28320 90 28370 {
lab=GND}
N 90 28370 90 28380 {
lab=GND}
N 150 28320 150 28370 {
lab=Y1}
N 150 28370 150 28380 {
lab=Y1}

N 170 28380 200 28380 {
lab=GND}
N 200 28370 200 28380 {
lab=GND}
N 160 28330 200 28330 {
lab=word472}
N 200 28330 240 28330 {
lab=word472}
N 170 28320 170 28370 {
lab=GND}
N 170 28370 170 28380 {
lab=GND}
N 230 28320 230 28370 {
lab=Y2}
N 230 28370 230 28380 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 28350 1 0 {name=M2103
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 28380 280 28380 {
lab=GND}
N 280 28370 280 28380 {
lab=GND}
N 240 28330 280 28330 {
lab=word472}
N 280 28330 320 28330 {
lab=word472}
N 250 28320 250 28370 {
lab=GND}
N 250 28370 250 28380 {
lab=GND}
N 310 28320 310 28370 {
lab=Y3}
N 310 28370 310 28380 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 28350 1 0 {name=M2104
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 28330 360 28330 {
lab=word472}
N 360 28330 400 28330 {
lab=word472}
N 330 28320 330 28370 {
lab=GND}
N 330 28370 330 28380 {
lab=GND}
N 390 28320 390 28370 {
lab=Y4}
N 390 28370 390 28380 {
lab=Y4}
N 400 28330 440 28330 {
lab=word472}
N 440 28330 480 28330 {
lab=word472}
N 410 28320 410 28370 {
lab=GND}
N 410 28370 410 28380 {
lab=GND}
N 470 28320 470 28370 {
lab=Y5}
N 470 28370 470 28380 {
lab=Y5}
N 480 28330 520 28330 {
lab=word472}
N 520 28330 560 28330 {
lab=word472}
N 490 28320 490 28370 {
lab=GND}
N 490 28370 490 28380 {
lab=GND}
N 550 28320 550 28370 {
lab=Y6}
N 550 28370 550 28380 {
lab=Y6}
N 560 28330 600 28330 {
lab=word472}
N 600 28330 640 28330 {
lab=word472}
N 570 28320 570 28370 {
lab=GND}
N 570 28370 570 28380 {
lab=GND}
N 630 28320 630 28370 {
lab=Y7}
N 630 28370 630 28380 {
lab=Y7}
C {devices/ipin.sym} 0 28390 0 0 {name=p496 lab=word473}

N 10 28440 40 28440 {
lab=GND}
N 40 28430 40 28440 {
lab=GND}
N 0 28390 40 28390 {
lab=word473}
N 40 28390 80 28390 {
lab=word473}
N 10 28380 10 28430 {
lab=GND}
N 10 28430 10 28440 {
lab=GND}
N 70 28380 70 28430 {
lab=Y0}
N 70 28430 70 28440 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28410 1 0 {name=M2105
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 28390 120 28390 {
lab=word473}
N 120 28390 160 28390 {
lab=word473}
N 90 28380 90 28430 {
lab=GND}
N 90 28430 90 28440 {
lab=GND}
N 150 28380 150 28430 {
lab=Y1}
N 150 28430 150 28440 {
lab=Y1}

N 170 28440 200 28440 {
lab=GND}
N 200 28430 200 28440 {
lab=GND}
N 160 28390 200 28390 {
lab=word473}
N 200 28390 240 28390 {
lab=word473}
N 170 28380 170 28430 {
lab=GND}
N 170 28430 170 28440 {
lab=GND}
N 230 28380 230 28430 {
lab=Y2}
N 230 28430 230 28440 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 28410 1 0 {name=M2106
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 28390 280 28390 {
lab=word473}
N 280 28390 320 28390 {
lab=word473}
N 250 28380 250 28430 {
lab=GND}
N 250 28430 250 28440 {
lab=GND}
N 310 28380 310 28430 {
lab=Y3}
N 310 28430 310 28440 {
lab=Y3}

N 330 28440 360 28440 {
lab=GND}
N 360 28430 360 28440 {
lab=GND}
N 320 28390 360 28390 {
lab=word473}
N 360 28390 400 28390 {
lab=word473}
N 330 28380 330 28430 {
lab=GND}
N 330 28430 330 28440 {
lab=GND}
N 390 28380 390 28430 {
lab=Y4}
N 390 28430 390 28440 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 28410 1 0 {name=M2107
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 28390 440 28390 {
lab=word473}
N 440 28390 480 28390 {
lab=word473}
N 410 28380 410 28430 {
lab=GND}
N 410 28430 410 28440 {
lab=GND}
N 470 28380 470 28430 {
lab=Y5}
N 470 28430 470 28440 {
lab=Y5}

N 490 28440 520 28440 {
lab=GND}
N 520 28430 520 28440 {
lab=GND}
N 480 28390 520 28390 {
lab=word473}
N 520 28390 560 28390 {
lab=word473}
N 490 28380 490 28430 {
lab=GND}
N 490 28430 490 28440 {
lab=GND}
N 550 28380 550 28430 {
lab=Y6}
N 550 28430 550 28440 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 28410 1 0 {name=M2108
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 28390 600 28390 {
lab=word473}
N 600 28390 640 28390 {
lab=word473}
N 570 28380 570 28430 {
lab=GND}
N 570 28430 570 28440 {
lab=GND}
N 630 28380 630 28430 {
lab=Y7}
N 630 28430 630 28440 {
lab=Y7}
C {devices/ipin.sym} 0 28450 0 0 {name=p497 lab=word474}

N 10 28500 40 28500 {
lab=GND}
N 40 28490 40 28500 {
lab=GND}
N 0 28450 40 28450 {
lab=word474}
N 40 28450 80 28450 {
lab=word474}
N 10 28440 10 28490 {
lab=GND}
N 10 28490 10 28500 {
lab=GND}
N 70 28440 70 28490 {
lab=Y0}
N 70 28490 70 28500 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28470 1 0 {name=M2109
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 28450 120 28450 {
lab=word474}
N 120 28450 160 28450 {
lab=word474}
N 90 28440 90 28490 {
lab=GND}
N 90 28490 90 28500 {
lab=GND}
N 150 28440 150 28490 {
lab=Y1}
N 150 28490 150 28500 {
lab=Y1}

N 170 28500 200 28500 {
lab=GND}
N 200 28490 200 28500 {
lab=GND}
N 160 28450 200 28450 {
lab=word474}
N 200 28450 240 28450 {
lab=word474}
N 170 28440 170 28490 {
lab=GND}
N 170 28490 170 28500 {
lab=GND}
N 230 28440 230 28490 {
lab=Y2}
N 230 28490 230 28500 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 28470 1 0 {name=M2110
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 28450 280 28450 {
lab=word474}
N 280 28450 320 28450 {
lab=word474}
N 250 28440 250 28490 {
lab=GND}
N 250 28490 250 28500 {
lab=GND}
N 310 28440 310 28490 {
lab=Y3}
N 310 28490 310 28500 {
lab=Y3}
N 320 28450 360 28450 {
lab=word474}
N 360 28450 400 28450 {
lab=word474}
N 330 28440 330 28490 {
lab=GND}
N 330 28490 330 28500 {
lab=GND}
N 390 28440 390 28490 {
lab=Y4}
N 390 28490 390 28500 {
lab=Y4}

N 410 28500 440 28500 {
lab=GND}
N 440 28490 440 28500 {
lab=GND}
N 400 28450 440 28450 {
lab=word474}
N 440 28450 480 28450 {
lab=word474}
N 410 28440 410 28490 {
lab=GND}
N 410 28490 410 28500 {
lab=GND}
N 470 28440 470 28490 {
lab=Y5}
N 470 28490 470 28500 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 28470 1 0 {name=M2111
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 28450 520 28450 {
lab=word474}
N 520 28450 560 28450 {
lab=word474}
N 490 28440 490 28490 {
lab=GND}
N 490 28490 490 28500 {
lab=GND}
N 550 28440 550 28490 {
lab=Y6}
N 550 28490 550 28500 {
lab=Y6}

N 570 28500 600 28500 {
lab=GND}
N 600 28490 600 28500 {
lab=GND}
N 560 28450 600 28450 {
lab=word474}
N 600 28450 640 28450 {
lab=word474}
N 570 28440 570 28490 {
lab=GND}
N 570 28490 570 28500 {
lab=GND}
N 630 28440 630 28490 {
lab=Y7}
N 630 28490 630 28500 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 28470 1 0 {name=M2112
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 28510 0 0 {name=p498 lab=word475}

N 10 28560 40 28560 {
lab=GND}
N 40 28550 40 28560 {
lab=GND}
N 0 28510 40 28510 {
lab=word475}
N 40 28510 80 28510 {
lab=word475}
N 10 28500 10 28550 {
lab=GND}
N 10 28550 10 28560 {
lab=GND}
N 70 28500 70 28550 {
lab=Y0}
N 70 28550 70 28560 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28530 1 0 {name=M2113
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 28510 120 28510 {
lab=word475}
N 120 28510 160 28510 {
lab=word475}
N 90 28500 90 28550 {
lab=GND}
N 90 28550 90 28560 {
lab=GND}
N 150 28500 150 28550 {
lab=Y1}
N 150 28550 150 28560 {
lab=Y1}
N 160 28510 200 28510 {
lab=word475}
N 200 28510 240 28510 {
lab=word475}
N 170 28500 170 28550 {
lab=GND}
N 170 28550 170 28560 {
lab=GND}
N 230 28500 230 28550 {
lab=Y2}
N 230 28550 230 28560 {
lab=Y2}

N 250 28560 280 28560 {
lab=GND}
N 280 28550 280 28560 {
lab=GND}
N 240 28510 280 28510 {
lab=word475}
N 280 28510 320 28510 {
lab=word475}
N 250 28500 250 28550 {
lab=GND}
N 250 28550 250 28560 {
lab=GND}
N 310 28500 310 28550 {
lab=Y3}
N 310 28550 310 28560 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 28530 1 0 {name=M2114
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 28560 360 28560 {
lab=GND}
N 360 28550 360 28560 {
lab=GND}
N 320 28510 360 28510 {
lab=word475}
N 360 28510 400 28510 {
lab=word475}
N 330 28500 330 28550 {
lab=GND}
N 330 28550 330 28560 {
lab=GND}
N 390 28500 390 28550 {
lab=Y4}
N 390 28550 390 28560 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 28530 1 0 {name=M2115
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 28560 440 28560 {
lab=GND}
N 440 28550 440 28560 {
lab=GND}
N 400 28510 440 28510 {
lab=word475}
N 440 28510 480 28510 {
lab=word475}
N 410 28500 410 28550 {
lab=GND}
N 410 28550 410 28560 {
lab=GND}
N 470 28500 470 28550 {
lab=Y5}
N 470 28550 470 28560 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 28530 1 0 {name=M2116
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 28560 520 28560 {
lab=GND}
N 520 28550 520 28560 {
lab=GND}
N 480 28510 520 28510 {
lab=word475}
N 520 28510 560 28510 {
lab=word475}
N 490 28500 490 28550 {
lab=GND}
N 490 28550 490 28560 {
lab=GND}
N 550 28500 550 28550 {
lab=Y6}
N 550 28550 550 28560 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 28530 1 0 {name=M2117
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 28510 600 28510 {
lab=word475}
N 600 28510 640 28510 {
lab=word475}
N 570 28500 570 28550 {
lab=GND}
N 570 28550 570 28560 {
lab=GND}
N 630 28500 630 28550 {
lab=Y7}
N 630 28550 630 28560 {
lab=Y7}
C {devices/ipin.sym} 0 28570 0 0 {name=p499 lab=word476}

N 10 28620 40 28620 {
lab=GND}
N 40 28610 40 28620 {
lab=GND}
N 0 28570 40 28570 {
lab=word476}
N 40 28570 80 28570 {
lab=word476}
N 10 28560 10 28610 {
lab=GND}
N 10 28610 10 28620 {
lab=GND}
N 70 28560 70 28610 {
lab=Y0}
N 70 28610 70 28620 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28590 1 0 {name=M2118
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 28570 120 28570 {
lab=word476}
N 120 28570 160 28570 {
lab=word476}
N 90 28560 90 28610 {
lab=GND}
N 90 28610 90 28620 {
lab=GND}
N 150 28560 150 28610 {
lab=Y1}
N 150 28610 150 28620 {
lab=Y1}
N 160 28570 200 28570 {
lab=word476}
N 200 28570 240 28570 {
lab=word476}
N 170 28560 170 28610 {
lab=GND}
N 170 28610 170 28620 {
lab=GND}
N 230 28560 230 28610 {
lab=Y2}
N 230 28610 230 28620 {
lab=Y2}

N 250 28620 280 28620 {
lab=GND}
N 280 28610 280 28620 {
lab=GND}
N 240 28570 280 28570 {
lab=word476}
N 280 28570 320 28570 {
lab=word476}
N 250 28560 250 28610 {
lab=GND}
N 250 28610 250 28620 {
lab=GND}
N 310 28560 310 28610 {
lab=Y3}
N 310 28610 310 28620 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 28590 1 0 {name=M2119
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 28620 360 28620 {
lab=GND}
N 360 28610 360 28620 {
lab=GND}
N 320 28570 360 28570 {
lab=word476}
N 360 28570 400 28570 {
lab=word476}
N 330 28560 330 28610 {
lab=GND}
N 330 28610 330 28620 {
lab=GND}
N 390 28560 390 28610 {
lab=Y4}
N 390 28610 390 28620 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 28590 1 0 {name=M2120
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 28570 440 28570 {
lab=word476}
N 440 28570 480 28570 {
lab=word476}
N 410 28560 410 28610 {
lab=GND}
N 410 28610 410 28620 {
lab=GND}
N 470 28560 470 28610 {
lab=Y5}
N 470 28610 470 28620 {
lab=Y5}
N 480 28570 520 28570 {
lab=word476}
N 520 28570 560 28570 {
lab=word476}
N 490 28560 490 28610 {
lab=GND}
N 490 28610 490 28620 {
lab=GND}
N 550 28560 550 28610 {
lab=Y6}
N 550 28610 550 28620 {
lab=Y6}
N 560 28570 600 28570 {
lab=word476}
N 600 28570 640 28570 {
lab=word476}
N 570 28560 570 28610 {
lab=GND}
N 570 28610 570 28620 {
lab=GND}
N 630 28560 630 28610 {
lab=Y7}
N 630 28610 630 28620 {
lab=Y7}
C {devices/ipin.sym} 0 28630 0 0 {name=p500 lab=word477}

N 10 28680 40 28680 {
lab=GND}
N 40 28670 40 28680 {
lab=GND}
N 0 28630 40 28630 {
lab=word477}
N 40 28630 80 28630 {
lab=word477}
N 10 28620 10 28670 {
lab=GND}
N 10 28670 10 28680 {
lab=GND}
N 70 28620 70 28670 {
lab=Y0}
N 70 28670 70 28680 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28650 1 0 {name=M2121
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 28630 120 28630 {
lab=word477}
N 120 28630 160 28630 {
lab=word477}
N 90 28620 90 28670 {
lab=GND}
N 90 28670 90 28680 {
lab=GND}
N 150 28620 150 28670 {
lab=Y1}
N 150 28670 150 28680 {
lab=Y1}
N 160 28630 200 28630 {
lab=word477}
N 200 28630 240 28630 {
lab=word477}
N 170 28620 170 28670 {
lab=GND}
N 170 28670 170 28680 {
lab=GND}
N 230 28620 230 28670 {
lab=Y2}
N 230 28670 230 28680 {
lab=Y2}

N 250 28680 280 28680 {
lab=GND}
N 280 28670 280 28680 {
lab=GND}
N 240 28630 280 28630 {
lab=word477}
N 280 28630 320 28630 {
lab=word477}
N 250 28620 250 28670 {
lab=GND}
N 250 28670 250 28680 {
lab=GND}
N 310 28620 310 28670 {
lab=Y3}
N 310 28670 310 28680 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 28650 1 0 {name=M2122
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 28630 360 28630 {
lab=word477}
N 360 28630 400 28630 {
lab=word477}
N 330 28620 330 28670 {
lab=GND}
N 330 28670 330 28680 {
lab=GND}
N 390 28620 390 28670 {
lab=Y4}
N 390 28670 390 28680 {
lab=Y4}
N 400 28630 440 28630 {
lab=word477}
N 440 28630 480 28630 {
lab=word477}
N 410 28620 410 28670 {
lab=GND}
N 410 28670 410 28680 {
lab=GND}
N 470 28620 470 28670 {
lab=Y5}
N 470 28670 470 28680 {
lab=Y5}

N 490 28680 520 28680 {
lab=GND}
N 520 28670 520 28680 {
lab=GND}
N 480 28630 520 28630 {
lab=word477}
N 520 28630 560 28630 {
lab=word477}
N 490 28620 490 28670 {
lab=GND}
N 490 28670 490 28680 {
lab=GND}
N 550 28620 550 28670 {
lab=Y6}
N 550 28670 550 28680 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 28650 1 0 {name=M2123
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 28630 600 28630 {
lab=word477}
N 600 28630 640 28630 {
lab=word477}
N 570 28620 570 28670 {
lab=GND}
N 570 28670 570 28680 {
lab=GND}
N 630 28620 630 28670 {
lab=Y7}
N 630 28670 630 28680 {
lab=Y7}
C {devices/ipin.sym} 0 28690 0 0 {name=p501 lab=word478}

N 10 28740 40 28740 {
lab=GND}
N 40 28730 40 28740 {
lab=GND}
N 0 28690 40 28690 {
lab=word478}
N 40 28690 80 28690 {
lab=word478}
N 10 28680 10 28730 {
lab=GND}
N 10 28730 10 28740 {
lab=GND}
N 70 28680 70 28730 {
lab=Y0}
N 70 28730 70 28740 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28710 1 0 {name=M2124
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 28690 120 28690 {
lab=word478}
N 120 28690 160 28690 {
lab=word478}
N 90 28680 90 28730 {
lab=GND}
N 90 28730 90 28740 {
lab=GND}
N 150 28680 150 28730 {
lab=Y1}
N 150 28730 150 28740 {
lab=Y1}
N 160 28690 200 28690 {
lab=word478}
N 200 28690 240 28690 {
lab=word478}
N 170 28680 170 28730 {
lab=GND}
N 170 28730 170 28740 {
lab=GND}
N 230 28680 230 28730 {
lab=Y2}
N 230 28730 230 28740 {
lab=Y2}
N 240 28690 280 28690 {
lab=word478}
N 280 28690 320 28690 {
lab=word478}
N 250 28680 250 28730 {
lab=GND}
N 250 28730 250 28740 {
lab=GND}
N 310 28680 310 28730 {
lab=Y3}
N 310 28730 310 28740 {
lab=Y3}

N 330 28740 360 28740 {
lab=GND}
N 360 28730 360 28740 {
lab=GND}
N 320 28690 360 28690 {
lab=word478}
N 360 28690 400 28690 {
lab=word478}
N 330 28680 330 28730 {
lab=GND}
N 330 28730 330 28740 {
lab=GND}
N 390 28680 390 28730 {
lab=Y4}
N 390 28730 390 28740 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 28710 1 0 {name=M2125
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 28740 440 28740 {
lab=GND}
N 440 28730 440 28740 {
lab=GND}
N 400 28690 440 28690 {
lab=word478}
N 440 28690 480 28690 {
lab=word478}
N 410 28680 410 28730 {
lab=GND}
N 410 28730 410 28740 {
lab=GND}
N 470 28680 470 28730 {
lab=Y5}
N 470 28730 470 28740 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 28710 1 0 {name=M2126
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 28690 520 28690 {
lab=word478}
N 520 28690 560 28690 {
lab=word478}
N 490 28680 490 28730 {
lab=GND}
N 490 28730 490 28740 {
lab=GND}
N 550 28680 550 28730 {
lab=Y6}
N 550 28730 550 28740 {
lab=Y6}
N 560 28690 600 28690 {
lab=word478}
N 600 28690 640 28690 {
lab=word478}
N 570 28680 570 28730 {
lab=GND}
N 570 28730 570 28740 {
lab=GND}
N 630 28680 630 28730 {
lab=Y7}
N 630 28730 630 28740 {
lab=Y7}
C {devices/ipin.sym} 0 28750 0 0 {name=p502 lab=word479}

N 10 28800 40 28800 {
lab=GND}
N 40 28790 40 28800 {
lab=GND}
N 0 28750 40 28750 {
lab=word479}
N 40 28750 80 28750 {
lab=word479}
N 10 28740 10 28790 {
lab=GND}
N 10 28790 10 28800 {
lab=GND}
N 70 28740 70 28790 {
lab=Y0}
N 70 28790 70 28800 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28770 1 0 {name=M2127
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 28750 120 28750 {
lab=word479}
N 120 28750 160 28750 {
lab=word479}
N 90 28740 90 28790 {
lab=GND}
N 90 28790 90 28800 {
lab=GND}
N 150 28740 150 28790 {
lab=Y1}
N 150 28790 150 28800 {
lab=Y1}
N 160 28750 200 28750 {
lab=word479}
N 200 28750 240 28750 {
lab=word479}
N 170 28740 170 28790 {
lab=GND}
N 170 28790 170 28800 {
lab=GND}
N 230 28740 230 28790 {
lab=Y2}
N 230 28790 230 28800 {
lab=Y2}
N 240 28750 280 28750 {
lab=word479}
N 280 28750 320 28750 {
lab=word479}
N 250 28740 250 28790 {
lab=GND}
N 250 28790 250 28800 {
lab=GND}
N 310 28740 310 28790 {
lab=Y3}
N 310 28790 310 28800 {
lab=Y3}
N 320 28750 360 28750 {
lab=word479}
N 360 28750 400 28750 {
lab=word479}
N 330 28740 330 28790 {
lab=GND}
N 330 28790 330 28800 {
lab=GND}
N 390 28740 390 28790 {
lab=Y4}
N 390 28790 390 28800 {
lab=Y4}

N 410 28800 440 28800 {
lab=GND}
N 440 28790 440 28800 {
lab=GND}
N 400 28750 440 28750 {
lab=word479}
N 440 28750 480 28750 {
lab=word479}
N 410 28740 410 28790 {
lab=GND}
N 410 28790 410 28800 {
lab=GND}
N 470 28740 470 28790 {
lab=Y5}
N 470 28790 470 28800 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 28770 1 0 {name=M2128
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 28800 520 28800 {
lab=GND}
N 520 28790 520 28800 {
lab=GND}
N 480 28750 520 28750 {
lab=word479}
N 520 28750 560 28750 {
lab=word479}
N 490 28740 490 28790 {
lab=GND}
N 490 28790 490 28800 {
lab=GND}
N 550 28740 550 28790 {
lab=Y6}
N 550 28790 550 28800 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 28770 1 0 {name=M2129
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 28750 600 28750 {
lab=word479}
N 600 28750 640 28750 {
lab=word479}
N 570 28740 570 28790 {
lab=GND}
N 570 28790 570 28800 {
lab=GND}
N 630 28740 630 28790 {
lab=Y7}
N 630 28790 630 28800 {
lab=Y7}
C {devices/ipin.sym} 0 28810 0 0 {name=p503 lab=word480}

N 10 28860 40 28860 {
lab=GND}
N 40 28850 40 28860 {
lab=GND}
N 0 28810 40 28810 {
lab=word480}
N 40 28810 80 28810 {
lab=word480}
N 10 28800 10 28850 {
lab=GND}
N 10 28850 10 28860 {
lab=GND}
N 70 28800 70 28850 {
lab=Y0}
N 70 28850 70 28860 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 28830 1 0 {name=M2130
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 28810 120 28810 {
lab=word480}
N 120 28810 160 28810 {
lab=word480}
N 90 28800 90 28850 {
lab=GND}
N 90 28850 90 28860 {
lab=GND}
N 150 28800 150 28850 {
lab=Y1}
N 150 28850 150 28860 {
lab=Y1}
N 160 28810 200 28810 {
lab=word480}
N 200 28810 240 28810 {
lab=word480}
N 170 28800 170 28850 {
lab=GND}
N 170 28850 170 28860 {
lab=GND}
N 230 28800 230 28850 {
lab=Y2}
N 230 28850 230 28860 {
lab=Y2}
N 240 28810 280 28810 {
lab=word480}
N 280 28810 320 28810 {
lab=word480}
N 250 28800 250 28850 {
lab=GND}
N 250 28850 250 28860 {
lab=GND}
N 310 28800 310 28850 {
lab=Y3}
N 310 28850 310 28860 {
lab=Y3}
N 320 28810 360 28810 {
lab=word480}
N 360 28810 400 28810 {
lab=word480}
N 330 28800 330 28850 {
lab=GND}
N 330 28850 330 28860 {
lab=GND}
N 390 28800 390 28850 {
lab=Y4}
N 390 28850 390 28860 {
lab=Y4}
N 400 28810 440 28810 {
lab=word480}
N 440 28810 480 28810 {
lab=word480}
N 410 28800 410 28850 {
lab=GND}
N 410 28850 410 28860 {
lab=GND}
N 470 28800 470 28850 {
lab=Y5}
N 470 28850 470 28860 {
lab=Y5}
N 480 28810 520 28810 {
lab=word480}
N 520 28810 560 28810 {
lab=word480}
N 490 28800 490 28850 {
lab=GND}
N 490 28850 490 28860 {
lab=GND}
N 550 28800 550 28850 {
lab=Y6}
N 550 28850 550 28860 {
lab=Y6}
N 560 28810 600 28810 {
lab=word480}
N 600 28810 640 28810 {
lab=word480}
N 570 28800 570 28850 {
lab=GND}
N 570 28850 570 28860 {
lab=GND}
N 630 28800 630 28850 {
lab=Y7}
N 630 28850 630 28860 {
lab=Y7}
C {devices/ipin.sym} 0 28870 0 0 {name=p504 lab=word481}
N 0 28870 40 28870 {
lab=word481}
N 40 28870 80 28870 {
lab=word481}
N 10 28860 10 28910 {
lab=GND}
N 10 28910 10 28920 {
lab=GND}
N 70 28860 70 28910 {
lab=Y0}
N 70 28910 70 28920 {
lab=Y0}

N 90 28920 120 28920 {
lab=GND}
N 120 28910 120 28920 {
lab=GND}
N 80 28870 120 28870 {
lab=word481}
N 120 28870 160 28870 {
lab=word481}
N 90 28860 90 28910 {
lab=GND}
N 90 28910 90 28920 {
lab=GND}
N 150 28860 150 28910 {
lab=Y1}
N 150 28910 150 28920 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 28890 1 0 {name=M2131
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 28920 200 28920 {
lab=GND}
N 200 28910 200 28920 {
lab=GND}
N 160 28870 200 28870 {
lab=word481}
N 200 28870 240 28870 {
lab=word481}
N 170 28860 170 28910 {
lab=GND}
N 170 28910 170 28920 {
lab=GND}
N 230 28860 230 28910 {
lab=Y2}
N 230 28910 230 28920 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 28890 1 0 {name=M2132
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 28920 280 28920 {
lab=GND}
N 280 28910 280 28920 {
lab=GND}
N 240 28870 280 28870 {
lab=word481}
N 280 28870 320 28870 {
lab=word481}
N 250 28860 250 28910 {
lab=GND}
N 250 28910 250 28920 {
lab=GND}
N 310 28860 310 28910 {
lab=Y3}
N 310 28910 310 28920 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 28890 1 0 {name=M2133
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 28920 360 28920 {
lab=GND}
N 360 28910 360 28920 {
lab=GND}
N 320 28870 360 28870 {
lab=word481}
N 360 28870 400 28870 {
lab=word481}
N 330 28860 330 28910 {
lab=GND}
N 330 28910 330 28920 {
lab=GND}
N 390 28860 390 28910 {
lab=Y4}
N 390 28910 390 28920 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 28890 1 0 {name=M2134
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 28870 440 28870 {
lab=word481}
N 440 28870 480 28870 {
lab=word481}
N 410 28860 410 28910 {
lab=GND}
N 410 28910 410 28920 {
lab=GND}
N 470 28860 470 28910 {
lab=Y5}
N 470 28910 470 28920 {
lab=Y5}
N 480 28870 520 28870 {
lab=word481}
N 520 28870 560 28870 {
lab=word481}
N 490 28860 490 28910 {
lab=GND}
N 490 28910 490 28920 {
lab=GND}
N 550 28860 550 28910 {
lab=Y6}
N 550 28910 550 28920 {
lab=Y6}

N 570 28920 600 28920 {
lab=GND}
N 600 28910 600 28920 {
lab=GND}
N 560 28870 600 28870 {
lab=word481}
N 600 28870 640 28870 {
lab=word481}
N 570 28860 570 28910 {
lab=GND}
N 570 28910 570 28920 {
lab=GND}
N 630 28860 630 28910 {
lab=Y7}
N 630 28910 630 28920 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 28890 1 0 {name=M2135
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 28930 0 0 {name=p505 lab=word482}
N 0 28930 40 28930 {
lab=word482}
N 40 28930 80 28930 {
lab=word482}
N 10 28920 10 28970 {
lab=GND}
N 10 28970 10 28980 {
lab=GND}
N 70 28920 70 28970 {
lab=Y0}
N 70 28970 70 28980 {
lab=Y0}

N 90 28980 120 28980 {
lab=GND}
N 120 28970 120 28980 {
lab=GND}
N 80 28930 120 28930 {
lab=word482}
N 120 28930 160 28930 {
lab=word482}
N 90 28920 90 28970 {
lab=GND}
N 90 28970 90 28980 {
lab=GND}
N 150 28920 150 28970 {
lab=Y1}
N 150 28970 150 28980 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 28950 1 0 {name=M2136
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 28980 200 28980 {
lab=GND}
N 200 28970 200 28980 {
lab=GND}
N 160 28930 200 28930 {
lab=word482}
N 200 28930 240 28930 {
lab=word482}
N 170 28920 170 28970 {
lab=GND}
N 170 28970 170 28980 {
lab=GND}
N 230 28920 230 28970 {
lab=Y2}
N 230 28970 230 28980 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 28950 1 0 {name=M2137
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 28980 280 28980 {
lab=GND}
N 280 28970 280 28980 {
lab=GND}
N 240 28930 280 28930 {
lab=word482}
N 280 28930 320 28930 {
lab=word482}
N 250 28920 250 28970 {
lab=GND}
N 250 28970 250 28980 {
lab=GND}
N 310 28920 310 28970 {
lab=Y3}
N 310 28970 310 28980 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 28950 1 0 {name=M2138
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 28930 360 28930 {
lab=word482}
N 360 28930 400 28930 {
lab=word482}
N 330 28920 330 28970 {
lab=GND}
N 330 28970 330 28980 {
lab=GND}
N 390 28920 390 28970 {
lab=Y4}
N 390 28970 390 28980 {
lab=Y4}
N 400 28930 440 28930 {
lab=word482}
N 440 28930 480 28930 {
lab=word482}
N 410 28920 410 28970 {
lab=GND}
N 410 28970 410 28980 {
lab=GND}
N 470 28920 470 28970 {
lab=Y5}
N 470 28970 470 28980 {
lab=Y5}

N 490 28980 520 28980 {
lab=GND}
N 520 28970 520 28980 {
lab=GND}
N 480 28930 520 28930 {
lab=word482}
N 520 28930 560 28930 {
lab=word482}
N 490 28920 490 28970 {
lab=GND}
N 490 28970 490 28980 {
lab=GND}
N 550 28920 550 28970 {
lab=Y6}
N 550 28970 550 28980 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 28950 1 0 {name=M2139
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 28980 600 28980 {
lab=GND}
N 600 28970 600 28980 {
lab=GND}
N 560 28930 600 28930 {
lab=word482}
N 600 28930 640 28930 {
lab=word482}
N 570 28920 570 28970 {
lab=GND}
N 570 28970 570 28980 {
lab=GND}
N 630 28920 630 28970 {
lab=Y7}
N 630 28970 630 28980 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 28950 1 0 {name=M2140
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 28990 0 0 {name=p506 lab=word483}
N 0 28990 40 28990 {
lab=word483}
N 40 28990 80 28990 {
lab=word483}
N 10 28980 10 29030 {
lab=GND}
N 10 29030 10 29040 {
lab=GND}
N 70 28980 70 29030 {
lab=Y0}
N 70 29030 70 29040 {
lab=Y0}

N 90 29040 120 29040 {
lab=GND}
N 120 29030 120 29040 {
lab=GND}
N 80 28990 120 28990 {
lab=word483}
N 120 28990 160 28990 {
lab=word483}
N 90 28980 90 29030 {
lab=GND}
N 90 29030 90 29040 {
lab=GND}
N 150 28980 150 29030 {
lab=Y1}
N 150 29030 150 29040 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 29010 1 0 {name=M2141
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 29040 200 29040 {
lab=GND}
N 200 29030 200 29040 {
lab=GND}
N 160 28990 200 28990 {
lab=word483}
N 200 28990 240 28990 {
lab=word483}
N 170 28980 170 29030 {
lab=GND}
N 170 29030 170 29040 {
lab=GND}
N 230 28980 230 29030 {
lab=Y2}
N 230 29030 230 29040 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 29010 1 0 {name=M2142
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 28990 280 28990 {
lab=word483}
N 280 28990 320 28990 {
lab=word483}
N 250 28980 250 29030 {
lab=GND}
N 250 29030 250 29040 {
lab=GND}
N 310 28980 310 29030 {
lab=Y3}
N 310 29030 310 29040 {
lab=Y3}

N 330 29040 360 29040 {
lab=GND}
N 360 29030 360 29040 {
lab=GND}
N 320 28990 360 28990 {
lab=word483}
N 360 28990 400 28990 {
lab=word483}
N 330 28980 330 29030 {
lab=GND}
N 330 29030 330 29040 {
lab=GND}
N 390 28980 390 29030 {
lab=Y4}
N 390 29030 390 29040 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 29010 1 0 {name=M2143
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 29040 440 29040 {
lab=GND}
N 440 29030 440 29040 {
lab=GND}
N 400 28990 440 28990 {
lab=word483}
N 440 28990 480 28990 {
lab=word483}
N 410 28980 410 29030 {
lab=GND}
N 410 29030 410 29040 {
lab=GND}
N 470 28980 470 29030 {
lab=Y5}
N 470 29030 470 29040 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 29010 1 0 {name=M2144
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 28990 520 28990 {
lab=word483}
N 520 28990 560 28990 {
lab=word483}
N 490 28980 490 29030 {
lab=GND}
N 490 29030 490 29040 {
lab=GND}
N 550 28980 550 29030 {
lab=Y6}
N 550 29030 550 29040 {
lab=Y6}

N 570 29040 600 29040 {
lab=GND}
N 600 29030 600 29040 {
lab=GND}
N 560 28990 600 28990 {
lab=word483}
N 600 28990 640 28990 {
lab=word483}
N 570 28980 570 29030 {
lab=GND}
N 570 29030 570 29040 {
lab=GND}
N 630 28980 630 29030 {
lab=Y7}
N 630 29030 630 29040 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29010 1 0 {name=M2145
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 29050 0 0 {name=p507 lab=word484}
N 0 29050 40 29050 {
lab=word484}
N 40 29050 80 29050 {
lab=word484}
N 10 29040 10 29090 {
lab=GND}
N 10 29090 10 29100 {
lab=GND}
N 70 29040 70 29090 {
lab=Y0}
N 70 29090 70 29100 {
lab=Y0}

N 90 29100 120 29100 {
lab=GND}
N 120 29090 120 29100 {
lab=GND}
N 80 29050 120 29050 {
lab=word484}
N 120 29050 160 29050 {
lab=word484}
N 90 29040 90 29090 {
lab=GND}
N 90 29090 90 29100 {
lab=GND}
N 150 29040 150 29090 {
lab=Y1}
N 150 29090 150 29100 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 29070 1 0 {name=M2146
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 29100 200 29100 {
lab=GND}
N 200 29090 200 29100 {
lab=GND}
N 160 29050 200 29050 {
lab=word484}
N 200 29050 240 29050 {
lab=word484}
N 170 29040 170 29090 {
lab=GND}
N 170 29090 170 29100 {
lab=GND}
N 230 29040 230 29090 {
lab=Y2}
N 230 29090 230 29100 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 29070 1 0 {name=M2147
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 29050 280 29050 {
lab=word484}
