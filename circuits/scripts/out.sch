nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 14530 360 14530 {
lab=word242}
N 360 14530 400 14530 {
lab=word242}
N 330 14520 330 14570 {
lab=GND}
N 330 14570 330 14580 {
lab=GND}
N 390 14520 390 14570 {
lab=Y4}
N 390 14570 390 14580 {
lab=Y4}

N 410 14580 440 14580 {
lab=GND}
N 440 14570 440 14580 {
lab=GND}
N 400 14530 440 14530 {
lab=word242}
N 440 14530 480 14530 {
lab=word242}
N 410 14520 410 14570 {
lab=GND}
N 410 14570 410 14580 {
lab=GND}
N 470 14520 470 14570 {
lab=Y5}
N 470 14570 470 14580 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 14550 1 0 {name=M1102
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 14580 520 14580 {
lab=GND}
N 520 14570 520 14580 {
lab=GND}
N 480 14530 520 14530 {
lab=word242}
N 520 14530 560 14530 {
lab=word242}
N 490 14520 490 14570 {
lab=GND}
N 490 14570 490 14580 {
lab=GND}
N 550 14520 550 14570 {
lab=Y6}
N 550 14570 550 14580 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14550 1 0 {name=M1103
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14580 600 14580 {
lab=GND}
N 600 14570 600 14580 {
lab=GND}
N 560 14530 600 14530 {
lab=word242}
N 600 14530 640 14530 {
lab=word242}
N 570 14520 570 14570 {
lab=GND}
N 570 14570 570 14580 {
lab=GND}
N 630 14520 630 14570 {
lab=Y7}
N 630 14570 630 14580 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14550 1 0 {name=M1104
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14590 0 0 {name=p266 lab=word243}
N 0 14590 40 14590 {
lab=word243}
N 40 14590 80 14590 {
lab=word243}
N 10 14580 10 14630 {
lab=GND}
N 10 14630 10 14640 {
lab=GND}
N 70 14580 70 14630 {
lab=Y0}
N 70 14630 70 14640 {
lab=Y0}
N 80 14590 120 14590 {
lab=word243}
N 120 14590 160 14590 {
lab=word243}
N 90 14580 90 14630 {
lab=GND}
N 90 14630 90 14640 {
lab=GND}
N 150 14580 150 14630 {
lab=Y1}
N 150 14630 150 14640 {
lab=Y1}

N 170 14640 200 14640 {
lab=GND}
N 200 14630 200 14640 {
lab=GND}
N 160 14590 200 14590 {
lab=word243}
N 200 14590 240 14590 {
lab=word243}
N 170 14580 170 14630 {
lab=GND}
N 170 14630 170 14640 {
lab=GND}
N 230 14580 230 14630 {
lab=Y2}
N 230 14630 230 14640 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 14610 1 0 {name=M1105
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 14640 280 14640 {
lab=GND}
N 280 14630 280 14640 {
lab=GND}
N 240 14590 280 14590 {
lab=word243}
N 280 14590 320 14590 {
lab=word243}
N 250 14580 250 14630 {
lab=GND}
N 250 14630 250 14640 {
lab=GND}
N 310 14580 310 14630 {
lab=Y3}
N 310 14630 310 14640 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 14610 1 0 {name=M1106
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 14590 360 14590 {
lab=word243}
N 360 14590 400 14590 {
lab=word243}
N 330 14580 330 14630 {
lab=GND}
N 330 14630 330 14640 {
lab=GND}
N 390 14580 390 14630 {
lab=Y4}
N 390 14630 390 14640 {
lab=Y4}
N 400 14590 440 14590 {
lab=word243}
N 440 14590 480 14590 {
lab=word243}
N 410 14580 410 14630 {
lab=GND}
N 410 14630 410 14640 {
lab=GND}
N 470 14580 470 14630 {
lab=Y5}
N 470 14630 470 14640 {
lab=Y5}

N 490 14640 520 14640 {
lab=GND}
N 520 14630 520 14640 {
lab=GND}
N 480 14590 520 14590 {
lab=word243}
N 520 14590 560 14590 {
lab=word243}
N 490 14580 490 14630 {
lab=GND}
N 490 14630 490 14640 {
lab=GND}
N 550 14580 550 14630 {
lab=Y6}
N 550 14630 550 14640 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14610 1 0 {name=M1107
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14640 600 14640 {
lab=GND}
N 600 14630 600 14640 {
lab=GND}
N 560 14590 600 14590 {
lab=word243}
N 600 14590 640 14590 {
lab=word243}
N 570 14580 570 14630 {
lab=GND}
N 570 14630 570 14640 {
lab=GND}
N 630 14580 630 14630 {
lab=Y7}
N 630 14630 630 14640 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14610 1 0 {name=M1108
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14650 0 0 {name=p267 lab=word244}
N 0 14650 40 14650 {
lab=word244}
N 40 14650 80 14650 {
lab=word244}
N 10 14640 10 14690 {
lab=GND}
N 10 14690 10 14700 {
lab=GND}
N 70 14640 70 14690 {
lab=Y0}
N 70 14690 70 14700 {
lab=Y0}
N 80 14650 120 14650 {
lab=word244}
N 120 14650 160 14650 {
lab=word244}
N 90 14640 90 14690 {
lab=GND}
N 90 14690 90 14700 {
lab=GND}
N 150 14640 150 14690 {
lab=Y1}
N 150 14690 150 14700 {
lab=Y1}

N 170 14700 200 14700 {
lab=GND}
N 200 14690 200 14700 {
lab=GND}
N 160 14650 200 14650 {
lab=word244}
N 200 14650 240 14650 {
lab=word244}
N 170 14640 170 14690 {
lab=GND}
N 170 14690 170 14700 {
lab=GND}
N 230 14640 230 14690 {
lab=Y2}
N 230 14690 230 14700 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 14670 1 0 {name=M1109
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 14650 280 14650 {
lab=word244}
N 280 14650 320 14650 {
lab=word244}
N 250 14640 250 14690 {
lab=GND}
N 250 14690 250 14700 {
lab=GND}
N 310 14640 310 14690 {
lab=Y3}
N 310 14690 310 14700 {
lab=Y3}

N 330 14700 360 14700 {
lab=GND}
N 360 14690 360 14700 {
lab=GND}
N 320 14650 360 14650 {
lab=word244}
N 360 14650 400 14650 {
lab=word244}
N 330 14640 330 14690 {
lab=GND}
N 330 14690 330 14700 {
lab=GND}
N 390 14640 390 14690 {
lab=Y4}
N 390 14690 390 14700 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 14670 1 0 {name=M1110
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 14700 440 14700 {
lab=GND}
N 440 14690 440 14700 {
lab=GND}
N 400 14650 440 14650 {
lab=word244}
N 440 14650 480 14650 {
lab=word244}
N 410 14640 410 14690 {
lab=GND}
N 410 14690 410 14700 {
lab=GND}
N 470 14640 470 14690 {
lab=Y5}
N 470 14690 470 14700 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 14670 1 0 {name=M1111
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 14700 520 14700 {
lab=GND}
N 520 14690 520 14700 {
lab=GND}
N 480 14650 520 14650 {
lab=word244}
N 520 14650 560 14650 {
lab=word244}
N 490 14640 490 14690 {
lab=GND}
N 490 14690 490 14700 {
lab=GND}
N 550 14640 550 14690 {
lab=Y6}
N 550 14690 550 14700 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14670 1 0 {name=M1112
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14700 600 14700 {
lab=GND}
N 600 14690 600 14700 {
lab=GND}
N 560 14650 600 14650 {
lab=word244}
N 600 14650 640 14650 {
lab=word244}
N 570 14640 570 14690 {
lab=GND}
N 570 14690 570 14700 {
lab=GND}
N 630 14640 630 14690 {
lab=Y7}
N 630 14690 630 14700 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14670 1 0 {name=M1113
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14710 0 0 {name=p268 lab=word245}
N 0 14710 40 14710 {
lab=word245}
N 40 14710 80 14710 {
lab=word245}
N 10 14700 10 14750 {
lab=GND}
N 10 14750 10 14760 {
lab=GND}
N 70 14700 70 14750 {
lab=Y0}
N 70 14750 70 14760 {
lab=Y0}
N 80 14710 120 14710 {
lab=word245}
N 120 14710 160 14710 {
lab=word245}
N 90 14700 90 14750 {
lab=GND}
N 90 14750 90 14760 {
lab=GND}
N 150 14700 150 14750 {
lab=Y1}
N 150 14750 150 14760 {
lab=Y1}

N 170 14760 200 14760 {
lab=GND}
N 200 14750 200 14760 {
lab=GND}
N 160 14710 200 14710 {
lab=word245}
N 200 14710 240 14710 {
lab=word245}
N 170 14700 170 14750 {
lab=GND}
N 170 14750 170 14760 {
lab=GND}
N 230 14700 230 14750 {
lab=Y2}
N 230 14750 230 14760 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 14730 1 0 {name=M1114
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 14710 280 14710 {
lab=word245}
N 280 14710 320 14710 {
lab=word245}
N 250 14700 250 14750 {
lab=GND}
N 250 14750 250 14760 {
lab=GND}
N 310 14700 310 14750 {
lab=Y3}
N 310 14750 310 14760 {
lab=Y3}

N 330 14760 360 14760 {
lab=GND}
N 360 14750 360 14760 {
lab=GND}
N 320 14710 360 14710 {
lab=word245}
N 360 14710 400 14710 {
lab=word245}
N 330 14700 330 14750 {
lab=GND}
N 330 14750 330 14760 {
lab=GND}
N 390 14700 390 14750 {
lab=Y4}
N 390 14750 390 14760 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 14730 1 0 {name=M1115
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 14710 440 14710 {
lab=word245}
N 440 14710 480 14710 {
lab=word245}
N 410 14700 410 14750 {
lab=GND}
N 410 14750 410 14760 {
lab=GND}
N 470 14700 470 14750 {
lab=Y5}
N 470 14750 470 14760 {
lab=Y5}

N 490 14760 520 14760 {
lab=GND}
N 520 14750 520 14760 {
lab=GND}
N 480 14710 520 14710 {
lab=word245}
N 520 14710 560 14710 {
lab=word245}
N 490 14700 490 14750 {
lab=GND}
N 490 14750 490 14760 {
lab=GND}
N 550 14700 550 14750 {
lab=Y6}
N 550 14750 550 14760 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14730 1 0 {name=M1116
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14760 600 14760 {
lab=GND}
N 600 14750 600 14760 {
lab=GND}
N 560 14710 600 14710 {
lab=word245}
N 600 14710 640 14710 {
lab=word245}
N 570 14700 570 14750 {
lab=GND}
N 570 14750 570 14760 {
lab=GND}
N 630 14700 630 14750 {
lab=Y7}
N 630 14750 630 14760 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14730 1 0 {name=M1117
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14770 0 0 {name=p269 lab=word246}
N 0 14770 40 14770 {
lab=word246}
N 40 14770 80 14770 {
lab=word246}
N 10 14760 10 14810 {
lab=GND}
N 10 14810 10 14820 {
lab=GND}
N 70 14760 70 14810 {
lab=Y0}
N 70 14810 70 14820 {
lab=Y0}
N 80 14770 120 14770 {
lab=word246}
N 120 14770 160 14770 {
lab=word246}
N 90 14760 90 14810 {
lab=GND}
N 90 14810 90 14820 {
lab=GND}
N 150 14760 150 14810 {
lab=Y1}
N 150 14810 150 14820 {
lab=Y1}

N 170 14820 200 14820 {
lab=GND}
N 200 14810 200 14820 {
lab=GND}
N 160 14770 200 14770 {
lab=word246}
N 200 14770 240 14770 {
lab=word246}
N 170 14760 170 14810 {
lab=GND}
N 170 14810 170 14820 {
lab=GND}
N 230 14760 230 14810 {
lab=Y2}
N 230 14810 230 14820 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 14790 1 0 {name=M1118
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 14770 280 14770 {
lab=word246}
N 280 14770 320 14770 {
lab=word246}
N 250 14760 250 14810 {
lab=GND}
N 250 14810 250 14820 {
lab=GND}
N 310 14760 310 14810 {
lab=Y3}
N 310 14810 310 14820 {
lab=Y3}
N 320 14770 360 14770 {
lab=word246}
N 360 14770 400 14770 {
lab=word246}
N 330 14760 330 14810 {
lab=GND}
N 330 14810 330 14820 {
lab=GND}
N 390 14760 390 14810 {
lab=Y4}
N 390 14810 390 14820 {
lab=Y4}

N 410 14820 440 14820 {
lab=GND}
N 440 14810 440 14820 {
lab=GND}
N 400 14770 440 14770 {
lab=word246}
N 440 14770 480 14770 {
lab=word246}
N 410 14760 410 14810 {
lab=GND}
N 410 14810 410 14820 {
lab=GND}
N 470 14760 470 14810 {
lab=Y5}
N 470 14810 470 14820 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 14790 1 0 {name=M1119
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 14820 520 14820 {
lab=GND}
N 520 14810 520 14820 {
lab=GND}
N 480 14770 520 14770 {
lab=word246}
N 520 14770 560 14770 {
lab=word246}
N 490 14760 490 14810 {
lab=GND}
N 490 14810 490 14820 {
lab=GND}
N 550 14760 550 14810 {
lab=Y6}
N 550 14810 550 14820 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14790 1 0 {name=M1120
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14820 600 14820 {
lab=GND}
N 600 14810 600 14820 {
lab=GND}
N 560 14770 600 14770 {
lab=word246}
N 600 14770 640 14770 {
lab=word246}
N 570 14760 570 14810 {
lab=GND}
N 570 14810 570 14820 {
lab=GND}
N 630 14760 630 14810 {
lab=Y7}
N 630 14810 630 14820 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14790 1 0 {name=M1121
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14830 0 0 {name=p270 lab=word247}
N 0 14830 40 14830 {
lab=word247}
N 40 14830 80 14830 {
lab=word247}
N 10 14820 10 14870 {
lab=GND}
N 10 14870 10 14880 {
lab=GND}
N 70 14820 70 14870 {
lab=Y0}
N 70 14870 70 14880 {
lab=Y0}
N 80 14830 120 14830 {
lab=word247}
N 120 14830 160 14830 {
lab=word247}
N 90 14820 90 14870 {
lab=GND}
N 90 14870 90 14880 {
lab=GND}
N 150 14820 150 14870 {
lab=Y1}
N 150 14870 150 14880 {
lab=Y1}

N 170 14880 200 14880 {
lab=GND}
N 200 14870 200 14880 {
lab=GND}
N 160 14830 200 14830 {
lab=word247}
N 200 14830 240 14830 {
lab=word247}
N 170 14820 170 14870 {
lab=GND}
N 170 14870 170 14880 {
lab=GND}
N 230 14820 230 14870 {
lab=Y2}
N 230 14870 230 14880 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 14850 1 0 {name=M1122
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 14830 280 14830 {
lab=word247}
N 280 14830 320 14830 {
lab=word247}
N 250 14820 250 14870 {
lab=GND}
N 250 14870 250 14880 {
lab=GND}
N 310 14820 310 14870 {
lab=Y3}
N 310 14870 310 14880 {
lab=Y3}
N 320 14830 360 14830 {
lab=word247}
N 360 14830 400 14830 {
lab=word247}
N 330 14820 330 14870 {
lab=GND}
N 330 14870 330 14880 {
lab=GND}
N 390 14820 390 14870 {
lab=Y4}
N 390 14870 390 14880 {
lab=Y4}
N 400 14830 440 14830 {
lab=word247}
N 440 14830 480 14830 {
lab=word247}
N 410 14820 410 14870 {
lab=GND}
N 410 14870 410 14880 {
lab=GND}
N 470 14820 470 14870 {
lab=Y5}
N 470 14870 470 14880 {
lab=Y5}

N 490 14880 520 14880 {
lab=GND}
N 520 14870 520 14880 {
lab=GND}
N 480 14830 520 14830 {
lab=word247}
N 520 14830 560 14830 {
lab=word247}
N 490 14820 490 14870 {
lab=GND}
N 490 14870 490 14880 {
lab=GND}
N 550 14820 550 14870 {
lab=Y6}
N 550 14870 550 14880 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14850 1 0 {name=M1123
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14880 600 14880 {
lab=GND}
N 600 14870 600 14880 {
lab=GND}
N 560 14830 600 14830 {
lab=word247}
N 600 14830 640 14830 {
lab=word247}
N 570 14820 570 14870 {
lab=GND}
N 570 14870 570 14880 {
lab=GND}
N 630 14820 630 14870 {
lab=Y7}
N 630 14870 630 14880 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14850 1 0 {name=M1124
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14890 0 0 {name=p271 lab=word248}
N 0 14890 40 14890 {
lab=word248}
N 40 14890 80 14890 {
lab=word248}
N 10 14880 10 14930 {
lab=GND}
N 10 14930 10 14940 {
lab=GND}
N 70 14880 70 14930 {
lab=Y0}
N 70 14930 70 14940 {
lab=Y0}
N 80 14890 120 14890 {
lab=word248}
N 120 14890 160 14890 {
lab=word248}
N 90 14880 90 14930 {
lab=GND}
N 90 14930 90 14940 {
lab=GND}
N 150 14880 150 14930 {
lab=Y1}
N 150 14930 150 14940 {
lab=Y1}
N 160 14890 200 14890 {
lab=word248}
N 200 14890 240 14890 {
lab=word248}
N 170 14880 170 14930 {
lab=GND}
N 170 14930 170 14940 {
lab=GND}
N 230 14880 230 14930 {
lab=Y2}
N 230 14930 230 14940 {
lab=Y2}

N 250 14940 280 14940 {
lab=GND}
N 280 14930 280 14940 {
lab=GND}
N 240 14890 280 14890 {
lab=word248}
N 280 14890 320 14890 {
lab=word248}
N 250 14880 250 14930 {
lab=GND}
N 250 14930 250 14940 {
lab=GND}
N 310 14880 310 14930 {
lab=Y3}
N 310 14930 310 14940 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 14910 1 0 {name=M1125
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 14940 360 14940 {
lab=GND}
N 360 14930 360 14940 {
lab=GND}
N 320 14890 360 14890 {
lab=word248}
N 360 14890 400 14890 {
lab=word248}
N 330 14880 330 14930 {
lab=GND}
N 330 14930 330 14940 {
lab=GND}
N 390 14880 390 14930 {
lab=Y4}
N 390 14930 390 14940 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 14910 1 0 {name=M1126
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 14940 440 14940 {
lab=GND}
N 440 14930 440 14940 {
lab=GND}
N 400 14890 440 14890 {
lab=word248}
N 440 14890 480 14890 {
lab=word248}
N 410 14880 410 14930 {
lab=GND}
N 410 14930 410 14940 {
lab=GND}
N 470 14880 470 14930 {
lab=Y5}
N 470 14930 470 14940 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 14910 1 0 {name=M1127
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 14940 520 14940 {
lab=GND}
N 520 14930 520 14940 {
lab=GND}
N 480 14890 520 14890 {
lab=word248}
N 520 14890 560 14890 {
lab=word248}
N 490 14880 490 14930 {
lab=GND}
N 490 14930 490 14940 {
lab=GND}
N 550 14880 550 14930 {
lab=Y6}
N 550 14930 550 14940 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14910 1 0 {name=M1128
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 14940 600 14940 {
lab=GND}
N 600 14930 600 14940 {
lab=GND}
N 560 14890 600 14890 {
lab=word248}
N 600 14890 640 14890 {
lab=word248}
N 570 14880 570 14930 {
lab=GND}
N 570 14930 570 14940 {
lab=GND}
N 630 14880 630 14930 {
lab=Y7}
N 630 14930 630 14940 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14910 1 0 {name=M1129
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 14950 0 0 {name=p272 lab=word249}
N 0 14950 40 14950 {
lab=word249}
N 40 14950 80 14950 {
lab=word249}
N 10 14940 10 14990 {
lab=GND}
N 10 14990 10 15000 {
lab=GND}
N 70 14940 70 14990 {
lab=Y0}
N 70 14990 70 15000 {
lab=Y0}
N 80 14950 120 14950 {
lab=word249}
N 120 14950 160 14950 {
lab=word249}
N 90 14940 90 14990 {
lab=GND}
N 90 14990 90 15000 {
lab=GND}
N 150 14940 150 14990 {
lab=Y1}
N 150 14990 150 15000 {
lab=Y1}
N 160 14950 200 14950 {
lab=word249}
N 200 14950 240 14950 {
lab=word249}
N 170 14940 170 14990 {
lab=GND}
N 170 14990 170 15000 {
lab=GND}
N 230 14940 230 14990 {
lab=Y2}
N 230 14990 230 15000 {
lab=Y2}

N 250 15000 280 15000 {
lab=GND}
N 280 14990 280 15000 {
lab=GND}
N 240 14950 280 14950 {
lab=word249}
N 280 14950 320 14950 {
lab=word249}
N 250 14940 250 14990 {
lab=GND}
N 250 14990 250 15000 {
lab=GND}
N 310 14940 310 14990 {
lab=Y3}
N 310 14990 310 15000 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 14970 1 0 {name=M1130
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 15000 360 15000 {
lab=GND}
N 360 14990 360 15000 {
lab=GND}
N 320 14950 360 14950 {
lab=word249}
N 360 14950 400 14950 {
lab=word249}
N 330 14940 330 14990 {
lab=GND}
N 330 14990 330 15000 {
lab=GND}
N 390 14940 390 14990 {
lab=Y4}
N 390 14990 390 15000 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 14970 1 0 {name=M1131
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 14950 440 14950 {
lab=word249}
N 440 14950 480 14950 {
lab=word249}
N 410 14940 410 14990 {
lab=GND}
N 410 14990 410 15000 {
lab=GND}
N 470 14940 470 14990 {
lab=Y5}
N 470 14990 470 15000 {
lab=Y5}

N 490 15000 520 15000 {
lab=GND}
N 520 14990 520 15000 {
lab=GND}
N 480 14950 520 14950 {
lab=word249}
N 520 14950 560 14950 {
lab=word249}
N 490 14940 490 14990 {
lab=GND}
N 490 14990 490 15000 {
lab=GND}
N 550 14940 550 14990 {
lab=Y6}
N 550 14990 550 15000 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 14970 1 0 {name=M1132
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 15000 600 15000 {
lab=GND}
N 600 14990 600 15000 {
lab=GND}
N 560 14950 600 14950 {
lab=word249}
N 600 14950 640 14950 {
lab=word249}
N 570 14940 570 14990 {
lab=GND}
N 570 14990 570 15000 {
lab=GND}
N 630 14940 630 14990 {
lab=Y7}
N 630 14990 630 15000 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 14970 1 0 {name=M1133
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15010 0 0 {name=p273 lab=word250}
N 0 15010 40 15010 {
lab=word250}
N 40 15010 80 15010 {
lab=word250}
N 10 15000 10 15050 {
lab=GND}
N 10 15050 10 15060 {
lab=GND}
N 70 15000 70 15050 {
lab=Y0}
N 70 15050 70 15060 {
lab=Y0}
N 80 15010 120 15010 {
lab=word250}
N 120 15010 160 15010 {
lab=word250}
N 90 15000 90 15050 {
lab=GND}
N 90 15050 90 15060 {
lab=GND}
N 150 15000 150 15050 {
lab=Y1}
N 150 15050 150 15060 {
lab=Y1}
N 160 15010 200 15010 {
lab=word250}
N 200 15010 240 15010 {
lab=word250}
N 170 15000 170 15050 {
lab=GND}
N 170 15050 170 15060 {
lab=GND}
N 230 15000 230 15050 {
lab=Y2}
N 230 15050 230 15060 {
lab=Y2}

N 250 15060 280 15060 {
lab=GND}
N 280 15050 280 15060 {
lab=GND}
N 240 15010 280 15010 {
lab=word250}
N 280 15010 320 15010 {
lab=word250}
N 250 15000 250 15050 {
lab=GND}
N 250 15050 250 15060 {
lab=GND}
N 310 15000 310 15050 {
lab=Y3}
N 310 15050 310 15060 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 15030 1 0 {name=M1134
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 15010 360 15010 {
lab=word250}
N 360 15010 400 15010 {
lab=word250}
N 330 15000 330 15050 {
lab=GND}
N 330 15050 330 15060 {
lab=GND}
N 390 15000 390 15050 {
lab=Y4}
N 390 15050 390 15060 {
lab=Y4}

N 410 15060 440 15060 {
lab=GND}
N 440 15050 440 15060 {
lab=GND}
N 400 15010 440 15010 {
lab=word250}
N 440 15010 480 15010 {
lab=word250}
N 410 15000 410 15050 {
lab=GND}
N 410 15050 410 15060 {
lab=GND}
N 470 15000 470 15050 {
lab=Y5}
N 470 15050 470 15060 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 15030 1 0 {name=M1135
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 15060 520 15060 {
lab=GND}
N 520 15050 520 15060 {
lab=GND}
N 480 15010 520 15010 {
lab=word250}
N 520 15010 560 15010 {
lab=word250}
N 490 15000 490 15050 {
lab=GND}
N 490 15050 490 15060 {
lab=GND}
N 550 15000 550 15050 {
lab=Y6}
N 550 15050 550 15060 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 15030 1 0 {name=M1136
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 15060 600 15060 {
lab=GND}
N 600 15050 600 15060 {
lab=GND}
N 560 15010 600 15010 {
lab=word250}
N 600 15010 640 15010 {
lab=word250}
N 570 15000 570 15050 {
lab=GND}
N 570 15050 570 15060 {
lab=GND}
N 630 15000 630 15050 {
lab=Y7}
N 630 15050 630 15060 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15030 1 0 {name=M1137
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15070 0 0 {name=p274 lab=word251}
N 0 15070 40 15070 {
lab=word251}
N 40 15070 80 15070 {
lab=word251}
N 10 15060 10 15110 {
lab=GND}
N 10 15110 10 15120 {
lab=GND}
N 70 15060 70 15110 {
lab=Y0}
N 70 15110 70 15120 {
lab=Y0}
N 80 15070 120 15070 {
lab=word251}
N 120 15070 160 15070 {
lab=word251}
N 90 15060 90 15110 {
lab=GND}
N 90 15110 90 15120 {
lab=GND}
N 150 15060 150 15110 {
lab=Y1}
N 150 15110 150 15120 {
lab=Y1}
N 160 15070 200 15070 {
lab=word251}
N 200 15070 240 15070 {
lab=word251}
N 170 15060 170 15110 {
lab=GND}
N 170 15110 170 15120 {
lab=GND}
N 230 15060 230 15110 {
lab=Y2}
N 230 15110 230 15120 {
lab=Y2}

N 250 15120 280 15120 {
lab=GND}
N 280 15110 280 15120 {
lab=GND}
N 240 15070 280 15070 {
lab=word251}
N 280 15070 320 15070 {
lab=word251}
N 250 15060 250 15110 {
lab=GND}
N 250 15110 250 15120 {
lab=GND}
N 310 15060 310 15110 {
lab=Y3}
N 310 15110 310 15120 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 15090 1 0 {name=M1138
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 15070 360 15070 {
lab=word251}
N 360 15070 400 15070 {
lab=word251}
N 330 15060 330 15110 {
lab=GND}
N 330 15110 330 15120 {
lab=GND}
N 390 15060 390 15110 {
lab=Y4}
N 390 15110 390 15120 {
lab=Y4}
N 400 15070 440 15070 {
lab=word251}
N 440 15070 480 15070 {
lab=word251}
N 410 15060 410 15110 {
lab=GND}
N 410 15110 410 15120 {
lab=GND}
N 470 15060 470 15110 {
lab=Y5}
N 470 15110 470 15120 {
lab=Y5}

N 490 15120 520 15120 {
lab=GND}
N 520 15110 520 15120 {
lab=GND}
N 480 15070 520 15070 {
lab=word251}
N 520 15070 560 15070 {
lab=word251}
N 490 15060 490 15110 {
lab=GND}
N 490 15110 490 15120 {
lab=GND}
N 550 15060 550 15110 {
lab=Y6}
N 550 15110 550 15120 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 15090 1 0 {name=M1139
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 15120 600 15120 {
lab=GND}
N 600 15110 600 15120 {
lab=GND}
N 560 15070 600 15070 {
lab=word251}
N 600 15070 640 15070 {
lab=word251}
N 570 15060 570 15110 {
lab=GND}
N 570 15110 570 15120 {
lab=GND}
N 630 15060 630 15110 {
lab=Y7}
N 630 15110 630 15120 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15090 1 0 {name=M1140
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15130 0 0 {name=p275 lab=word252}
N 0 15130 40 15130 {
lab=word252}
N 40 15130 80 15130 {
lab=word252}
N 10 15120 10 15170 {
lab=GND}
N 10 15170 10 15180 {
lab=GND}
N 70 15120 70 15170 {
lab=Y0}
N 70 15170 70 15180 {
lab=Y0}
N 80 15130 120 15130 {
lab=word252}
N 120 15130 160 15130 {
lab=word252}
N 90 15120 90 15170 {
lab=GND}
N 90 15170 90 15180 {
lab=GND}
N 150 15120 150 15170 {
lab=Y1}
N 150 15170 150 15180 {
lab=Y1}
N 160 15130 200 15130 {
lab=word252}
N 200 15130 240 15130 {
lab=word252}
N 170 15120 170 15170 {
lab=GND}
N 170 15170 170 15180 {
lab=GND}
N 230 15120 230 15170 {
lab=Y2}
N 230 15170 230 15180 {
lab=Y2}
N 240 15130 280 15130 {
lab=word252}
N 280 15130 320 15130 {
lab=word252}
N 250 15120 250 15170 {
lab=GND}
N 250 15170 250 15180 {
lab=GND}
N 310 15120 310 15170 {
lab=Y3}
N 310 15170 310 15180 {
lab=Y3}

N 330 15180 360 15180 {
lab=GND}
N 360 15170 360 15180 {
lab=GND}
N 320 15130 360 15130 {
lab=word252}
N 360 15130 400 15130 {
lab=word252}
N 330 15120 330 15170 {
lab=GND}
N 330 15170 330 15180 {
lab=GND}
N 390 15120 390 15170 {
lab=Y4}
N 390 15170 390 15180 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 15150 1 0 {name=M1141
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 15180 440 15180 {
lab=GND}
N 440 15170 440 15180 {
lab=GND}
N 400 15130 440 15130 {
lab=word252}
N 440 15130 480 15130 {
lab=word252}
N 410 15120 410 15170 {
lab=GND}
N 410 15170 410 15180 {
lab=GND}
N 470 15120 470 15170 {
lab=Y5}
N 470 15170 470 15180 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 15150 1 0 {name=M1142
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 15180 520 15180 {
lab=GND}
N 520 15170 520 15180 {
lab=GND}
N 480 15130 520 15130 {
lab=word252}
N 520 15130 560 15130 {
lab=word252}
N 490 15120 490 15170 {
lab=GND}
N 490 15170 490 15180 {
lab=GND}
N 550 15120 550 15170 {
lab=Y6}
N 550 15170 550 15180 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 15150 1 0 {name=M1143
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 15180 600 15180 {
lab=GND}
N 600 15170 600 15180 {
lab=GND}
N 560 15130 600 15130 {
lab=word252}
N 600 15130 640 15130 {
lab=word252}
N 570 15120 570 15170 {
lab=GND}
N 570 15170 570 15180 {
lab=GND}
N 630 15120 630 15170 {
lab=Y7}
N 630 15170 630 15180 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15150 1 0 {name=M1144
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15190 0 0 {name=p276 lab=word253}
N 0 15190 40 15190 {
lab=word253}
N 40 15190 80 15190 {
lab=word253}
N 10 15180 10 15230 {
lab=GND}
N 10 15230 10 15240 {
lab=GND}
N 70 15180 70 15230 {
lab=Y0}
N 70 15230 70 15240 {
lab=Y0}
N 80 15190 120 15190 {
lab=word253}
N 120 15190 160 15190 {
lab=word253}
N 90 15180 90 15230 {
lab=GND}
N 90 15230 90 15240 {
lab=GND}
N 150 15180 150 15230 {
lab=Y1}
N 150 15230 150 15240 {
lab=Y1}
N 160 15190 200 15190 {
lab=word253}
N 200 15190 240 15190 {
lab=word253}
N 170 15180 170 15230 {
lab=GND}
N 170 15230 170 15240 {
lab=GND}
N 230 15180 230 15230 {
lab=Y2}
N 230 15230 230 15240 {
lab=Y2}
N 240 15190 280 15190 {
lab=word253}
N 280 15190 320 15190 {
lab=word253}
N 250 15180 250 15230 {
lab=GND}
N 250 15230 250 15240 {
lab=GND}
N 310 15180 310 15230 {
lab=Y3}
N 310 15230 310 15240 {
lab=Y3}

N 330 15240 360 15240 {
lab=GND}
N 360 15230 360 15240 {
lab=GND}
N 320 15190 360 15190 {
lab=word253}
N 360 15190 400 15190 {
lab=word253}
N 330 15180 330 15230 {
lab=GND}
N 330 15230 330 15240 {
lab=GND}
N 390 15180 390 15230 {
lab=Y4}
N 390 15230 390 15240 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 15210 1 0 {name=M1145
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 15190 440 15190 {
lab=word253}
N 440 15190 480 15190 {
lab=word253}
N 410 15180 410 15230 {
lab=GND}
N 410 15230 410 15240 {
lab=GND}
N 470 15180 470 15230 {
lab=Y5}
N 470 15230 470 15240 {
lab=Y5}

N 490 15240 520 15240 {
lab=GND}
N 520 15230 520 15240 {
lab=GND}
N 480 15190 520 15190 {
lab=word253}
N 520 15190 560 15190 {
lab=word253}
N 490 15180 490 15230 {
lab=GND}
N 490 15230 490 15240 {
lab=GND}
N 550 15180 550 15230 {
lab=Y6}
N 550 15230 550 15240 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 15210 1 0 {name=M1146
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 15240 600 15240 {
lab=GND}
N 600 15230 600 15240 {
lab=GND}
N 560 15190 600 15190 {
lab=word253}
N 600 15190 640 15190 {
lab=word253}
N 570 15180 570 15230 {
lab=GND}
N 570 15230 570 15240 {
lab=GND}
N 630 15180 630 15230 {
lab=Y7}
N 630 15230 630 15240 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15210 1 0 {name=M1147
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15250 0 0 {name=p277 lab=word254}
N 0 15250 40 15250 {
lab=word254}
N 40 15250 80 15250 {
lab=word254}
N 10 15240 10 15290 {
lab=GND}
N 10 15290 10 15300 {
lab=GND}
N 70 15240 70 15290 {
lab=Y0}
N 70 15290 70 15300 {
lab=Y0}
N 80 15250 120 15250 {
lab=word254}
N 120 15250 160 15250 {
lab=word254}
N 90 15240 90 15290 {
lab=GND}
N 90 15290 90 15300 {
lab=GND}
N 150 15240 150 15290 {
lab=Y1}
N 150 15290 150 15300 {
lab=Y1}
N 160 15250 200 15250 {
lab=word254}
N 200 15250 240 15250 {
lab=word254}
N 170 15240 170 15290 {
lab=GND}
N 170 15290 170 15300 {
lab=GND}
N 230 15240 230 15290 {
lab=Y2}
N 230 15290 230 15300 {
lab=Y2}
N 240 15250 280 15250 {
lab=word254}
N 280 15250 320 15250 {
lab=word254}
N 250 15240 250 15290 {
lab=GND}
N 250 15290 250 15300 {
lab=GND}
N 310 15240 310 15290 {
lab=Y3}
N 310 15290 310 15300 {
lab=Y3}
N 320 15250 360 15250 {
lab=word254}
N 360 15250 400 15250 {
lab=word254}
N 330 15240 330 15290 {
lab=GND}
N 330 15290 330 15300 {
lab=GND}
N 390 15240 390 15290 {
lab=Y4}
N 390 15290 390 15300 {
lab=Y4}

N 410 15300 440 15300 {
lab=GND}
N 440 15290 440 15300 {
lab=GND}
N 400 15250 440 15250 {
lab=word254}
N 440 15250 480 15250 {
lab=word254}
N 410 15240 410 15290 {
lab=GND}
N 410 15290 410 15300 {
lab=GND}
N 470 15240 470 15290 {
lab=Y5}
N 470 15290 470 15300 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 15270 1 0 {name=M1148
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 15300 520 15300 {
lab=GND}
N 520 15290 520 15300 {
lab=GND}
N 480 15250 520 15250 {
lab=word254}
N 520 15250 560 15250 {
lab=word254}
N 490 15240 490 15290 {
lab=GND}
N 490 15290 490 15300 {
lab=GND}
N 550 15240 550 15290 {
lab=Y6}
N 550 15290 550 15300 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 15270 1 0 {name=M1149
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 15300 600 15300 {
lab=GND}
N 600 15290 600 15300 {
lab=GND}
N 560 15250 600 15250 {
lab=word254}
N 600 15250 640 15250 {
lab=word254}
N 570 15240 570 15290 {
lab=GND}
N 570 15290 570 15300 {
lab=GND}
N 630 15240 630 15290 {
lab=Y7}
N 630 15290 630 15300 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15270 1 0 {name=M1150
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15310 0 0 {name=p278 lab=word255}
N 0 15310 40 15310 {
lab=word255}
N 40 15310 80 15310 {
lab=word255}
N 10 15300 10 15350 {
lab=GND}
N 10 15350 10 15360 {
lab=GND}
N 70 15300 70 15350 {
lab=Y0}
N 70 15350 70 15360 {
lab=Y0}
N 80 15310 120 15310 {
lab=word255}
N 120 15310 160 15310 {
lab=word255}
N 90 15300 90 15350 {
lab=GND}
N 90 15350 90 15360 {
lab=GND}
N 150 15300 150 15350 {
lab=Y1}
N 150 15350 150 15360 {
lab=Y1}
N 160 15310 200 15310 {
lab=word255}
N 200 15310 240 15310 {
lab=word255}
N 170 15300 170 15350 {
lab=GND}
N 170 15350 170 15360 {
lab=GND}
N 230 15300 230 15350 {
lab=Y2}
N 230 15350 230 15360 {
lab=Y2}
N 240 15310 280 15310 {
lab=word255}
N 280 15310 320 15310 {
lab=word255}
N 250 15300 250 15350 {
lab=GND}
N 250 15350 250 15360 {
lab=GND}
N 310 15300 310 15350 {
lab=Y3}
N 310 15350 310 15360 {
lab=Y3}
N 320 15310 360 15310 {
lab=word255}
N 360 15310 400 15310 {
lab=word255}
N 330 15300 330 15350 {
lab=GND}
N 330 15350 330 15360 {
lab=GND}
N 390 15300 390 15350 {
lab=Y4}
N 390 15350 390 15360 {
lab=Y4}
N 400 15310 440 15310 {
lab=word255}
N 440 15310 480 15310 {
lab=word255}
N 410 15300 410 15350 {
lab=GND}
N 410 15350 410 15360 {
lab=GND}
N 470 15300 470 15350 {
lab=Y5}
N 470 15350 470 15360 {
lab=Y5}

N 490 15360 520 15360 {
lab=GND}
N 520 15350 520 15360 {
lab=GND}
N 480 15310 520 15310 {
lab=word255}
N 520 15310 560 15310 {
lab=word255}
N 490 15300 490 15350 {
lab=GND}
N 490 15350 490 15360 {
lab=GND}
N 550 15300 550 15350 {
lab=Y6}
N 550 15350 550 15360 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 15330 1 0 {name=M1151
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 15360 600 15360 {
lab=GND}
N 600 15350 600 15360 {
lab=GND}
N 560 15310 600 15310 {
lab=word255}
N 600 15310 640 15310 {
lab=word255}
N 570 15300 570 15350 {
lab=GND}
N 570 15350 570 15360 {
lab=GND}
N 630 15300 630 15350 {
lab=Y7}
N 630 15350 630 15360 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15330 1 0 {name=M1152
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15370 0 0 {name=p279 lab=word256}
N 0 15370 40 15370 {
lab=word256}
N 40 15370 80 15370 {
lab=word256}
N 10 15360 10 15410 {
lab=GND}
N 10 15410 10 15420 {
lab=GND}
N 70 15360 70 15410 {
lab=Y0}
N 70 15410 70 15420 {
lab=Y0}
N 80 15370 120 15370 {
lab=word256}
N 120 15370 160 15370 {
lab=word256}
N 90 15360 90 15410 {
lab=GND}
N 90 15410 90 15420 {
lab=GND}
N 150 15360 150 15410 {
lab=Y1}
N 150 15410 150 15420 {
lab=Y1}
N 160 15370 200 15370 {
lab=word256}
N 200 15370 240 15370 {
lab=word256}
N 170 15360 170 15410 {
lab=GND}
N 170 15410 170 15420 {
lab=GND}
N 230 15360 230 15410 {
lab=Y2}
N 230 15410 230 15420 {
lab=Y2}
N 240 15370 280 15370 {
lab=word256}
N 280 15370 320 15370 {
lab=word256}
N 250 15360 250 15410 {
lab=GND}
N 250 15410 250 15420 {
lab=GND}
N 310 15360 310 15410 {
lab=Y3}
N 310 15410 310 15420 {
lab=Y3}
N 320 15370 360 15370 {
lab=word256}
N 360 15370 400 15370 {
lab=word256}
N 330 15360 330 15410 {
lab=GND}
N 330 15410 330 15420 {
lab=GND}
N 390 15360 390 15410 {
lab=Y4}
N 390 15410 390 15420 {
lab=Y4}
N 400 15370 440 15370 {
lab=word256}
N 440 15370 480 15370 {
lab=word256}
N 410 15360 410 15410 {
lab=GND}
N 410 15410 410 15420 {
lab=GND}
N 470 15360 470 15410 {
lab=Y5}
N 470 15410 470 15420 {
lab=Y5}
N 480 15370 520 15370 {
lab=word256}
N 520 15370 560 15370 {
lab=word256}
N 490 15360 490 15410 {
lab=GND}
N 490 15410 490 15420 {
lab=GND}
N 550 15360 550 15410 {
lab=Y6}
N 550 15410 550 15420 {
lab=Y6}
N 560 15370 600 15370 {
lab=word256}
N 600 15370 640 15370 {
lab=word256}
N 570 15360 570 15410 {
lab=GND}
N 570 15410 570 15420 {
lab=GND}
N 630 15360 630 15410 {
lab=Y7}
N 630 15410 630 15420 {
lab=Y7}
C {devices/ipin.sym} 0 15430 0 0 {name=p280 lab=word257}
N 0 15430 40 15430 {
lab=word257}
N 40 15430 80 15430 {
lab=word257}
N 10 15420 10 15470 {
lab=GND}
N 10 15470 10 15480 {
lab=GND}
N 70 15420 70 15470 {
lab=Y0}
N 70 15470 70 15480 {
lab=Y0}
N 80 15430 120 15430 {
lab=word257}
N 120 15430 160 15430 {
lab=word257}
N 90 15420 90 15470 {
lab=GND}
N 90 15470 90 15480 {
lab=GND}
N 150 15420 150 15470 {
lab=Y1}
N 150 15470 150 15480 {
lab=Y1}
N 160 15430 200 15430 {
lab=word257}
N 200 15430 240 15430 {
lab=word257}
N 170 15420 170 15470 {
lab=GND}
N 170 15470 170 15480 {
lab=GND}
N 230 15420 230 15470 {
lab=Y2}
N 230 15470 230 15480 {
lab=Y2}
N 240 15430 280 15430 {
lab=word257}
N 280 15430 320 15430 {
lab=word257}
N 250 15420 250 15470 {
lab=GND}
N 250 15470 250 15480 {
lab=GND}
N 310 15420 310 15470 {
lab=Y3}
N 310 15470 310 15480 {
lab=Y3}
N 320 15430 360 15430 {
lab=word257}
N 360 15430 400 15430 {
lab=word257}
N 330 15420 330 15470 {
lab=GND}
N 330 15470 330 15480 {
lab=GND}
N 390 15420 390 15470 {
lab=Y4}
N 390 15470 390 15480 {
lab=Y4}
N 400 15430 440 15430 {
lab=word257}
N 440 15430 480 15430 {
lab=word257}
N 410 15420 410 15470 {
lab=GND}
N 410 15470 410 15480 {
lab=GND}
N 470 15420 470 15470 {
lab=Y5}
N 470 15470 470 15480 {
lab=Y5}
N 480 15430 520 15430 {
lab=word257}
N 520 15430 560 15430 {
lab=word257}
N 490 15420 490 15470 {
lab=GND}
N 490 15470 490 15480 {
lab=GND}
N 550 15420 550 15470 {
lab=Y6}
N 550 15470 550 15480 {
lab=Y6}

N 570 15480 600 15480 {
lab=GND}
N 600 15470 600 15480 {
lab=GND}
N 560 15430 600 15430 {
lab=word257}
N 600 15430 640 15430 {
lab=word257}
N 570 15420 570 15470 {
lab=GND}
N 570 15470 570 15480 {
lab=GND}
N 630 15420 630 15470 {
lab=Y7}
N 630 15470 630 15480 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15450 1 0 {name=M1153
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15490 0 0 {name=p281 lab=word258}
N 0 15490 40 15490 {
lab=word258}
N 40 15490 80 15490 {
lab=word258}
N 10 15480 10 15530 {
lab=GND}
N 10 15530 10 15540 {
lab=GND}
N 70 15480 70 15530 {
lab=Y0}
N 70 15530 70 15540 {
lab=Y0}
N 80 15490 120 15490 {
lab=word258}
N 120 15490 160 15490 {
lab=word258}
N 90 15480 90 15530 {
lab=GND}
N 90 15530 90 15540 {
lab=GND}
N 150 15480 150 15530 {
lab=Y1}
N 150 15530 150 15540 {
lab=Y1}
N 160 15490 200 15490 {
lab=word258}
N 200 15490 240 15490 {
lab=word258}
N 170 15480 170 15530 {
lab=GND}
N 170 15530 170 15540 {
lab=GND}
N 230 15480 230 15530 {
lab=Y2}
N 230 15530 230 15540 {
lab=Y2}
N 240 15490 280 15490 {
lab=word258}
N 280 15490 320 15490 {
lab=word258}
N 250 15480 250 15530 {
lab=GND}
N 250 15530 250 15540 {
lab=GND}
N 310 15480 310 15530 {
lab=Y3}
N 310 15530 310 15540 {
lab=Y3}
N 320 15490 360 15490 {
lab=word258}
N 360 15490 400 15490 {
lab=word258}
N 330 15480 330 15530 {
lab=GND}
N 330 15530 330 15540 {
lab=GND}
N 390 15480 390 15530 {
lab=Y4}
N 390 15530 390 15540 {
lab=Y4}
N 400 15490 440 15490 {
lab=word258}
N 440 15490 480 15490 {
lab=word258}
N 410 15480 410 15530 {
lab=GND}
N 410 15530 410 15540 {
lab=GND}
N 470 15480 470 15530 {
lab=Y5}
N 470 15530 470 15540 {
lab=Y5}

N 490 15540 520 15540 {
lab=GND}
N 520 15530 520 15540 {
lab=GND}
N 480 15490 520 15490 {
lab=word258}
N 520 15490 560 15490 {
lab=word258}
N 490 15480 490 15530 {
lab=GND}
N 490 15530 490 15540 {
lab=GND}
N 550 15480 550 15530 {
lab=Y6}
N 550 15530 550 15540 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 15510 1 0 {name=M1154
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 15540 600 15540 {
lab=GND}
N 600 15530 600 15540 {
lab=GND}
N 560 15490 600 15490 {
lab=word258}
N 600 15490 640 15490 {
lab=word258}
N 570 15480 570 15530 {
lab=GND}
N 570 15530 570 15540 {
lab=GND}
N 630 15480 630 15530 {
lab=Y7}
N 630 15530 630 15540 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15510 1 0 {name=M1155
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15550 0 0 {name=p282 lab=word259}
N 0 15550 40 15550 {
lab=word259}
N 40 15550 80 15550 {
lab=word259}
N 10 15540 10 15590 {
lab=GND}
N 10 15590 10 15600 {
lab=GND}
N 70 15540 70 15590 {
lab=Y0}
N 70 15590 70 15600 {
lab=Y0}
N 80 15550 120 15550 {
lab=word259}
N 120 15550 160 15550 {
lab=word259}
N 90 15540 90 15590 {
lab=GND}
N 90 15590 90 15600 {
lab=GND}
N 150 15540 150 15590 {
lab=Y1}
N 150 15590 150 15600 {
lab=Y1}
N 160 15550 200 15550 {
lab=word259}
N 200 15550 240 15550 {
lab=word259}
N 170 15540 170 15590 {
lab=GND}
N 170 15590 170 15600 {
lab=GND}
N 230 15540 230 15590 {
lab=Y2}
N 230 15590 230 15600 {
lab=Y2}
N 240 15550 280 15550 {
lab=word259}
N 280 15550 320 15550 {
lab=word259}
N 250 15540 250 15590 {
lab=GND}
N 250 15590 250 15600 {
lab=GND}
N 310 15540 310 15590 {
lab=Y3}
N 310 15590 310 15600 {
lab=Y3}
N 320 15550 360 15550 {
lab=word259}
N 360 15550 400 15550 {
lab=word259}
N 330 15540 330 15590 {
lab=GND}
N 330 15590 330 15600 {
lab=GND}
N 390 15540 390 15590 {
lab=Y4}
N 390 15590 390 15600 {
lab=Y4}

N 410 15600 440 15600 {
lab=GND}
N 440 15590 440 15600 {
lab=GND}
N 400 15550 440 15550 {
lab=word259}
N 440 15550 480 15550 {
lab=word259}
N 410 15540 410 15590 {
lab=GND}
N 410 15590 410 15600 {
lab=GND}
N 470 15540 470 15590 {
lab=Y5}
N 470 15590 470 15600 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 15570 1 0 {name=M1156
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 15550 520 15550 {
lab=word259}
N 520 15550 560 15550 {
lab=word259}
N 490 15540 490 15590 {
lab=GND}
N 490 15590 490 15600 {
lab=GND}
N 550 15540 550 15590 {
lab=Y6}
N 550 15590 550 15600 {
lab=Y6}

N 570 15600 600 15600 {
lab=GND}
N 600 15590 600 15600 {
lab=GND}
N 560 15550 600 15550 {
lab=word259}
N 600 15550 640 15550 {
lab=word259}
N 570 15540 570 15590 {
lab=GND}
N 570 15590 570 15600 {
lab=GND}
N 630 15540 630 15590 {
lab=Y7}
N 630 15590 630 15600 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15570 1 0 {name=M1157
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15610 0 0 {name=p283 lab=word260}
N 0 15610 40 15610 {
lab=word260}
N 40 15610 80 15610 {
lab=word260}
N 10 15600 10 15650 {
lab=GND}
N 10 15650 10 15660 {
lab=GND}
N 70 15600 70 15650 {
lab=Y0}
N 70 15650 70 15660 {
lab=Y0}
N 80 15610 120 15610 {
lab=word260}
N 120 15610 160 15610 {
lab=word260}
N 90 15600 90 15650 {
lab=GND}
N 90 15650 90 15660 {
lab=GND}
N 150 15600 150 15650 {
lab=Y1}
N 150 15650 150 15660 {
lab=Y1}
N 160 15610 200 15610 {
lab=word260}
N 200 15610 240 15610 {
lab=word260}
N 170 15600 170 15650 {
lab=GND}
N 170 15650 170 15660 {
lab=GND}
N 230 15600 230 15650 {
lab=Y2}
N 230 15650 230 15660 {
lab=Y2}
N 240 15610 280 15610 {
lab=word260}
N 280 15610 320 15610 {
lab=word260}
N 250 15600 250 15650 {
lab=GND}
N 250 15650 250 15660 {
lab=GND}
N 310 15600 310 15650 {
lab=Y3}
N 310 15650 310 15660 {
lab=Y3}
N 320 15610 360 15610 {
lab=word260}
N 360 15610 400 15610 {
lab=word260}
N 330 15600 330 15650 {
lab=GND}
N 330 15650 330 15660 {
lab=GND}
N 390 15600 390 15650 {
lab=Y4}
N 390 15650 390 15660 {
lab=Y4}

N 410 15660 440 15660 {
lab=GND}
N 440 15650 440 15660 {
lab=GND}
N 400 15610 440 15610 {
lab=word260}
N 440 15610 480 15610 {
lab=word260}
N 410 15600 410 15650 {
lab=GND}
N 410 15650 410 15660 {
lab=GND}
N 470 15600 470 15650 {
lab=Y5}
N 470 15650 470 15660 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 15630 1 0 {name=M1158
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 15660 520 15660 {
lab=GND}
N 520 15650 520 15660 {
lab=GND}
N 480 15610 520 15610 {
lab=word260}
N 520 15610 560 15610 {
lab=word260}
N 490 15600 490 15650 {
lab=GND}
N 490 15650 490 15660 {
lab=GND}
N 550 15600 550 15650 {
lab=Y6}
N 550 15650 550 15660 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 15630 1 0 {name=M1159
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 15660 600 15660 {
lab=GND}
N 600 15650 600 15660 {
lab=GND}
N 560 15610 600 15610 {
lab=word260}
N 600 15610 640 15610 {
lab=word260}
N 570 15600 570 15650 {
lab=GND}
N 570 15650 570 15660 {
lab=GND}
N 630 15600 630 15650 {
lab=Y7}
N 630 15650 630 15660 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15630 1 0 {name=M1160
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15670 0 0 {name=p284 lab=word261}
N 0 15670 40 15670 {
lab=word261}
N 40 15670 80 15670 {
lab=word261}
N 10 15660 10 15710 {
lab=GND}
N 10 15710 10 15720 {
lab=GND}
N 70 15660 70 15710 {
lab=Y0}
N 70 15710 70 15720 {
lab=Y0}
N 80 15670 120 15670 {
lab=word261}
N 120 15670 160 15670 {
lab=word261}
N 90 15660 90 15710 {
lab=GND}
N 90 15710 90 15720 {
lab=GND}
N 150 15660 150 15710 {
lab=Y1}
N 150 15710 150 15720 {
lab=Y1}
N 160 15670 200 15670 {
lab=word261}
N 200 15670 240 15670 {
lab=word261}
N 170 15660 170 15710 {
lab=GND}
N 170 15710 170 15720 {
lab=GND}
N 230 15660 230 15710 {
lab=Y2}
N 230 15710 230 15720 {
lab=Y2}
N 240 15670 280 15670 {
lab=word261}
N 280 15670 320 15670 {
lab=word261}
N 250 15660 250 15710 {
lab=GND}
N 250 15710 250 15720 {
lab=GND}
N 310 15660 310 15710 {
lab=Y3}
N 310 15710 310 15720 {
lab=Y3}

N 330 15720 360 15720 {
lab=GND}
N 360 15710 360 15720 {
lab=GND}
N 320 15670 360 15670 {
lab=word261}
N 360 15670 400 15670 {
lab=word261}
N 330 15660 330 15710 {
lab=GND}
N 330 15710 330 15720 {
lab=GND}
N 390 15660 390 15710 {
lab=Y4}
N 390 15710 390 15720 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 15690 1 0 {name=M1161
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 15670 440 15670 {
lab=word261}
N 440 15670 480 15670 {
lab=word261}
N 410 15660 410 15710 {
lab=GND}
N 410 15710 410 15720 {
lab=GND}
N 470 15660 470 15710 {
lab=Y5}
N 470 15710 470 15720 {
lab=Y5}
N 480 15670 520 15670 {
lab=word261}
N 520 15670 560 15670 {
lab=word261}
N 490 15660 490 15710 {
lab=GND}
N 490 15710 490 15720 {
lab=GND}
N 550 15660 550 15710 {
lab=Y6}
N 550 15710 550 15720 {
lab=Y6}

N 570 15720 600 15720 {
lab=GND}
N 600 15710 600 15720 {
lab=GND}
N 560 15670 600 15670 {
lab=word261}
N 600 15670 640 15670 {
lab=word261}
N 570 15660 570 15710 {
lab=GND}
N 570 15710 570 15720 {
lab=GND}
N 630 15660 630 15710 {
lab=Y7}
N 630 15710 630 15720 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15690 1 0 {name=M1162
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15730 0 0 {name=p285 lab=word262}
N 0 15730 40 15730 {
lab=word262}
N 40 15730 80 15730 {
lab=word262}
N 10 15720 10 15770 {
lab=GND}
N 10 15770 10 15780 {
lab=GND}
N 70 15720 70 15770 {
lab=Y0}
N 70 15770 70 15780 {
lab=Y0}
N 80 15730 120 15730 {
lab=word262}
N 120 15730 160 15730 {
lab=word262}
N 90 15720 90 15770 {
lab=GND}
N 90 15770 90 15780 {
lab=GND}
N 150 15720 150 15770 {
lab=Y1}
N 150 15770 150 15780 {
lab=Y1}
N 160 15730 200 15730 {
lab=word262}
N 200 15730 240 15730 {
lab=word262}
N 170 15720 170 15770 {
lab=GND}
N 170 15770 170 15780 {
lab=GND}
N 230 15720 230 15770 {
lab=Y2}
N 230 15770 230 15780 {
lab=Y2}
N 240 15730 280 15730 {
lab=word262}
N 280 15730 320 15730 {
lab=word262}
N 250 15720 250 15770 {
lab=GND}
N 250 15770 250 15780 {
lab=GND}
N 310 15720 310 15770 {
lab=Y3}
N 310 15770 310 15780 {
lab=Y3}

N 330 15780 360 15780 {
lab=GND}
N 360 15770 360 15780 {
lab=GND}
N 320 15730 360 15730 {
lab=word262}
N 360 15730 400 15730 {
lab=word262}
N 330 15720 330 15770 {
lab=GND}
N 330 15770 330 15780 {
lab=GND}
N 390 15720 390 15770 {
lab=Y4}
N 390 15770 390 15780 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 15750 1 0 {name=M1163
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 15730 440 15730 {
lab=word262}
N 440 15730 480 15730 {
lab=word262}
N 410 15720 410 15770 {
lab=GND}
N 410 15770 410 15780 {
lab=GND}
N 470 15720 470 15770 {
lab=Y5}
N 470 15770 470 15780 {
lab=Y5}

N 490 15780 520 15780 {
lab=GND}
N 520 15770 520 15780 {
lab=GND}
N 480 15730 520 15730 {
lab=word262}
N 520 15730 560 15730 {
lab=word262}
N 490 15720 490 15770 {
lab=GND}
N 490 15770 490 15780 {
lab=GND}
N 550 15720 550 15770 {
lab=Y6}
N 550 15770 550 15780 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 15750 1 0 {name=M1164
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 15780 600 15780 {
lab=GND}
N 600 15770 600 15780 {
lab=GND}
N 560 15730 600 15730 {
lab=word262}
N 600 15730 640 15730 {
lab=word262}
N 570 15720 570 15770 {
lab=GND}
N 570 15770 570 15780 {
lab=GND}
N 630 15720 630 15770 {
lab=Y7}
N 630 15770 630 15780 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15750 1 0 {name=M1165
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15790 0 0 {name=p286 lab=word263}
N 0 15790 40 15790 {
lab=word263}
N 40 15790 80 15790 {
lab=word263}
N 10 15780 10 15830 {
lab=GND}
N 10 15830 10 15840 {
lab=GND}
N 70 15780 70 15830 {
lab=Y0}
N 70 15830 70 15840 {
lab=Y0}
N 80 15790 120 15790 {
lab=word263}
N 120 15790 160 15790 {
lab=word263}
N 90 15780 90 15830 {
lab=GND}
N 90 15830 90 15840 {
lab=GND}
N 150 15780 150 15830 {
lab=Y1}
N 150 15830 150 15840 {
lab=Y1}
N 160 15790 200 15790 {
lab=word263}
N 200 15790 240 15790 {
lab=word263}
N 170 15780 170 15830 {
lab=GND}
N 170 15830 170 15840 {
lab=GND}
N 230 15780 230 15830 {
lab=Y2}
N 230 15830 230 15840 {
lab=Y2}
N 240 15790 280 15790 {
lab=word263}
N 280 15790 320 15790 {
lab=word263}
N 250 15780 250 15830 {
lab=GND}
N 250 15830 250 15840 {
lab=GND}
N 310 15780 310 15830 {
lab=Y3}
N 310 15830 310 15840 {
lab=Y3}

N 330 15840 360 15840 {
lab=GND}
N 360 15830 360 15840 {
lab=GND}
N 320 15790 360 15790 {
lab=word263}
N 360 15790 400 15790 {
lab=word263}
N 330 15780 330 15830 {
lab=GND}
N 330 15830 330 15840 {
lab=GND}
N 390 15780 390 15830 {
lab=Y4}
N 390 15830 390 15840 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 15810 1 0 {name=M1166
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 15840 440 15840 {
lab=GND}
N 440 15830 440 15840 {
lab=GND}
N 400 15790 440 15790 {
lab=word263}
N 440 15790 480 15790 {
lab=word263}
N 410 15780 410 15830 {
lab=GND}
N 410 15830 410 15840 {
lab=GND}
N 470 15780 470 15830 {
lab=Y5}
N 470 15830 470 15840 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 15810 1 0 {name=M1167
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 15790 520 15790 {
lab=word263}
N 520 15790 560 15790 {
lab=word263}
N 490 15780 490 15830 {
lab=GND}
N 490 15830 490 15840 {
lab=GND}
N 550 15780 550 15830 {
lab=Y6}
N 550 15830 550 15840 {
lab=Y6}

N 570 15840 600 15840 {
lab=GND}
N 600 15830 600 15840 {
lab=GND}
N 560 15790 600 15790 {
lab=word263}
N 600 15790 640 15790 {
lab=word263}
N 570 15780 570 15830 {
lab=GND}
N 570 15830 570 15840 {
lab=GND}
N 630 15780 630 15830 {
lab=Y7}
N 630 15830 630 15840 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15810 1 0 {name=M1168
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15850 0 0 {name=p287 lab=word264}
N 0 15850 40 15850 {
lab=word264}
N 40 15850 80 15850 {
lab=word264}
N 10 15840 10 15890 {
lab=GND}
N 10 15890 10 15900 {
lab=GND}
N 70 15840 70 15890 {
lab=Y0}
N 70 15890 70 15900 {
lab=Y0}
N 80 15850 120 15850 {
lab=word264}
N 120 15850 160 15850 {
lab=word264}
N 90 15840 90 15890 {
lab=GND}
N 90 15890 90 15900 {
lab=GND}
N 150 15840 150 15890 {
lab=Y1}
N 150 15890 150 15900 {
lab=Y1}
N 160 15850 200 15850 {
lab=word264}
N 200 15850 240 15850 {
lab=word264}
N 170 15840 170 15890 {
lab=GND}
N 170 15890 170 15900 {
lab=GND}
N 230 15840 230 15890 {
lab=Y2}
N 230 15890 230 15900 {
lab=Y2}
N 240 15850 280 15850 {
lab=word264}
N 280 15850 320 15850 {
lab=word264}
N 250 15840 250 15890 {
lab=GND}
N 250 15890 250 15900 {
lab=GND}
N 310 15840 310 15890 {
lab=Y3}
N 310 15890 310 15900 {
lab=Y3}

N 330 15900 360 15900 {
lab=GND}
N 360 15890 360 15900 {
lab=GND}
N 320 15850 360 15850 {
lab=word264}
N 360 15850 400 15850 {
lab=word264}
N 330 15840 330 15890 {
lab=GND}
N 330 15890 330 15900 {
lab=GND}
N 390 15840 390 15890 {
lab=Y4}
N 390 15890 390 15900 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 15870 1 0 {name=M1169
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 15900 440 15900 {
lab=GND}
N 440 15890 440 15900 {
lab=GND}
N 400 15850 440 15850 {
lab=word264}
N 440 15850 480 15850 {
lab=word264}
N 410 15840 410 15890 {
lab=GND}
N 410 15890 410 15900 {
lab=GND}
N 470 15840 470 15890 {
lab=Y5}
N 470 15890 470 15900 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 15870 1 0 {name=M1170
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 15900 520 15900 {
lab=GND}
N 520 15890 520 15900 {
lab=GND}
N 480 15850 520 15850 {
lab=word264}
N 520 15850 560 15850 {
lab=word264}
N 490 15840 490 15890 {
lab=GND}
N 490 15890 490 15900 {
lab=GND}
N 550 15840 550 15890 {
lab=Y6}
N 550 15890 550 15900 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 15870 1 0 {name=M1171
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 15900 600 15900 {
lab=GND}
N 600 15890 600 15900 {
lab=GND}
N 560 15850 600 15850 {
lab=word264}
N 600 15850 640 15850 {
lab=word264}
N 570 15840 570 15890 {
lab=GND}
N 570 15890 570 15900 {
lab=GND}
N 630 15840 630 15890 {
lab=Y7}
N 630 15890 630 15900 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15870 1 0 {name=M1172
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15910 0 0 {name=p288 lab=word265}
N 0 15910 40 15910 {
lab=word265}
N 40 15910 80 15910 {
lab=word265}
N 10 15900 10 15950 {
lab=GND}
N 10 15950 10 15960 {
lab=GND}
N 70 15900 70 15950 {
lab=Y0}
N 70 15950 70 15960 {
lab=Y0}
N 80 15910 120 15910 {
lab=word265}
N 120 15910 160 15910 {
lab=word265}
N 90 15900 90 15950 {
lab=GND}
N 90 15950 90 15960 {
lab=GND}
N 150 15900 150 15950 {
lab=Y1}
N 150 15950 150 15960 {
lab=Y1}
N 160 15910 200 15910 {
lab=word265}
N 200 15910 240 15910 {
lab=word265}
N 170 15900 170 15950 {
lab=GND}
N 170 15950 170 15960 {
lab=GND}
N 230 15900 230 15950 {
lab=Y2}
N 230 15950 230 15960 {
lab=Y2}

N 250 15960 280 15960 {
lab=GND}
N 280 15950 280 15960 {
lab=GND}
N 240 15910 280 15910 {
lab=word265}
N 280 15910 320 15910 {
lab=word265}
N 250 15900 250 15950 {
lab=GND}
N 250 15950 250 15960 {
lab=GND}
N 310 15900 310 15950 {
lab=Y3}
N 310 15950 310 15960 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 15930 1 0 {name=M1173
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 15910 360 15910 {
lab=word265}
N 360 15910 400 15910 {
lab=word265}
N 330 15900 330 15950 {
lab=GND}
N 330 15950 330 15960 {
lab=GND}
N 390 15900 390 15950 {
lab=Y4}
N 390 15950 390 15960 {
lab=Y4}
N 400 15910 440 15910 {
lab=word265}
N 440 15910 480 15910 {
lab=word265}
N 410 15900 410 15950 {
lab=GND}
N 410 15950 410 15960 {
lab=GND}
N 470 15900 470 15950 {
lab=Y5}
N 470 15950 470 15960 {
lab=Y5}
N 480 15910 520 15910 {
lab=word265}
N 520 15910 560 15910 {
lab=word265}
N 490 15900 490 15950 {
lab=GND}
N 490 15950 490 15960 {
lab=GND}
N 550 15900 550 15950 {
lab=Y6}
N 550 15950 550 15960 {
lab=Y6}

N 570 15960 600 15960 {
lab=GND}
N 600 15950 600 15960 {
lab=GND}
N 560 15910 600 15910 {
lab=word265}
N 600 15910 640 15910 {
lab=word265}
N 570 15900 570 15950 {
lab=GND}
N 570 15950 570 15960 {
lab=GND}
N 630 15900 630 15950 {
lab=Y7}
N 630 15950 630 15960 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15930 1 0 {name=M1174
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 15970 0 0 {name=p289 lab=word266}
N 0 15970 40 15970 {
lab=word266}
N 40 15970 80 15970 {
lab=word266}
N 10 15960 10 16010 {
lab=GND}
N 10 16010 10 16020 {
lab=GND}
N 70 15960 70 16010 {
lab=Y0}
N 70 16010 70 16020 {
lab=Y0}
N 80 15970 120 15970 {
lab=word266}
N 120 15970 160 15970 {
lab=word266}
N 90 15960 90 16010 {
lab=GND}
N 90 16010 90 16020 {
lab=GND}
N 150 15960 150 16010 {
lab=Y1}
N 150 16010 150 16020 {
lab=Y1}
N 160 15970 200 15970 {
lab=word266}
N 200 15970 240 15970 {
lab=word266}
N 170 15960 170 16010 {
lab=GND}
N 170 16010 170 16020 {
lab=GND}
N 230 15960 230 16010 {
lab=Y2}
N 230 16010 230 16020 {
lab=Y2}

N 250 16020 280 16020 {
lab=GND}
N 280 16010 280 16020 {
lab=GND}
N 240 15970 280 15970 {
lab=word266}
N 280 15970 320 15970 {
lab=word266}
N 250 15960 250 16010 {
lab=GND}
N 250 16010 250 16020 {
lab=GND}
N 310 15960 310 16010 {
lab=Y3}
N 310 16010 310 16020 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 15990 1 0 {name=M1175
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 15970 360 15970 {
lab=word266}
N 360 15970 400 15970 {
lab=word266}
N 330 15960 330 16010 {
lab=GND}
N 330 16010 330 16020 {
lab=GND}
N 390 15960 390 16010 {
lab=Y4}
N 390 16010 390 16020 {
lab=Y4}
N 400 15970 440 15970 {
lab=word266}
N 440 15970 480 15970 {
lab=word266}
N 410 15960 410 16010 {
lab=GND}
N 410 16010 410 16020 {
lab=GND}
N 470 15960 470 16010 {
lab=Y5}
N 470 16010 470 16020 {
lab=Y5}

N 490 16020 520 16020 {
lab=GND}
N 520 16010 520 16020 {
lab=GND}
N 480 15970 520 15970 {
lab=word266}
N 520 15970 560 15970 {
lab=word266}
N 490 15960 490 16010 {
lab=GND}
N 490 16010 490 16020 {
lab=GND}
N 550 15960 550 16010 {
lab=Y6}
N 550 16010 550 16020 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 15990 1 0 {name=M1176
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 16020 600 16020 {
lab=GND}
N 600 16010 600 16020 {
lab=GND}
N 560 15970 600 15970 {
lab=word266}
N 600 15970 640 15970 {
lab=word266}
N 570 15960 570 16010 {
lab=GND}
N 570 16010 570 16020 {
lab=GND}
N 630 15960 630 16010 {
lab=Y7}
N 630 16010 630 16020 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 15990 1 0 {name=M1177
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16030 0 0 {name=p290 lab=word267}
N 0 16030 40 16030 {
lab=word267}
N 40 16030 80 16030 {
lab=word267}
N 10 16020 10 16070 {
lab=GND}
N 10 16070 10 16080 {
lab=GND}
N 70 16020 70 16070 {
lab=Y0}
N 70 16070 70 16080 {
lab=Y0}
N 80 16030 120 16030 {
lab=word267}
N 120 16030 160 16030 {
lab=word267}
N 90 16020 90 16070 {
lab=GND}
N 90 16070 90 16080 {
lab=GND}
N 150 16020 150 16070 {
lab=Y1}
N 150 16070 150 16080 {
lab=Y1}
N 160 16030 200 16030 {
lab=word267}
N 200 16030 240 16030 {
lab=word267}
N 170 16020 170 16070 {
lab=GND}
N 170 16070 170 16080 {
lab=GND}
N 230 16020 230 16070 {
lab=Y2}
N 230 16070 230 16080 {
lab=Y2}

N 250 16080 280 16080 {
lab=GND}
N 280 16070 280 16080 {
lab=GND}
N 240 16030 280 16030 {
lab=word267}
N 280 16030 320 16030 {
lab=word267}
N 250 16020 250 16070 {
lab=GND}
N 250 16070 250 16080 {
lab=GND}
N 310 16020 310 16070 {
lab=Y3}
N 310 16070 310 16080 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 16050 1 0 {name=M1178
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 16030 360 16030 {
lab=word267}
N 360 16030 400 16030 {
lab=word267}
N 330 16020 330 16070 {
lab=GND}
N 330 16070 330 16080 {
lab=GND}
N 390 16020 390 16070 {
lab=Y4}
N 390 16070 390 16080 {
lab=Y4}

N 410 16080 440 16080 {
lab=GND}
N 440 16070 440 16080 {
lab=GND}
N 400 16030 440 16030 {
lab=word267}
N 440 16030 480 16030 {
lab=word267}
N 410 16020 410 16070 {
lab=GND}
N 410 16070 410 16080 {
lab=GND}
N 470 16020 470 16070 {
lab=Y5}
N 470 16070 470 16080 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 16050 1 0 {name=M1179
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 16030 520 16030 {
lab=word267}
N 520 16030 560 16030 {
lab=word267}
N 490 16020 490 16070 {
lab=GND}
N 490 16070 490 16080 {
lab=GND}
N 550 16020 550 16070 {
lab=Y6}
N 550 16070 550 16080 {
lab=Y6}

N 570 16080 600 16080 {
lab=GND}
N 600 16070 600 16080 {
lab=GND}
N 560 16030 600 16030 {
lab=word267}
N 600 16030 640 16030 {
lab=word267}
N 570 16020 570 16070 {
lab=GND}
N 570 16070 570 16080 {
lab=GND}
N 630 16020 630 16070 {
lab=Y7}
N 630 16070 630 16080 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16050 1 0 {name=M1180
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16090 0 0 {name=p291 lab=word268}
N 0 16090 40 16090 {
lab=word268}
N 40 16090 80 16090 {
lab=word268}
N 10 16080 10 16130 {
lab=GND}
N 10 16130 10 16140 {
lab=GND}
N 70 16080 70 16130 {
lab=Y0}
N 70 16130 70 16140 {
lab=Y0}
N 80 16090 120 16090 {
lab=word268}
N 120 16090 160 16090 {
lab=word268}
N 90 16080 90 16130 {
lab=GND}
N 90 16130 90 16140 {
lab=GND}
N 150 16080 150 16130 {
lab=Y1}
N 150 16130 150 16140 {
lab=Y1}
N 160 16090 200 16090 {
lab=word268}
N 200 16090 240 16090 {
lab=word268}
N 170 16080 170 16130 {
lab=GND}
N 170 16130 170 16140 {
lab=GND}
N 230 16080 230 16130 {
lab=Y2}
N 230 16130 230 16140 {
lab=Y2}

N 250 16140 280 16140 {
lab=GND}
N 280 16130 280 16140 {
lab=GND}
N 240 16090 280 16090 {
lab=word268}
N 280 16090 320 16090 {
lab=word268}
N 250 16080 250 16130 {
lab=GND}
N 250 16130 250 16140 {
lab=GND}
N 310 16080 310 16130 {
lab=Y3}
N 310 16130 310 16140 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 16110 1 0 {name=M1181
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 16090 360 16090 {
lab=word268}
N 360 16090 400 16090 {
lab=word268}
N 330 16080 330 16130 {
lab=GND}
N 330 16130 330 16140 {
lab=GND}
N 390 16080 390 16130 {
lab=Y4}
N 390 16130 390 16140 {
lab=Y4}

N 410 16140 440 16140 {
lab=GND}
N 440 16130 440 16140 {
lab=GND}
N 400 16090 440 16090 {
lab=word268}
N 440 16090 480 16090 {
lab=word268}
N 410 16080 410 16130 {
lab=GND}
N 410 16130 410 16140 {
lab=GND}
N 470 16080 470 16130 {
lab=Y5}
N 470 16130 470 16140 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 16110 1 0 {name=M1182
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 16140 520 16140 {
lab=GND}
N 520 16130 520 16140 {
lab=GND}
N 480 16090 520 16090 {
lab=word268}
N 520 16090 560 16090 {
lab=word268}
N 490 16080 490 16130 {
lab=GND}
N 490 16130 490 16140 {
lab=GND}
N 550 16080 550 16130 {
lab=Y6}
N 550 16130 550 16140 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 16110 1 0 {name=M1183
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 16140 600 16140 {
lab=GND}
N 600 16130 600 16140 {
lab=GND}
N 560 16090 600 16090 {
lab=word268}
N 600 16090 640 16090 {
lab=word268}
N 570 16080 570 16130 {
lab=GND}
N 570 16130 570 16140 {
lab=GND}
N 630 16080 630 16130 {
lab=Y7}
N 630 16130 630 16140 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16110 1 0 {name=M1184
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16150 0 0 {name=p292 lab=word269}
N 0 16150 40 16150 {
lab=word269}
N 40 16150 80 16150 {
lab=word269}
N 10 16140 10 16190 {
lab=GND}
N 10 16190 10 16200 {
lab=GND}
N 70 16140 70 16190 {
lab=Y0}
N 70 16190 70 16200 {
lab=Y0}
N 80 16150 120 16150 {
lab=word269}
N 120 16150 160 16150 {
lab=word269}
N 90 16140 90 16190 {
lab=GND}
N 90 16190 90 16200 {
lab=GND}
N 150 16140 150 16190 {
lab=Y1}
N 150 16190 150 16200 {
lab=Y1}
N 160 16150 200 16150 {
lab=word269}
N 200 16150 240 16150 {
lab=word269}
N 170 16140 170 16190 {
lab=GND}
N 170 16190 170 16200 {
lab=GND}
N 230 16140 230 16190 {
lab=Y2}
N 230 16190 230 16200 {
lab=Y2}

N 250 16200 280 16200 {
lab=GND}
N 280 16190 280 16200 {
lab=GND}
N 240 16150 280 16150 {
lab=word269}
N 280 16150 320 16150 {
lab=word269}
N 250 16140 250 16190 {
lab=GND}
N 250 16190 250 16200 {
lab=GND}
N 310 16140 310 16190 {
lab=Y3}
N 310 16190 310 16200 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 16170 1 0 {name=M1185
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 16200 360 16200 {
lab=GND}
N 360 16190 360 16200 {
lab=GND}
N 320 16150 360 16150 {
lab=word269}
N 360 16150 400 16150 {
lab=word269}
N 330 16140 330 16190 {
lab=GND}
N 330 16190 330 16200 {
lab=GND}
N 390 16140 390 16190 {
lab=Y4}
N 390 16190 390 16200 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 16170 1 0 {name=M1186
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 16150 440 16150 {
lab=word269}
N 440 16150 480 16150 {
lab=word269}
N 410 16140 410 16190 {
lab=GND}
N 410 16190 410 16200 {
lab=GND}
N 470 16140 470 16190 {
lab=Y5}
N 470 16190 470 16200 {
lab=Y5}
N 480 16150 520 16150 {
lab=word269}
N 520 16150 560 16150 {
lab=word269}
N 490 16140 490 16190 {
lab=GND}
N 490 16190 490 16200 {
lab=GND}
N 550 16140 550 16190 {
lab=Y6}
N 550 16190 550 16200 {
lab=Y6}

N 570 16200 600 16200 {
lab=GND}
N 600 16190 600 16200 {
lab=GND}
N 560 16150 600 16150 {
lab=word269}
N 600 16150 640 16150 {
lab=word269}
N 570 16140 570 16190 {
lab=GND}
N 570 16190 570 16200 {
lab=GND}
N 630 16140 630 16190 {
lab=Y7}
N 630 16190 630 16200 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16170 1 0 {name=M1187
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16210 0 0 {name=p293 lab=word270}
N 0 16210 40 16210 {
lab=word270}
N 40 16210 80 16210 {
lab=word270}
N 10 16200 10 16250 {
lab=GND}
N 10 16250 10 16260 {
lab=GND}
N 70 16200 70 16250 {
lab=Y0}
N 70 16250 70 16260 {
lab=Y0}
N 80 16210 120 16210 {
lab=word270}
N 120 16210 160 16210 {
lab=word270}
N 90 16200 90 16250 {
lab=GND}
N 90 16250 90 16260 {
lab=GND}
N 150 16200 150 16250 {
lab=Y1}
N 150 16250 150 16260 {
lab=Y1}
N 160 16210 200 16210 {
lab=word270}
N 200 16210 240 16210 {
lab=word270}
N 170 16200 170 16250 {
lab=GND}
N 170 16250 170 16260 {
lab=GND}
N 230 16200 230 16250 {
lab=Y2}
N 230 16250 230 16260 {
lab=Y2}

N 250 16260 280 16260 {
lab=GND}
N 280 16250 280 16260 {
lab=GND}
N 240 16210 280 16210 {
lab=word270}
N 280 16210 320 16210 {
lab=word270}
N 250 16200 250 16250 {
lab=GND}
N 250 16250 250 16260 {
lab=GND}
N 310 16200 310 16250 {
lab=Y3}
N 310 16250 310 16260 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 16230 1 0 {name=M1188
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 16260 360 16260 {
lab=GND}
N 360 16250 360 16260 {
lab=GND}
N 320 16210 360 16210 {
lab=word270}
N 360 16210 400 16210 {
lab=word270}
N 330 16200 330 16250 {
lab=GND}
N 330 16250 330 16260 {
lab=GND}
N 390 16200 390 16250 {
lab=Y4}
N 390 16250 390 16260 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 16230 1 0 {name=M1189
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 16210 440 16210 {
lab=word270}
N 440 16210 480 16210 {
lab=word270}
N 410 16200 410 16250 {
lab=GND}
N 410 16250 410 16260 {
lab=GND}
N 470 16200 470 16250 {
lab=Y5}
N 470 16250 470 16260 {
lab=Y5}

N 490 16260 520 16260 {
lab=GND}
N 520 16250 520 16260 {
lab=GND}
N 480 16210 520 16210 {
lab=word270}
N 520 16210 560 16210 {
lab=word270}
N 490 16200 490 16250 {
lab=GND}
N 490 16250 490 16260 {
lab=GND}
N 550 16200 550 16250 {
lab=Y6}
N 550 16250 550 16260 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 16230 1 0 {name=M1190
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 16260 600 16260 {
lab=GND}
N 600 16250 600 16260 {
lab=GND}
N 560 16210 600 16210 {
lab=word270}
N 600 16210 640 16210 {
lab=word270}
N 570 16200 570 16250 {
lab=GND}
N 570 16250 570 16260 {
lab=GND}
N 630 16200 630 16250 {
lab=Y7}
N 630 16250 630 16260 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16230 1 0 {name=M1191
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16270 0 0 {name=p294 lab=word271}
N 0 16270 40 16270 {
lab=word271}
N 40 16270 80 16270 {
lab=word271}
N 10 16260 10 16310 {
lab=GND}
N 10 16310 10 16320 {
lab=GND}
N 70 16260 70 16310 {
lab=Y0}
N 70 16310 70 16320 {
lab=Y0}
N 80 16270 120 16270 {
lab=word271}
N 120 16270 160 16270 {
lab=word271}
N 90 16260 90 16310 {
lab=GND}
N 90 16310 90 16320 {
lab=GND}
N 150 16260 150 16310 {
lab=Y1}
N 150 16310 150 16320 {
lab=Y1}
N 160 16270 200 16270 {
lab=word271}
N 200 16270 240 16270 {
lab=word271}
N 170 16260 170 16310 {
lab=GND}
N 170 16310 170 16320 {
lab=GND}
N 230 16260 230 16310 {
lab=Y2}
N 230 16310 230 16320 {
lab=Y2}

N 250 16320 280 16320 {
lab=GND}
N 280 16310 280 16320 {
lab=GND}
N 240 16270 280 16270 {
lab=word271}
N 280 16270 320 16270 {
lab=word271}
N 250 16260 250 16310 {
lab=GND}
N 250 16310 250 16320 {
lab=GND}
N 310 16260 310 16310 {
lab=Y3}
N 310 16310 310 16320 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 16290 1 0 {name=M1192
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 16320 360 16320 {
lab=GND}
N 360 16310 360 16320 {
lab=GND}
N 320 16270 360 16270 {
lab=word271}
N 360 16270 400 16270 {
lab=word271}
N 330 16260 330 16310 {
lab=GND}
N 330 16310 330 16320 {
lab=GND}
N 390 16260 390 16310 {
lab=Y4}
N 390 16310 390 16320 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 16290 1 0 {name=M1193
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 16320 440 16320 {
lab=GND}
N 440 16310 440 16320 {
lab=GND}
N 400 16270 440 16270 {
lab=word271}
N 440 16270 480 16270 {
lab=word271}
N 410 16260 410 16310 {
lab=GND}
N 410 16310 410 16320 {
lab=GND}
N 470 16260 470 16310 {
lab=Y5}
N 470 16310 470 16320 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 16290 1 0 {name=M1194
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 16270 520 16270 {
lab=word271}
N 520 16270 560 16270 {
lab=word271}
N 490 16260 490 16310 {
lab=GND}
N 490 16310 490 16320 {
lab=GND}
N 550 16260 550 16310 {
lab=Y6}
N 550 16310 550 16320 {
lab=Y6}

N 570 16320 600 16320 {
lab=GND}
N 600 16310 600 16320 {
lab=GND}
N 560 16270 600 16270 {
lab=word271}
N 600 16270 640 16270 {
lab=word271}
N 570 16260 570 16310 {
lab=GND}
N 570 16310 570 16320 {
lab=GND}
N 630 16260 630 16310 {
lab=Y7}
N 630 16310 630 16320 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16290 1 0 {name=M1195
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16330 0 0 {name=p295 lab=word272}
N 0 16330 40 16330 {
lab=word272}
N 40 16330 80 16330 {
lab=word272}
N 10 16320 10 16370 {
lab=GND}
N 10 16370 10 16380 {
lab=GND}
N 70 16320 70 16370 {
lab=Y0}
N 70 16370 70 16380 {
lab=Y0}
N 80 16330 120 16330 {
lab=word272}
N 120 16330 160 16330 {
lab=word272}
N 90 16320 90 16370 {
lab=GND}
N 90 16370 90 16380 {
lab=GND}
N 150 16320 150 16370 {
lab=Y1}
N 150 16370 150 16380 {
lab=Y1}
N 160 16330 200 16330 {
lab=word272}
N 200 16330 240 16330 {
lab=word272}
N 170 16320 170 16370 {
lab=GND}
N 170 16370 170 16380 {
lab=GND}
N 230 16320 230 16370 {
lab=Y2}
N 230 16370 230 16380 {
lab=Y2}

N 250 16380 280 16380 {
lab=GND}
N 280 16370 280 16380 {
lab=GND}
N 240 16330 280 16330 {
lab=word272}
N 280 16330 320 16330 {
lab=word272}
N 250 16320 250 16370 {
lab=GND}
N 250 16370 250 16380 {
lab=GND}
N 310 16320 310 16370 {
lab=Y3}
N 310 16370 310 16380 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 16350 1 0 {name=M1196
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 16380 360 16380 {
lab=GND}
N 360 16370 360 16380 {
lab=GND}
N 320 16330 360 16330 {
lab=word272}
N 360 16330 400 16330 {
lab=word272}
N 330 16320 330 16370 {
lab=GND}
N 330 16370 330 16380 {
lab=GND}
N 390 16320 390 16370 {
lab=Y4}
N 390 16370 390 16380 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 16350 1 0 {name=M1197
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 16380 440 16380 {
lab=GND}
N 440 16370 440 16380 {
lab=GND}
N 400 16330 440 16330 {
lab=word272}
N 440 16330 480 16330 {
lab=word272}
N 410 16320 410 16370 {
lab=GND}
N 410 16370 410 16380 {
lab=GND}
N 470 16320 470 16370 {
lab=Y5}
N 470 16370 470 16380 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 16350 1 0 {name=M1198
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 16380 520 16380 {
lab=GND}
N 520 16370 520 16380 {
lab=GND}
N 480 16330 520 16330 {
lab=word272}
N 520 16330 560 16330 {
lab=word272}
N 490 16320 490 16370 {
lab=GND}
N 490 16370 490 16380 {
lab=GND}
N 550 16320 550 16370 {
lab=Y6}
N 550 16370 550 16380 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 16350 1 0 {name=M1199
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 16380 600 16380 {
lab=GND}
N 600 16370 600 16380 {
lab=GND}
N 560 16330 600 16330 {
lab=word272}
N 600 16330 640 16330 {
lab=word272}
N 570 16320 570 16370 {
lab=GND}
N 570 16370 570 16380 {
lab=GND}
N 630 16320 630 16370 {
lab=Y7}
N 630 16370 630 16380 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16350 1 0 {name=M1200
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16390 0 0 {name=p296 lab=word273}
N 0 16390 40 16390 {
lab=word273}
N 40 16390 80 16390 {
lab=word273}
N 10 16380 10 16430 {
lab=GND}
N 10 16430 10 16440 {
lab=GND}
N 70 16380 70 16430 {
lab=Y0}
N 70 16430 70 16440 {
lab=Y0}
N 80 16390 120 16390 {
lab=word273}
N 120 16390 160 16390 {
lab=word273}
N 90 16380 90 16430 {
lab=GND}
N 90 16430 90 16440 {
lab=GND}
N 150 16380 150 16430 {
lab=Y1}
N 150 16430 150 16440 {
lab=Y1}

N 170 16440 200 16440 {
lab=GND}
N 200 16430 200 16440 {
lab=GND}
N 160 16390 200 16390 {
lab=word273}
N 200 16390 240 16390 {
lab=word273}
N 170 16380 170 16430 {
lab=GND}
N 170 16430 170 16440 {
lab=GND}
N 230 16380 230 16430 {
lab=Y2}
N 230 16430 230 16440 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 16410 1 0 {name=M1201
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 16390 280 16390 {
lab=word273}
N 280 16390 320 16390 {
lab=word273}
N 250 16380 250 16430 {
lab=GND}
N 250 16430 250 16440 {
lab=GND}
N 310 16380 310 16430 {
lab=Y3}
N 310 16430 310 16440 {
lab=Y3}
N 320 16390 360 16390 {
lab=word273}
N 360 16390 400 16390 {
lab=word273}
N 330 16380 330 16430 {
lab=GND}
N 330 16430 330 16440 {
lab=GND}
N 390 16380 390 16430 {
lab=Y4}
N 390 16430 390 16440 {
lab=Y4}
N 400 16390 440 16390 {
lab=word273}
N 440 16390 480 16390 {
lab=word273}
N 410 16380 410 16430 {
lab=GND}
N 410 16430 410 16440 {
lab=GND}
N 470 16380 470 16430 {
lab=Y5}
N 470 16430 470 16440 {
lab=Y5}
N 480 16390 520 16390 {
lab=word273}
N 520 16390 560 16390 {
lab=word273}
N 490 16380 490 16430 {
lab=GND}
N 490 16430 490 16440 {
lab=GND}
N 550 16380 550 16430 {
lab=Y6}
N 550 16430 550 16440 {
lab=Y6}

N 570 16440 600 16440 {
lab=GND}
N 600 16430 600 16440 {
lab=GND}
N 560 16390 600 16390 {
lab=word273}
N 600 16390 640 16390 {
lab=word273}
N 570 16380 570 16430 {
lab=GND}
N 570 16430 570 16440 {
lab=GND}
N 630 16380 630 16430 {
lab=Y7}
N 630 16430 630 16440 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16410 1 0 {name=M1202
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16450 0 0 {name=p297 lab=word274}
N 0 16450 40 16450 {
lab=word274}
N 40 16450 80 16450 {
lab=word274}
N 10 16440 10 16490 {
lab=GND}
N 10 16490 10 16500 {
lab=GND}
N 70 16440 70 16490 {
lab=Y0}
N 70 16490 70 16500 {
lab=Y0}
N 80 16450 120 16450 {
lab=word274}
N 120 16450 160 16450 {
lab=word274}
N 90 16440 90 16490 {
lab=GND}
N 90 16490 90 16500 {
lab=GND}
N 150 16440 150 16490 {
lab=Y1}
N 150 16490 150 16500 {
lab=Y1}

N 170 16500 200 16500 {
lab=GND}
N 200 16490 200 16500 {
lab=GND}
N 160 16450 200 16450 {
lab=word274}
N 200 16450 240 16450 {
lab=word274}
N 170 16440 170 16490 {
lab=GND}
N 170 16490 170 16500 {
lab=GND}
N 230 16440 230 16490 {
lab=Y2}
N 230 16490 230 16500 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 16470 1 0 {name=M1203
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 16450 280 16450 {
lab=word274}
N 280 16450 320 16450 {
lab=word274}
N 250 16440 250 16490 {
lab=GND}
N 250 16490 250 16500 {
lab=GND}
N 310 16440 310 16490 {
lab=Y3}
N 310 16490 310 16500 {
lab=Y3}
N 320 16450 360 16450 {
lab=word274}
N 360 16450 400 16450 {
lab=word274}
N 330 16440 330 16490 {
lab=GND}
N 330 16490 330 16500 {
lab=GND}
N 390 16440 390 16490 {
lab=Y4}
N 390 16490 390 16500 {
lab=Y4}
N 400 16450 440 16450 {
lab=word274}
N 440 16450 480 16450 {
lab=word274}
N 410 16440 410 16490 {
lab=GND}
N 410 16490 410 16500 {
lab=GND}
N 470 16440 470 16490 {
lab=Y5}
N 470 16490 470 16500 {
lab=Y5}

N 490 16500 520 16500 {
lab=GND}
N 520 16490 520 16500 {
lab=GND}
N 480 16450 520 16450 {
lab=word274}
N 520 16450 560 16450 {
lab=word274}
N 490 16440 490 16490 {
lab=GND}
N 490 16490 490 16500 {
lab=GND}
N 550 16440 550 16490 {
lab=Y6}
N 550 16490 550 16500 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 16470 1 0 {name=M1204
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 16500 600 16500 {
lab=GND}
N 600 16490 600 16500 {
lab=GND}
N 560 16450 600 16450 {
lab=word274}
N 600 16450 640 16450 {
lab=word274}
N 570 16440 570 16490 {
lab=GND}
N 570 16490 570 16500 {
lab=GND}
N 630 16440 630 16490 {
lab=Y7}
N 630 16490 630 16500 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16470 1 0 {name=M1205
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16510 0 0 {name=p298 lab=word275}
N 0 16510 40 16510 {
lab=word275}
N 40 16510 80 16510 {
lab=word275}
N 10 16500 10 16550 {
lab=GND}
N 10 16550 10 16560 {
lab=GND}
N 70 16500 70 16550 {
lab=Y0}
N 70 16550 70 16560 {
lab=Y0}
N 80 16510 120 16510 {
lab=word275}
N 120 16510 160 16510 {
lab=word275}
N 90 16500 90 16550 {
lab=GND}
N 90 16550 90 16560 {
lab=GND}
N 150 16500 150 16550 {
lab=Y1}
N 150 16550 150 16560 {
lab=Y1}

N 170 16560 200 16560 {
lab=GND}
N 200 16550 200 16560 {
lab=GND}
N 160 16510 200 16510 {
lab=word275}
N 200 16510 240 16510 {
lab=word275}
N 170 16500 170 16550 {
lab=GND}
N 170 16550 170 16560 {
lab=GND}
N 230 16500 230 16550 {
lab=Y2}
N 230 16550 230 16560 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 16530 1 0 {name=M1206
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 16510 280 16510 {
lab=word275}
N 280 16510 320 16510 {
lab=word275}
N 250 16500 250 16550 {
lab=GND}
N 250 16550 250 16560 {
lab=GND}
N 310 16500 310 16550 {
lab=Y3}
N 310 16550 310 16560 {
lab=Y3}
N 320 16510 360 16510 {
lab=word275}
N 360 16510 400 16510 {
lab=word275}
N 330 16500 330 16550 {
lab=GND}
N 330 16550 330 16560 {
lab=GND}
N 390 16500 390 16550 {
lab=Y4}
N 390 16550 390 16560 {
lab=Y4}

N 410 16560 440 16560 {
lab=GND}
N 440 16550 440 16560 {
lab=GND}
N 400 16510 440 16510 {
lab=word275}
N 440 16510 480 16510 {
lab=word275}
N 410 16500 410 16550 {
lab=GND}
N 410 16550 410 16560 {
lab=GND}
N 470 16500 470 16550 {
lab=Y5}
N 470 16550 470 16560 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 16530 1 0 {name=M1207
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 16510 520 16510 {
lab=word275}
N 520 16510 560 16510 {
lab=word275}
N 490 16500 490 16550 {
lab=GND}
N 490 16550 490 16560 {
lab=GND}
N 550 16500 550 16550 {
lab=Y6}
N 550 16550 550 16560 {
lab=Y6}

N 570 16560 600 16560 {
lab=GND}
N 600 16550 600 16560 {
lab=GND}
N 560 16510 600 16510 {
lab=word275}
N 600 16510 640 16510 {
lab=word275}
N 570 16500 570 16550 {
lab=GND}
N 570 16550 570 16560 {
lab=GND}
N 630 16500 630 16550 {
lab=Y7}
N 630 16550 630 16560 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16530 1 0 {name=M1208
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16570 0 0 {name=p299 lab=word276}
N 0 16570 40 16570 {
lab=word276}
N 40 16570 80 16570 {
lab=word276}
N 10 16560 10 16610 {
lab=GND}
N 10 16610 10 16620 {
lab=GND}
N 70 16560 70 16610 {
lab=Y0}
N 70 16610 70 16620 {
lab=Y0}
N 80 16570 120 16570 {
lab=word276}
N 120 16570 160 16570 {
lab=word276}
N 90 16560 90 16610 {
lab=GND}
N 90 16610 90 16620 {
lab=GND}
N 150 16560 150 16610 {
lab=Y1}
N 150 16610 150 16620 {
lab=Y1}

N 170 16620 200 16620 {
lab=GND}
N 200 16610 200 16620 {
lab=GND}
N 160 16570 200 16570 {
lab=word276}
N 200 16570 240 16570 {
lab=word276}
N 170 16560 170 16610 {
lab=GND}
N 170 16610 170 16620 {
lab=GND}
N 230 16560 230 16610 {
lab=Y2}
N 230 16610 230 16620 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 16590 1 0 {name=M1209
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 16570 280 16570 {
lab=word276}
N 280 16570 320 16570 {
lab=word276}
N 250 16560 250 16610 {
lab=GND}
N 250 16610 250 16620 {
lab=GND}
N 310 16560 310 16610 {
lab=Y3}
N 310 16610 310 16620 {
lab=Y3}
N 320 16570 360 16570 {
lab=word276}
N 360 16570 400 16570 {
lab=word276}
N 330 16560 330 16610 {
lab=GND}
N 330 16610 330 16620 {
lab=GND}
N 390 16560 390 16610 {
lab=Y4}
N 390 16610 390 16620 {
lab=Y4}

N 410 16620 440 16620 {
lab=GND}
N 440 16610 440 16620 {
lab=GND}
N 400 16570 440 16570 {
lab=word276}
N 440 16570 480 16570 {
lab=word276}
N 410 16560 410 16610 {
lab=GND}
N 410 16610 410 16620 {
lab=GND}
N 470 16560 470 16610 {
lab=Y5}
N 470 16610 470 16620 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 16590 1 0 {name=M1210
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 16620 520 16620 {
lab=GND}
N 520 16610 520 16620 {
lab=GND}
N 480 16570 520 16570 {
lab=word276}
N 520 16570 560 16570 {
lab=word276}
N 490 16560 490 16610 {
lab=GND}
N 490 16610 490 16620 {
lab=GND}
N 550 16560 550 16610 {
lab=Y6}
N 550 16610 550 16620 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 16590 1 0 {name=M1211
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 16620 600 16620 {
lab=GND}
N 600 16610 600 16620 {
lab=GND}
N 560 16570 600 16570 {
lab=word276}
N 600 16570 640 16570 {
lab=word276}
N 570 16560 570 16610 {
lab=GND}
N 570 16610 570 16620 {
lab=GND}
N 630 16560 630 16610 {
lab=Y7}
N 630 16610 630 16620 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16590 1 0 {name=M1212
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16630 0 0 {name=p300 lab=word277}
N 0 16630 40 16630 {
lab=word277}
N 40 16630 80 16630 {
lab=word277}
N 10 16620 10 16670 {
lab=GND}
N 10 16670 10 16680 {
lab=GND}
N 70 16620 70 16670 {
lab=Y0}
N 70 16670 70 16680 {
lab=Y0}
N 80 16630 120 16630 {
lab=word277}
N 120 16630 160 16630 {
lab=word277}
N 90 16620 90 16670 {
lab=GND}
N 90 16670 90 16680 {
lab=GND}
N 150 16620 150 16670 {
lab=Y1}
N 150 16670 150 16680 {
lab=Y1}

N 170 16680 200 16680 {
lab=GND}
N 200 16670 200 16680 {
lab=GND}
N 160 16630 200 16630 {
lab=word277}
N 200 16630 240 16630 {
lab=word277}
N 170 16620 170 16670 {
lab=GND}
N 170 16670 170 16680 {
lab=GND}
N 230 16620 230 16670 {
lab=Y2}
N 230 16670 230 16680 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 16650 1 0 {name=M1213
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 16630 280 16630 {
lab=word277}
N 280 16630 320 16630 {
lab=word277}
N 250 16620 250 16670 {
lab=GND}
N 250 16670 250 16680 {
lab=GND}
N 310 16620 310 16670 {
lab=Y3}
N 310 16670 310 16680 {
lab=Y3}

N 330 16680 360 16680 {
lab=GND}
N 360 16670 360 16680 {
lab=GND}
N 320 16630 360 16630 {
lab=word277}
N 360 16630 400 16630 {
lab=word277}
N 330 16620 330 16670 {
lab=GND}
N 330 16670 330 16680 {
lab=GND}
N 390 16620 390 16670 {
lab=Y4}
N 390 16670 390 16680 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 16650 1 0 {name=M1214
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 16630 440 16630 {
lab=word277}
N 440 16630 480 16630 {
lab=word277}
N 410 16620 410 16670 {
lab=GND}
N 410 16670 410 16680 {
lab=GND}
N 470 16620 470 16670 {
lab=Y5}
N 470 16670 470 16680 {
lab=Y5}
N 480 16630 520 16630 {
lab=word277}
N 520 16630 560 16630 {
lab=word277}
N 490 16620 490 16670 {
lab=GND}
N 490 16670 490 16680 {
lab=GND}
N 550 16620 550 16670 {
lab=Y6}
N 550 16670 550 16680 {
lab=Y6}

N 570 16680 600 16680 {
lab=GND}
N 600 16670 600 16680 {
lab=GND}
N 560 16630 600 16630 {
lab=word277}
N 600 16630 640 16630 {
lab=word277}
N 570 16620 570 16670 {
lab=GND}
N 570 16670 570 16680 {
lab=GND}
N 630 16620 630 16670 {
lab=Y7}
N 630 16670 630 16680 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16650 1 0 {name=M1215
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16690 0 0 {name=p301 lab=word278}
N 0 16690 40 16690 {
lab=word278}
N 40 16690 80 16690 {
lab=word278}
N 10 16680 10 16730 {
lab=GND}
N 10 16730 10 16740 {
lab=GND}
N 70 16680 70 16730 {
lab=Y0}
N 70 16730 70 16740 {
lab=Y0}
N 80 16690 120 16690 {
lab=word278}
N 120 16690 160 16690 {
lab=word278}
N 90 16680 90 16730 {
lab=GND}
N 90 16730 90 16740 {
lab=GND}
N 150 16680 150 16730 {
lab=Y1}
N 150 16730 150 16740 {
lab=Y1}

N 170 16740 200 16740 {
lab=GND}
N 200 16730 200 16740 {
lab=GND}
N 160 16690 200 16690 {
lab=word278}
N 200 16690 240 16690 {
lab=word278}
N 170 16680 170 16730 {
lab=GND}
N 170 16730 170 16740 {
lab=GND}
N 230 16680 230 16730 {
lab=Y2}
N 230 16730 230 16740 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 16710 1 0 {name=M1216
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 16690 280 16690 {
lab=word278}
N 280 16690 320 16690 {
lab=word278}
N 250 16680 250 16730 {
lab=GND}
N 250 16730 250 16740 {
lab=GND}
N 310 16680 310 16730 {
lab=Y3}
N 310 16730 310 16740 {
lab=Y3}

N 330 16740 360 16740 {
lab=GND}
N 360 16730 360 16740 {
lab=GND}
N 320 16690 360 16690 {
lab=word278}
N 360 16690 400 16690 {
lab=word278}
N 330 16680 330 16730 {
lab=GND}
N 330 16730 330 16740 {
lab=GND}
N 390 16680 390 16730 {
lab=Y4}
N 390 16730 390 16740 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 16710 1 0 {name=M1217
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 16690 440 16690 {
lab=word278}
N 440 16690 480 16690 {
lab=word278}
N 410 16680 410 16730 {
lab=GND}
N 410 16730 410 16740 {
lab=GND}
N 470 16680 470 16730 {
lab=Y5}
N 470 16730 470 16740 {
lab=Y5}

N 490 16740 520 16740 {
lab=GND}
N 520 16730 520 16740 {
lab=GND}
N 480 16690 520 16690 {
lab=word278}
N 520 16690 560 16690 {
lab=word278}
N 490 16680 490 16730 {
lab=GND}
N 490 16730 490 16740 {
lab=GND}
N 550 16680 550 16730 {
lab=Y6}
N 550 16730 550 16740 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 16710 1 0 {name=M1218
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 16740 600 16740 {
lab=GND}
N 600 16730 600 16740 {
lab=GND}
N 560 16690 600 16690 {
lab=word278}
N 600 16690 640 16690 {
lab=word278}
N 570 16680 570 16730 {
lab=GND}
N 570 16730 570 16740 {
lab=GND}
N 630 16680 630 16730 {
lab=Y7}
N 630 16730 630 16740 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16710 1 0 {name=M1219
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16750 0 0 {name=p302 lab=word279}
N 0 16750 40 16750 {
lab=word279}
N 40 16750 80 16750 {
lab=word279}
N 10 16740 10 16790 {
lab=GND}
N 10 16790 10 16800 {
lab=GND}
N 70 16740 70 16790 {
lab=Y0}
N 70 16790 70 16800 {
lab=Y0}
N 80 16750 120 16750 {
lab=word279}
N 120 16750 160 16750 {
lab=word279}
N 90 16740 90 16790 {
lab=GND}
N 90 16790 90 16800 {
lab=GND}
N 150 16740 150 16790 {
lab=Y1}
N 150 16790 150 16800 {
lab=Y1}

N 170 16800 200 16800 {
lab=GND}
N 200 16790 200 16800 {
lab=GND}
N 160 16750 200 16750 {
lab=word279}
N 200 16750 240 16750 {
lab=word279}
N 170 16740 170 16790 {
lab=GND}
N 170 16790 170 16800 {
lab=GND}
N 230 16740 230 16790 {
lab=Y2}
N 230 16790 230 16800 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 16770 1 0 {name=M1220
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 16750 280 16750 {
lab=word279}
N 280 16750 320 16750 {
lab=word279}
N 250 16740 250 16790 {
lab=GND}
N 250 16790 250 16800 {
lab=GND}
N 310 16740 310 16790 {
lab=Y3}
N 310 16790 310 16800 {
lab=Y3}

N 330 16800 360 16800 {
lab=GND}
N 360 16790 360 16800 {
lab=GND}
N 320 16750 360 16750 {
lab=word279}
N 360 16750 400 16750 {
lab=word279}
N 330 16740 330 16790 {
lab=GND}
N 330 16790 330 16800 {
lab=GND}
N 390 16740 390 16790 {
lab=Y4}
N 390 16790 390 16800 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 16770 1 0 {name=M1221
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 16800 440 16800 {
lab=GND}
N 440 16790 440 16800 {
lab=GND}
N 400 16750 440 16750 {
lab=word279}
N 440 16750 480 16750 {
lab=word279}
N 410 16740 410 16790 {
lab=GND}
N 410 16790 410 16800 {
lab=GND}
N 470 16740 470 16790 {
lab=Y5}
N 470 16790 470 16800 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 16770 1 0 {name=M1222
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 16750 520 16750 {
lab=word279}
N 520 16750 560 16750 {
lab=word279}
N 490 16740 490 16790 {
lab=GND}
N 490 16790 490 16800 {
lab=GND}
N 550 16740 550 16790 {
lab=Y6}
N 550 16790 550 16800 {
lab=Y6}

N 570 16800 600 16800 {
lab=GND}
N 600 16790 600 16800 {
lab=GND}
N 560 16750 600 16750 {
lab=word279}
N 600 16750 640 16750 {
lab=word279}
N 570 16740 570 16790 {
lab=GND}
N 570 16790 570 16800 {
lab=GND}
N 630 16740 630 16790 {
lab=Y7}
N 630 16790 630 16800 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16770 1 0 {name=M1223
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16810 0 0 {name=p303 lab=word280}
N 0 16810 40 16810 {
lab=word280}
N 40 16810 80 16810 {
lab=word280}
N 10 16800 10 16850 {
lab=GND}
N 10 16850 10 16860 {
lab=GND}
N 70 16800 70 16850 {
lab=Y0}
N 70 16850 70 16860 {
lab=Y0}
N 80 16810 120 16810 {
lab=word280}
N 120 16810 160 16810 {
lab=word280}
N 90 16800 90 16850 {
lab=GND}
N 90 16850 90 16860 {
lab=GND}
N 150 16800 150 16850 {
lab=Y1}
N 150 16850 150 16860 {
lab=Y1}

N 170 16860 200 16860 {
lab=GND}
N 200 16850 200 16860 {
lab=GND}
N 160 16810 200 16810 {
lab=word280}
N 200 16810 240 16810 {
lab=word280}
N 170 16800 170 16850 {
lab=GND}
N 170 16850 170 16860 {
lab=GND}
N 230 16800 230 16850 {
lab=Y2}
N 230 16850 230 16860 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 16830 1 0 {name=M1224
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 16810 280 16810 {
lab=word280}
N 280 16810 320 16810 {
lab=word280}
N 250 16800 250 16850 {
lab=GND}
N 250 16850 250 16860 {
lab=GND}
N 310 16800 310 16850 {
lab=Y3}
N 310 16850 310 16860 {
lab=Y3}

N 330 16860 360 16860 {
lab=GND}
N 360 16850 360 16860 {
lab=GND}
N 320 16810 360 16810 {
lab=word280}
N 360 16810 400 16810 {
lab=word280}
N 330 16800 330 16850 {
lab=GND}
N 330 16850 330 16860 {
lab=GND}
N 390 16800 390 16850 {
lab=Y4}
N 390 16850 390 16860 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 16830 1 0 {name=M1225
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 16860 440 16860 {
lab=GND}
N 440 16850 440 16860 {
lab=GND}
N 400 16810 440 16810 {
lab=word280}
N 440 16810 480 16810 {
lab=word280}
N 410 16800 410 16850 {
lab=GND}
N 410 16850 410 16860 {
lab=GND}
N 470 16800 470 16850 {
lab=Y5}
N 470 16850 470 16860 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 16830 1 0 {name=M1226
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 16860 520 16860 {
lab=GND}
N 520 16850 520 16860 {
lab=GND}
N 480 16810 520 16810 {
lab=word280}
N 520 16810 560 16810 {
lab=word280}
N 490 16800 490 16850 {
lab=GND}
N 490 16850 490 16860 {
lab=GND}
N 550 16800 550 16850 {
lab=Y6}
N 550 16850 550 16860 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 16830 1 0 {name=M1227
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 16860 600 16860 {
lab=GND}
N 600 16850 600 16860 {
lab=GND}
N 560 16810 600 16810 {
lab=word280}
N 600 16810 640 16810 {
lab=word280}
N 570 16800 570 16850 {
lab=GND}
N 570 16850 570 16860 {
lab=GND}
N 630 16800 630 16850 {
lab=Y7}
N 630 16850 630 16860 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16830 1 0 {name=M1228
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16870 0 0 {name=p304 lab=word281}
N 0 16870 40 16870 {
lab=word281}
N 40 16870 80 16870 {
lab=word281}
N 10 16860 10 16910 {
lab=GND}
N 10 16910 10 16920 {
lab=GND}
N 70 16860 70 16910 {
lab=Y0}
N 70 16910 70 16920 {
lab=Y0}
N 80 16870 120 16870 {
lab=word281}
N 120 16870 160 16870 {
lab=word281}
N 90 16860 90 16910 {
lab=GND}
N 90 16910 90 16920 {
lab=GND}
N 150 16860 150 16910 {
lab=Y1}
N 150 16910 150 16920 {
lab=Y1}

N 170 16920 200 16920 {
lab=GND}
N 200 16910 200 16920 {
lab=GND}
N 160 16870 200 16870 {
lab=word281}
N 200 16870 240 16870 {
lab=word281}
N 170 16860 170 16910 {
lab=GND}
N 170 16910 170 16920 {
lab=GND}
N 230 16860 230 16910 {
lab=Y2}
N 230 16910 230 16920 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 16890 1 0 {name=M1229
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 16920 280 16920 {
lab=GND}
N 280 16910 280 16920 {
lab=GND}
N 240 16870 280 16870 {
lab=word281}
N 280 16870 320 16870 {
lab=word281}
N 250 16860 250 16910 {
lab=GND}
N 250 16910 250 16920 {
lab=GND}
N 310 16860 310 16910 {
lab=Y3}
N 310 16910 310 16920 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 16890 1 0 {name=M1230
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 16870 360 16870 {
lab=word281}
N 360 16870 400 16870 {
lab=word281}
N 330 16860 330 16910 {
lab=GND}
N 330 16910 330 16920 {
lab=GND}
N 390 16860 390 16910 {
lab=Y4}
N 390 16910 390 16920 {
lab=Y4}
N 400 16870 440 16870 {
lab=word281}
N 440 16870 480 16870 {
lab=word281}
N 410 16860 410 16910 {
lab=GND}
N 410 16910 410 16920 {
lab=GND}
N 470 16860 470 16910 {
lab=Y5}
N 470 16910 470 16920 {
lab=Y5}
N 480 16870 520 16870 {
lab=word281}
N 520 16870 560 16870 {
lab=word281}
N 490 16860 490 16910 {
lab=GND}
N 490 16910 490 16920 {
lab=GND}
N 550 16860 550 16910 {
lab=Y6}
N 550 16910 550 16920 {
lab=Y6}

N 570 16920 600 16920 {
lab=GND}
N 600 16910 600 16920 {
lab=GND}
N 560 16870 600 16870 {
lab=word281}
N 600 16870 640 16870 {
lab=word281}
N 570 16860 570 16910 {
lab=GND}
N 570 16910 570 16920 {
lab=GND}
N 630 16860 630 16910 {
lab=Y7}
N 630 16910 630 16920 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16890 1 0 {name=M1231
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16930 0 0 {name=p305 lab=word282}
N 0 16930 40 16930 {
lab=word282}
N 40 16930 80 16930 {
lab=word282}
N 10 16920 10 16970 {
lab=GND}
N 10 16970 10 16980 {
lab=GND}
N 70 16920 70 16970 {
lab=Y0}
N 70 16970 70 16980 {
lab=Y0}
N 80 16930 120 16930 {
lab=word282}
N 120 16930 160 16930 {
lab=word282}
N 90 16920 90 16970 {
lab=GND}
N 90 16970 90 16980 {
lab=GND}
N 150 16920 150 16970 {
lab=Y1}
N 150 16970 150 16980 {
lab=Y1}

N 170 16980 200 16980 {
lab=GND}
N 200 16970 200 16980 {
lab=GND}
N 160 16930 200 16930 {
lab=word282}
N 200 16930 240 16930 {
lab=word282}
N 170 16920 170 16970 {
lab=GND}
N 170 16970 170 16980 {
lab=GND}
N 230 16920 230 16970 {
lab=Y2}
N 230 16970 230 16980 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 16950 1 0 {name=M1232
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 16980 280 16980 {
lab=GND}
N 280 16970 280 16980 {
lab=GND}
N 240 16930 280 16930 {
lab=word282}
N 280 16930 320 16930 {
lab=word282}
N 250 16920 250 16970 {
lab=GND}
N 250 16970 250 16980 {
lab=GND}
N 310 16920 310 16970 {
lab=Y3}
N 310 16970 310 16980 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 16950 1 0 {name=M1233
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 16930 360 16930 {
lab=word282}
N 360 16930 400 16930 {
lab=word282}
N 330 16920 330 16970 {
lab=GND}
N 330 16970 330 16980 {
lab=GND}
N 390 16920 390 16970 {
lab=Y4}
N 390 16970 390 16980 {
lab=Y4}
N 400 16930 440 16930 {
lab=word282}
N 440 16930 480 16930 {
lab=word282}
N 410 16920 410 16970 {
lab=GND}
N 410 16970 410 16980 {
lab=GND}
N 470 16920 470 16970 {
lab=Y5}
N 470 16970 470 16980 {
lab=Y5}

N 490 16980 520 16980 {
lab=GND}
N 520 16970 520 16980 {
lab=GND}
N 480 16930 520 16930 {
lab=word282}
N 520 16930 560 16930 {
lab=word282}
N 490 16920 490 16970 {
lab=GND}
N 490 16970 490 16980 {
lab=GND}
N 550 16920 550 16970 {
lab=Y6}
N 550 16970 550 16980 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 16950 1 0 {name=M1234
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 16980 600 16980 {
lab=GND}
N 600 16970 600 16980 {
lab=GND}
N 560 16930 600 16930 {
lab=word282}
N 600 16930 640 16930 {
lab=word282}
N 570 16920 570 16970 {
lab=GND}
N 570 16970 570 16980 {
lab=GND}
N 630 16920 630 16970 {
lab=Y7}
N 630 16970 630 16980 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 16950 1 0 {name=M1235
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 16990 0 0 {name=p306 lab=word283}
N 0 16990 40 16990 {
lab=word283}
N 40 16990 80 16990 {
lab=word283}
N 10 16980 10 17030 {
lab=GND}
N 10 17030 10 17040 {
lab=GND}
N 70 16980 70 17030 {
lab=Y0}
N 70 17030 70 17040 {
lab=Y0}
N 80 16990 120 16990 {
lab=word283}
N 120 16990 160 16990 {
lab=word283}
N 90 16980 90 17030 {
lab=GND}
N 90 17030 90 17040 {
lab=GND}
N 150 16980 150 17030 {
lab=Y1}
N 150 17030 150 17040 {
lab=Y1}

N 170 17040 200 17040 {
lab=GND}
N 200 17030 200 17040 {
lab=GND}
N 160 16990 200 16990 {
lab=word283}
N 200 16990 240 16990 {
lab=word283}
N 170 16980 170 17030 {
lab=GND}
N 170 17030 170 17040 {
lab=GND}
N 230 16980 230 17030 {
lab=Y2}
N 230 17030 230 17040 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 17010 1 0 {name=M1236
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 17040 280 17040 {
lab=GND}
N 280 17030 280 17040 {
lab=GND}
N 240 16990 280 16990 {
lab=word283}
N 280 16990 320 16990 {
lab=word283}
N 250 16980 250 17030 {
lab=GND}
N 250 17030 250 17040 {
lab=GND}
N 310 16980 310 17030 {
lab=Y3}
N 310 17030 310 17040 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 17010 1 0 {name=M1237
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 16990 360 16990 {
lab=word283}
N 360 16990 400 16990 {
lab=word283}
N 330 16980 330 17030 {
lab=GND}
N 330 17030 330 17040 {
lab=GND}
N 390 16980 390 17030 {
lab=Y4}
N 390 17030 390 17040 {
lab=Y4}

N 410 17040 440 17040 {
lab=GND}
N 440 17030 440 17040 {
lab=GND}
N 400 16990 440 16990 {
lab=word283}
N 440 16990 480 16990 {
lab=word283}
N 410 16980 410 17030 {
lab=GND}
N 410 17030 410 17040 {
lab=GND}
N 470 16980 470 17030 {
lab=Y5}
N 470 17030 470 17040 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 17010 1 0 {name=M1238
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 16990 520 16990 {
lab=word283}
N 520 16990 560 16990 {
lab=word283}
N 490 16980 490 17030 {
lab=GND}
N 490 17030 490 17040 {
lab=GND}
N 550 16980 550 17030 {
lab=Y6}
N 550 17030 550 17040 {
lab=Y6}

N 570 17040 600 17040 {
lab=GND}
N 600 17030 600 17040 {
lab=GND}
N 560 16990 600 16990 {
lab=word283}
N 600 16990 640 16990 {
lab=word283}
N 570 16980 570 17030 {
lab=GND}
N 570 17030 570 17040 {
lab=GND}
N 630 16980 630 17030 {
lab=Y7}
N 630 17030 630 17040 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17010 1 0 {name=M1239
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17050 0 0 {name=p307 lab=word284}
N 0 17050 40 17050 {
lab=word284}
N 40 17050 80 17050 {
lab=word284}
N 10 17040 10 17090 {
lab=GND}
N 10 17090 10 17100 {
lab=GND}
N 70 17040 70 17090 {
lab=Y0}
N 70 17090 70 17100 {
lab=Y0}
N 80 17050 120 17050 {
lab=word284}
N 120 17050 160 17050 {
lab=word284}
N 90 17040 90 17090 {
lab=GND}
N 90 17090 90 17100 {
lab=GND}
N 150 17040 150 17090 {
lab=Y1}
N 150 17090 150 17100 {
lab=Y1}

N 170 17100 200 17100 {
lab=GND}
N 200 17090 200 17100 {
lab=GND}
N 160 17050 200 17050 {
lab=word284}
N 200 17050 240 17050 {
lab=word284}
N 170 17040 170 17090 {
lab=GND}
N 170 17090 170 17100 {
lab=GND}
N 230 17040 230 17090 {
lab=Y2}
N 230 17090 230 17100 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 17070 1 0 {name=M1240
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 17100 280 17100 {
lab=GND}
N 280 17090 280 17100 {
lab=GND}
N 240 17050 280 17050 {
lab=word284}
N 280 17050 320 17050 {
lab=word284}
N 250 17040 250 17090 {
lab=GND}
N 250 17090 250 17100 {
lab=GND}
N 310 17040 310 17090 {
lab=Y3}
N 310 17090 310 17100 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 17070 1 0 {name=M1241
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 17050 360 17050 {
lab=word284}
N 360 17050 400 17050 {
lab=word284}
N 330 17040 330 17090 {
lab=GND}
N 330 17090 330 17100 {
lab=GND}
N 390 17040 390 17090 {
lab=Y4}
N 390 17090 390 17100 {
lab=Y4}

N 410 17100 440 17100 {
lab=GND}
N 440 17090 440 17100 {
lab=GND}
N 400 17050 440 17050 {
lab=word284}
N 440 17050 480 17050 {
lab=word284}
N 410 17040 410 17090 {
lab=GND}
N 410 17090 410 17100 {
lab=GND}
N 470 17040 470 17090 {
lab=Y5}
N 470 17090 470 17100 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 17070 1 0 {name=M1242
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 17100 520 17100 {
lab=GND}
N 520 17090 520 17100 {
lab=GND}
N 480 17050 520 17050 {
lab=word284}
N 520 17050 560 17050 {
lab=word284}
N 490 17040 490 17090 {
lab=GND}
N 490 17090 490 17100 {
lab=GND}
N 550 17040 550 17090 {
lab=Y6}
N 550 17090 550 17100 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 17070 1 0 {name=M1243
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 17100 600 17100 {
lab=GND}
N 600 17090 600 17100 {
lab=GND}
N 560 17050 600 17050 {
lab=word284}
N 600 17050 640 17050 {
lab=word284}
N 570 17040 570 17090 {
lab=GND}
N 570 17090 570 17100 {
lab=GND}
N 630 17040 630 17090 {
lab=Y7}
N 630 17090 630 17100 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17070 1 0 {name=M1244
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17110 0 0 {name=p308 lab=word285}
N 0 17110 40 17110 {
lab=word285}
N 40 17110 80 17110 {
lab=word285}
N 10 17100 10 17150 {
lab=GND}
N 10 17150 10 17160 {
lab=GND}
N 70 17100 70 17150 {
lab=Y0}
N 70 17150 70 17160 {
lab=Y0}
N 80 17110 120 17110 {
lab=word285}
N 120 17110 160 17110 {
lab=word285}
N 90 17100 90 17150 {
lab=GND}
N 90 17150 90 17160 {
lab=GND}
N 150 17100 150 17150 {
lab=Y1}
N 150 17150 150 17160 {
lab=Y1}

N 170 17160 200 17160 {
lab=GND}
N 200 17150 200 17160 {
lab=GND}
N 160 17110 200 17110 {
lab=word285}
N 200 17110 240 17110 {
lab=word285}
N 170 17100 170 17150 {
lab=GND}
N 170 17150 170 17160 {
lab=GND}
N 230 17100 230 17150 {
lab=Y2}
N 230 17150 230 17160 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 17130 1 0 {name=M1245
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 17160 280 17160 {
lab=GND}
N 280 17150 280 17160 {
lab=GND}
N 240 17110 280 17110 {
lab=word285}
N 280 17110 320 17110 {
lab=word285}
N 250 17100 250 17150 {
lab=GND}
N 250 17150 250 17160 {
lab=GND}
N 310 17100 310 17150 {
lab=Y3}
N 310 17150 310 17160 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 17130 1 0 {name=M1246
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 17160 360 17160 {
lab=GND}
N 360 17150 360 17160 {
lab=GND}
N 320 17110 360 17110 {
lab=word285}
N 360 17110 400 17110 {
lab=word285}
N 330 17100 330 17150 {
lab=GND}
N 330 17150 330 17160 {
lab=GND}
N 390 17100 390 17150 {
lab=Y4}
N 390 17150 390 17160 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 17130 1 0 {name=M1247
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 17110 440 17110 {
lab=word285}
N 440 17110 480 17110 {
lab=word285}
N 410 17100 410 17150 {
lab=GND}
N 410 17150 410 17160 {
lab=GND}
N 470 17100 470 17150 {
lab=Y5}
N 470 17150 470 17160 {
lab=Y5}
N 480 17110 520 17110 {
lab=word285}
N 520 17110 560 17110 {
lab=word285}
N 490 17100 490 17150 {
lab=GND}
N 490 17150 490 17160 {
lab=GND}
N 550 17100 550 17150 {
lab=Y6}
N 550 17150 550 17160 {
lab=Y6}

N 570 17160 600 17160 {
lab=GND}
N 600 17150 600 17160 {
lab=GND}
N 560 17110 600 17110 {
lab=word285}
N 600 17110 640 17110 {
lab=word285}
N 570 17100 570 17150 {
lab=GND}
N 570 17150 570 17160 {
lab=GND}
N 630 17100 630 17150 {
lab=Y7}
N 630 17150 630 17160 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17130 1 0 {name=M1248
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17170 0 0 {name=p309 lab=word286}
N 0 17170 40 17170 {
lab=word286}
N 40 17170 80 17170 {
lab=word286}
N 10 17160 10 17210 {
lab=GND}
N 10 17210 10 17220 {
lab=GND}
N 70 17160 70 17210 {
lab=Y0}
N 70 17210 70 17220 {
lab=Y0}
N 80 17170 120 17170 {
lab=word286}
N 120 17170 160 17170 {
lab=word286}
N 90 17160 90 17210 {
lab=GND}
N 90 17210 90 17220 {
lab=GND}
N 150 17160 150 17210 {
lab=Y1}
N 150 17210 150 17220 {
lab=Y1}

N 170 17220 200 17220 {
lab=GND}
N 200 17210 200 17220 {
lab=GND}
N 160 17170 200 17170 {
lab=word286}
N 200 17170 240 17170 {
lab=word286}
N 170 17160 170 17210 {
lab=GND}
N 170 17210 170 17220 {
lab=GND}
N 230 17160 230 17210 {
lab=Y2}
N 230 17210 230 17220 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 17190 1 0 {name=M1249
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 17220 280 17220 {
lab=GND}
N 280 17210 280 17220 {
lab=GND}
N 240 17170 280 17170 {
lab=word286}
N 280 17170 320 17170 {
lab=word286}
N 250 17160 250 17210 {
lab=GND}
N 250 17210 250 17220 {
lab=GND}
N 310 17160 310 17210 {
lab=Y3}
N 310 17210 310 17220 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 17190 1 0 {name=M1250
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 17220 360 17220 {
lab=GND}
N 360 17210 360 17220 {
lab=GND}
N 320 17170 360 17170 {
lab=word286}
N 360 17170 400 17170 {
lab=word286}
N 330 17160 330 17210 {
lab=GND}
N 330 17210 330 17220 {
lab=GND}
N 390 17160 390 17210 {
lab=Y4}
N 390 17210 390 17220 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 17190 1 0 {name=M1251
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 17170 440 17170 {
lab=word286}
N 440 17170 480 17170 {
lab=word286}
N 410 17160 410 17210 {
lab=GND}
N 410 17210 410 17220 {
lab=GND}
N 470 17160 470 17210 {
lab=Y5}
N 470 17210 470 17220 {
lab=Y5}

N 490 17220 520 17220 {
lab=GND}
N 520 17210 520 17220 {
lab=GND}
N 480 17170 520 17170 {
lab=word286}
N 520 17170 560 17170 {
lab=word286}
N 490 17160 490 17210 {
lab=GND}
N 490 17210 490 17220 {
lab=GND}
N 550 17160 550 17210 {
lab=Y6}
N 550 17210 550 17220 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 17190 1 0 {name=M1252
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 17220 600 17220 {
lab=GND}
N 600 17210 600 17220 {
lab=GND}
N 560 17170 600 17170 {
lab=word286}
N 600 17170 640 17170 {
lab=word286}
N 570 17160 570 17210 {
lab=GND}
N 570 17210 570 17220 {
lab=GND}
N 630 17160 630 17210 {
lab=Y7}
N 630 17210 630 17220 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17190 1 0 {name=M1253
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17230 0 0 {name=p310 lab=word287}
N 0 17230 40 17230 {
lab=word287}
N 40 17230 80 17230 {
lab=word287}
N 10 17220 10 17270 {
lab=GND}
N 10 17270 10 17280 {
lab=GND}
N 70 17220 70 17270 {
lab=Y0}
N 70 17270 70 17280 {
lab=Y0}
N 80 17230 120 17230 {
lab=word287}
N 120 17230 160 17230 {
lab=word287}
N 90 17220 90 17270 {
lab=GND}
N 90 17270 90 17280 {
lab=GND}
N 150 17220 150 17270 {
lab=Y1}
N 150 17270 150 17280 {
lab=Y1}

N 170 17280 200 17280 {
lab=GND}
N 200 17270 200 17280 {
lab=GND}
N 160 17230 200 17230 {
lab=word287}
N 200 17230 240 17230 {
lab=word287}
N 170 17220 170 17270 {
lab=GND}
N 170 17270 170 17280 {
lab=GND}
N 230 17220 230 17270 {
lab=Y2}
N 230 17270 230 17280 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 17250 1 0 {name=M1254
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 17280 280 17280 {
lab=GND}
N 280 17270 280 17280 {
lab=GND}
N 240 17230 280 17230 {
lab=word287}
N 280 17230 320 17230 {
lab=word287}
N 250 17220 250 17270 {
lab=GND}
N 250 17270 250 17280 {
lab=GND}
N 310 17220 310 17270 {
lab=Y3}
N 310 17270 310 17280 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 17250 1 0 {name=M1255
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 17280 360 17280 {
lab=GND}
N 360 17270 360 17280 {
lab=GND}
N 320 17230 360 17230 {
lab=word287}
N 360 17230 400 17230 {
lab=word287}
N 330 17220 330 17270 {
lab=GND}
N 330 17270 330 17280 {
lab=GND}
N 390 17220 390 17270 {
lab=Y4}
N 390 17270 390 17280 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 17250 1 0 {name=M1256
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 17280 440 17280 {
lab=GND}
N 440 17270 440 17280 {
lab=GND}
N 400 17230 440 17230 {
lab=word287}
N 440 17230 480 17230 {
lab=word287}
N 410 17220 410 17270 {
lab=GND}
N 410 17270 410 17280 {
lab=GND}
N 470 17220 470 17270 {
lab=Y5}
N 470 17270 470 17280 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 17250 1 0 {name=M1257
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 17230 520 17230 {
lab=word287}
N 520 17230 560 17230 {
lab=word287}
N 490 17220 490 17270 {
lab=GND}
N 490 17270 490 17280 {
lab=GND}
N 550 17220 550 17270 {
lab=Y6}
N 550 17270 550 17280 {
lab=Y6}

N 570 17280 600 17280 {
lab=GND}
N 600 17270 600 17280 {
lab=GND}
N 560 17230 600 17230 {
lab=word287}
N 600 17230 640 17230 {
lab=word287}
N 570 17220 570 17270 {
lab=GND}
N 570 17270 570 17280 {
lab=GND}
N 630 17220 630 17270 {
lab=Y7}
N 630 17270 630 17280 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17250 1 0 {name=M1258
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17290 0 0 {name=p311 lab=word288}
N 0 17290 40 17290 {
lab=word288}
N 40 17290 80 17290 {
lab=word288}
N 10 17280 10 17330 {
lab=GND}
N 10 17330 10 17340 {
lab=GND}
N 70 17280 70 17330 {
lab=Y0}
N 70 17330 70 17340 {
lab=Y0}
N 80 17290 120 17290 {
lab=word288}
N 120 17290 160 17290 {
lab=word288}
N 90 17280 90 17330 {
lab=GND}
N 90 17330 90 17340 {
lab=GND}
N 150 17280 150 17330 {
lab=Y1}
N 150 17330 150 17340 {
lab=Y1}

N 170 17340 200 17340 {
lab=GND}
N 200 17330 200 17340 {
lab=GND}
N 160 17290 200 17290 {
lab=word288}
N 200 17290 240 17290 {
lab=word288}
N 170 17280 170 17330 {
lab=GND}
N 170 17330 170 17340 {
lab=GND}
N 230 17280 230 17330 {
lab=Y2}
N 230 17330 230 17340 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 17310 1 0 {name=M1259
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 17340 280 17340 {
lab=GND}
N 280 17330 280 17340 {
lab=GND}
N 240 17290 280 17290 {
lab=word288}
N 280 17290 320 17290 {
lab=word288}
N 250 17280 250 17330 {
lab=GND}
N 250 17330 250 17340 {
lab=GND}
N 310 17280 310 17330 {
lab=Y3}
N 310 17330 310 17340 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 17310 1 0 {name=M1260
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 17340 360 17340 {
lab=GND}
N 360 17330 360 17340 {
lab=GND}
N 320 17290 360 17290 {
lab=word288}
N 360 17290 400 17290 {
lab=word288}
N 330 17280 330 17330 {
lab=GND}
N 330 17330 330 17340 {
lab=GND}
N 390 17280 390 17330 {
lab=Y4}
N 390 17330 390 17340 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 17310 1 0 {name=M1261
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 17340 440 17340 {
lab=GND}
N 440 17330 440 17340 {
lab=GND}
N 400 17290 440 17290 {
lab=word288}
N 440 17290 480 17290 {
lab=word288}
N 410 17280 410 17330 {
lab=GND}
N 410 17330 410 17340 {
lab=GND}
N 470 17280 470 17330 {
lab=Y5}
N 470 17330 470 17340 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 17310 1 0 {name=M1262
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 17340 520 17340 {
lab=GND}
N 520 17330 520 17340 {
lab=GND}
N 480 17290 520 17290 {
lab=word288}
N 520 17290 560 17290 {
lab=word288}
N 490 17280 490 17330 {
lab=GND}
N 490 17330 490 17340 {
lab=GND}
N 550 17280 550 17330 {
lab=Y6}
N 550 17330 550 17340 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 17310 1 0 {name=M1263
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 17340 600 17340 {
lab=GND}
N 600 17330 600 17340 {
lab=GND}
N 560 17290 600 17290 {
lab=word288}
N 600 17290 640 17290 {
lab=word288}
N 570 17280 570 17330 {
lab=GND}
N 570 17330 570 17340 {
lab=GND}
N 630 17280 630 17330 {
lab=Y7}
N 630 17330 630 17340 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17310 1 0 {name=M1264
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17350 0 0 {name=p312 lab=word289}
N 0 17350 40 17350 {
lab=word289}
N 40 17350 80 17350 {
lab=word289}
N 10 17340 10 17390 {
lab=GND}
N 10 17390 10 17400 {
lab=GND}
N 70 17340 70 17390 {
lab=Y0}
N 70 17390 70 17400 {
lab=Y0}

N 90 17400 120 17400 {
lab=GND}
N 120 17390 120 17400 {
lab=GND}
N 80 17350 120 17350 {
lab=word289}
N 120 17350 160 17350 {
lab=word289}
N 90 17340 90 17390 {
lab=GND}
N 90 17390 90 17400 {
lab=GND}
N 150 17340 150 17390 {
lab=Y1}
N 150 17390 150 17400 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 17370 1 0 {name=M1265
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 17350 200 17350 {
lab=word289}
N 200 17350 240 17350 {
lab=word289}
N 170 17340 170 17390 {
lab=GND}
N 170 17390 170 17400 {
lab=GND}
N 230 17340 230 17390 {
lab=Y2}
N 230 17390 230 17400 {
lab=Y2}
N 240 17350 280 17350 {
lab=word289}
N 280 17350 320 17350 {
lab=word289}
N 250 17340 250 17390 {
lab=GND}
N 250 17390 250 17400 {
lab=GND}
N 310 17340 310 17390 {
lab=Y3}
N 310 17390 310 17400 {
lab=Y3}
N 320 17350 360 17350 {
lab=word289}
N 360 17350 400 17350 {
lab=word289}
N 330 17340 330 17390 {
lab=GND}
N 330 17390 330 17400 {
lab=GND}
N 390 17340 390 17390 {
lab=Y4}
N 390 17390 390 17400 {
lab=Y4}
N 400 17350 440 17350 {
lab=word289}
N 440 17350 480 17350 {
lab=word289}
N 410 17340 410 17390 {
lab=GND}
N 410 17390 410 17400 {
lab=GND}
N 470 17340 470 17390 {
lab=Y5}
N 470 17390 470 17400 {
lab=Y5}
N 480 17350 520 17350 {
lab=word289}
N 520 17350 560 17350 {
lab=word289}
N 490 17340 490 17390 {
lab=GND}
N 490 17390 490 17400 {
lab=GND}
N 550 17340 550 17390 {
lab=Y6}
N 550 17390 550 17400 {
lab=Y6}

N 570 17400 600 17400 {
lab=GND}
N 600 17390 600 17400 {
lab=GND}
N 560 17350 600 17350 {
lab=word289}
N 600 17350 640 17350 {
lab=word289}
N 570 17340 570 17390 {
lab=GND}
N 570 17390 570 17400 {
lab=GND}
N 630 17340 630 17390 {
lab=Y7}
N 630 17390 630 17400 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17370 1 0 {name=M1266
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17410 0 0 {name=p313 lab=word290}
N 0 17410 40 17410 {
lab=word290}
N 40 17410 80 17410 {
lab=word290}
N 10 17400 10 17450 {
lab=GND}
N 10 17450 10 17460 {
lab=GND}
N 70 17400 70 17450 {
lab=Y0}
N 70 17450 70 17460 {
lab=Y0}

N 90 17460 120 17460 {
lab=GND}
N 120 17450 120 17460 {
lab=GND}
N 80 17410 120 17410 {
lab=word290}
N 120 17410 160 17410 {
lab=word290}
N 90 17400 90 17450 {
lab=GND}
N 90 17450 90 17460 {
lab=GND}
N 150 17400 150 17450 {
lab=Y1}
N 150 17450 150 17460 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 17430 1 0 {name=M1267
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 17410 200 17410 {
lab=word290}
N 200 17410 240 17410 {
lab=word290}
N 170 17400 170 17450 {
lab=GND}
N 170 17450 170 17460 {
lab=GND}
N 230 17400 230 17450 {
lab=Y2}
N 230 17450 230 17460 {
lab=Y2}
N 240 17410 280 17410 {
lab=word290}
N 280 17410 320 17410 {
lab=word290}
N 250 17400 250 17450 {
lab=GND}
N 250 17450 250 17460 {
lab=GND}
N 310 17400 310 17450 {
lab=Y3}
N 310 17450 310 17460 {
lab=Y3}
N 320 17410 360 17410 {
lab=word290}
N 360 17410 400 17410 {
lab=word290}
N 330 17400 330 17450 {
lab=GND}
N 330 17450 330 17460 {
lab=GND}
N 390 17400 390 17450 {
lab=Y4}
N 390 17450 390 17460 {
lab=Y4}
N 400 17410 440 17410 {
lab=word290}
N 440 17410 480 17410 {
lab=word290}
N 410 17400 410 17450 {
lab=GND}
N 410 17450 410 17460 {
lab=GND}
N 470 17400 470 17450 {
lab=Y5}
N 470 17450 470 17460 {
lab=Y5}

N 490 17460 520 17460 {
lab=GND}
N 520 17450 520 17460 {
lab=GND}
N 480 17410 520 17410 {
lab=word290}
N 520 17410 560 17410 {
lab=word290}
N 490 17400 490 17450 {
lab=GND}
N 490 17450 490 17460 {
lab=GND}
N 550 17400 550 17450 {
lab=Y6}
N 550 17450 550 17460 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 17430 1 0 {name=M1268
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 17460 600 17460 {
lab=GND}
N 600 17450 600 17460 {
lab=GND}
N 560 17410 600 17410 {
lab=word290}
N 600 17410 640 17410 {
lab=word290}
N 570 17400 570 17450 {
lab=GND}
N 570 17450 570 17460 {
lab=GND}
N 630 17400 630 17450 {
lab=Y7}
N 630 17450 630 17460 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17430 1 0 {name=M1269
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17470 0 0 {name=p314 lab=word291}
N 0 17470 40 17470 {
lab=word291}
N 40 17470 80 17470 {
lab=word291}
N 10 17460 10 17510 {
lab=GND}
N 10 17510 10 17520 {
lab=GND}
N 70 17460 70 17510 {
lab=Y0}
N 70 17510 70 17520 {
lab=Y0}

N 90 17520 120 17520 {
lab=GND}
N 120 17510 120 17520 {
lab=GND}
N 80 17470 120 17470 {
lab=word291}
N 120 17470 160 17470 {
lab=word291}
N 90 17460 90 17510 {
lab=GND}
N 90 17510 90 17520 {
lab=GND}
N 150 17460 150 17510 {
lab=Y1}
N 150 17510 150 17520 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 17490 1 0 {name=M1270
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 17470 200 17470 {
lab=word291}
N 200 17470 240 17470 {
lab=word291}
N 170 17460 170 17510 {
lab=GND}
N 170 17510 170 17520 {
lab=GND}
N 230 17460 230 17510 {
lab=Y2}
N 230 17510 230 17520 {
lab=Y2}
N 240 17470 280 17470 {
lab=word291}
N 280 17470 320 17470 {
lab=word291}
N 250 17460 250 17510 {
lab=GND}
N 250 17510 250 17520 {
lab=GND}
N 310 17460 310 17510 {
lab=Y3}
N 310 17510 310 17520 {
lab=Y3}
N 320 17470 360 17470 {
lab=word291}
N 360 17470 400 17470 {
lab=word291}
N 330 17460 330 17510 {
lab=GND}
N 330 17510 330 17520 {
lab=GND}
N 390 17460 390 17510 {
lab=Y4}
N 390 17510 390 17520 {
lab=Y4}

N 410 17520 440 17520 {
lab=GND}
N 440 17510 440 17520 {
lab=GND}
N 400 17470 440 17470 {
lab=word291}
N 440 17470 480 17470 {
lab=word291}
N 410 17460 410 17510 {
lab=GND}
N 410 17510 410 17520 {
lab=GND}
N 470 17460 470 17510 {
lab=Y5}
N 470 17510 470 17520 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 17490 1 0 {name=M1271
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 17470 520 17470 {
lab=word291}
N 520 17470 560 17470 {
lab=word291}
N 490 17460 490 17510 {
lab=GND}
N 490 17510 490 17520 {
lab=GND}
N 550 17460 550 17510 {
lab=Y6}
N 550 17510 550 17520 {
lab=Y6}

N 570 17520 600 17520 {
lab=GND}
N 600 17510 600 17520 {
lab=GND}
N 560 17470 600 17470 {
lab=word291}
N 600 17470 640 17470 {
lab=word291}
N 570 17460 570 17510 {
lab=GND}
N 570 17510 570 17520 {
lab=GND}
N 630 17460 630 17510 {
lab=Y7}
N 630 17510 630 17520 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17490 1 0 {name=M1272
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17530 0 0 {name=p315 lab=word292}
N 0 17530 40 17530 {
lab=word292}
N 40 17530 80 17530 {
lab=word292}
N 10 17520 10 17570 {
lab=GND}
N 10 17570 10 17580 {
lab=GND}
N 70 17520 70 17570 {
lab=Y0}
N 70 17570 70 17580 {
lab=Y0}

N 90 17580 120 17580 {
lab=GND}
N 120 17570 120 17580 {
lab=GND}
N 80 17530 120 17530 {
lab=word292}
N 120 17530 160 17530 {
lab=word292}
N 90 17520 90 17570 {
lab=GND}
N 90 17570 90 17580 {
lab=GND}
N 150 17520 150 17570 {
lab=Y1}
N 150 17570 150 17580 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 17550 1 0 {name=M1273
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 17530 200 17530 {
lab=word292}
N 200 17530 240 17530 {
lab=word292}
N 170 17520 170 17570 {
lab=GND}
N 170 17570 170 17580 {
lab=GND}
N 230 17520 230 17570 {
lab=Y2}
N 230 17570 230 17580 {
lab=Y2}
N 240 17530 280 17530 {
lab=word292}
N 280 17530 320 17530 {
lab=word292}
N 250 17520 250 17570 {
lab=GND}
N 250 17570 250 17580 {
lab=GND}
N 310 17520 310 17570 {
lab=Y3}
N 310 17570 310 17580 {
lab=Y3}
N 320 17530 360 17530 {
lab=word292}
N 360 17530 400 17530 {
lab=word292}
N 330 17520 330 17570 {
lab=GND}
N 330 17570 330 17580 {
lab=GND}
N 390 17520 390 17570 {
lab=Y4}
N 390 17570 390 17580 {
lab=Y4}

N 410 17580 440 17580 {
lab=GND}
N 440 17570 440 17580 {
lab=GND}
N 400 17530 440 17530 {
lab=word292}
N 440 17530 480 17530 {
lab=word292}
N 410 17520 410 17570 {
lab=GND}
N 410 17570 410 17580 {
lab=GND}
N 470 17520 470 17570 {
lab=Y5}
N 470 17570 470 17580 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 17550 1 0 {name=M1274
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 17580 520 17580 {
lab=GND}
N 520 17570 520 17580 {
lab=GND}
N 480 17530 520 17530 {
lab=word292}
N 520 17530 560 17530 {
lab=word292}
N 490 17520 490 17570 {
lab=GND}
N 490 17570 490 17580 {
lab=GND}
N 550 17520 550 17570 {
lab=Y6}
N 550 17570 550 17580 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 17550 1 0 {name=M1275
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 17580 600 17580 {
lab=GND}
N 600 17570 600 17580 {
lab=GND}
N 560 17530 600 17530 {
lab=word292}
N 600 17530 640 17530 {
lab=word292}
N 570 17520 570 17570 {
lab=GND}
N 570 17570 570 17580 {
lab=GND}
N 630 17520 630 17570 {
lab=Y7}
N 630 17570 630 17580 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17550 1 0 {name=M1276
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17590 0 0 {name=p316 lab=word293}
N 0 17590 40 17590 {
lab=word293}
N 40 17590 80 17590 {
lab=word293}
N 10 17580 10 17630 {
lab=GND}
N 10 17630 10 17640 {
lab=GND}
N 70 17580 70 17630 {
lab=Y0}
N 70 17630 70 17640 {
lab=Y0}

N 90 17640 120 17640 {
lab=GND}
N 120 17630 120 17640 {
lab=GND}
N 80 17590 120 17590 {
lab=word293}
N 120 17590 160 17590 {
lab=word293}
N 90 17580 90 17630 {
lab=GND}
N 90 17630 90 17640 {
lab=GND}
N 150 17580 150 17630 {
lab=Y1}
N 150 17630 150 17640 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 17610 1 0 {name=M1277
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 17590 200 17590 {
lab=word293}
N 200 17590 240 17590 {
lab=word293}
N 170 17580 170 17630 {
lab=GND}
N 170 17630 170 17640 {
lab=GND}
N 230 17580 230 17630 {
lab=Y2}
N 230 17630 230 17640 {
lab=Y2}
N 240 17590 280 17590 {
lab=word293}
N 280 17590 320 17590 {
lab=word293}
N 250 17580 250 17630 {
lab=GND}
N 250 17630 250 17640 {
lab=GND}
N 310 17580 310 17630 {
lab=Y3}
N 310 17630 310 17640 {
lab=Y3}

N 330 17640 360 17640 {
lab=GND}
N 360 17630 360 17640 {
lab=GND}
N 320 17590 360 17590 {
lab=word293}
N 360 17590 400 17590 {
lab=word293}
N 330 17580 330 17630 {
lab=GND}
N 330 17630 330 17640 {
lab=GND}
N 390 17580 390 17630 {
lab=Y4}
N 390 17630 390 17640 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 17610 1 0 {name=M1278
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 17590 440 17590 {
lab=word293}
N 440 17590 480 17590 {
lab=word293}
N 410 17580 410 17630 {
lab=GND}
N 410 17630 410 17640 {
lab=GND}
N 470 17580 470 17630 {
lab=Y5}
N 470 17630 470 17640 {
lab=Y5}
N 480 17590 520 17590 {
lab=word293}
N 520 17590 560 17590 {
lab=word293}
N 490 17580 490 17630 {
lab=GND}
N 490 17630 490 17640 {
lab=GND}
N 550 17580 550 17630 {
lab=Y6}
N 550 17630 550 17640 {
lab=Y6}

N 570 17640 600 17640 {
lab=GND}
N 600 17630 600 17640 {
lab=GND}
N 560 17590 600 17590 {
lab=word293}
N 600 17590 640 17590 {
lab=word293}
N 570 17580 570 17630 {
lab=GND}
N 570 17630 570 17640 {
lab=GND}
N 630 17580 630 17630 {
lab=Y7}
N 630 17630 630 17640 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17610 1 0 {name=M1279
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17650 0 0 {name=p317 lab=word294}
N 0 17650 40 17650 {
lab=word294}
N 40 17650 80 17650 {
lab=word294}
N 10 17640 10 17690 {
lab=GND}
N 10 17690 10 17700 {
lab=GND}
N 70 17640 70 17690 {
lab=Y0}
N 70 17690 70 17700 {
lab=Y0}

N 90 17700 120 17700 {
lab=GND}
N 120 17690 120 17700 {
lab=GND}
N 80 17650 120 17650 {
lab=word294}
N 120 17650 160 17650 {
lab=word294}
N 90 17640 90 17690 {
lab=GND}
N 90 17690 90 17700 {
lab=GND}
N 150 17640 150 17690 {
lab=Y1}
N 150 17690 150 17700 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 17670 1 0 {name=M1280
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 17650 200 17650 {
lab=word294}
N 200 17650 240 17650 {
lab=word294}
N 170 17640 170 17690 {
lab=GND}
N 170 17690 170 17700 {
lab=GND}
N 230 17640 230 17690 {
lab=Y2}
N 230 17690 230 17700 {
lab=Y2}
N 240 17650 280 17650 {
lab=word294}
N 280 17650 320 17650 {
lab=word294}
N 250 17640 250 17690 {
lab=GND}
N 250 17690 250 17700 {
lab=GND}
N 310 17640 310 17690 {
lab=Y3}
N 310 17690 310 17700 {
lab=Y3}

N 330 17700 360 17700 {
lab=GND}
N 360 17690 360 17700 {
lab=GND}
N 320 17650 360 17650 {
lab=word294}
N 360 17650 400 17650 {
lab=word294}
N 330 17640 330 17690 {
lab=GND}
N 330 17690 330 17700 {
lab=GND}
N 390 17640 390 17690 {
lab=Y4}
N 390 17690 390 17700 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 17670 1 0 {name=M1281
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 17650 440 17650 {
lab=word294}
N 440 17650 480 17650 {
lab=word294}
N 410 17640 410 17690 {
lab=GND}
N 410 17690 410 17700 {
lab=GND}
N 470 17640 470 17690 {
lab=Y5}
N 470 17690 470 17700 {
lab=Y5}

N 490 17700 520 17700 {
lab=GND}
N 520 17690 520 17700 {
lab=GND}
N 480 17650 520 17650 {
lab=word294}
N 520 17650 560 17650 {
lab=word294}
N 490 17640 490 17690 {
lab=GND}
N 490 17690 490 17700 {
lab=GND}
N 550 17640 550 17690 {
lab=Y6}
N 550 17690 550 17700 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 17670 1 0 {name=M1282
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 17700 600 17700 {
lab=GND}
N 600 17690 600 17700 {
lab=GND}
N 560 17650 600 17650 {
lab=word294}
N 600 17650 640 17650 {
lab=word294}
N 570 17640 570 17690 {
lab=GND}
N 570 17690 570 17700 {
lab=GND}
N 630 17640 630 17690 {
lab=Y7}
N 630 17690 630 17700 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17670 1 0 {name=M1283
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17710 0 0 {name=p318 lab=word295}
N 0 17710 40 17710 {
lab=word295}
N 40 17710 80 17710 {
lab=word295}
N 10 17700 10 17750 {
lab=GND}
N 10 17750 10 17760 {
lab=GND}
N 70 17700 70 17750 {
lab=Y0}
N 70 17750 70 17760 {
lab=Y0}

N 90 17760 120 17760 {
lab=GND}
N 120 17750 120 17760 {
lab=GND}
N 80 17710 120 17710 {
lab=word295}
N 120 17710 160 17710 {
lab=word295}
N 90 17700 90 17750 {
lab=GND}
N 90 17750 90 17760 {
lab=GND}
N 150 17700 150 17750 {
lab=Y1}
N 150 17750 150 17760 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 17730 1 0 {name=M1284
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 17710 200 17710 {
lab=word295}
N 200 17710 240 17710 {
lab=word295}
N 170 17700 170 17750 {
lab=GND}
N 170 17750 170 17760 {
lab=GND}
N 230 17700 230 17750 {
lab=Y2}
N 230 17750 230 17760 {
lab=Y2}
N 240 17710 280 17710 {
lab=word295}
N 280 17710 320 17710 {
lab=word295}
N 250 17700 250 17750 {
lab=GND}
N 250 17750 250 17760 {
lab=GND}
N 310 17700 310 17750 {
lab=Y3}
N 310 17750 310 17760 {
lab=Y3}

N 330 17760 360 17760 {
lab=GND}
N 360 17750 360 17760 {
lab=GND}
N 320 17710 360 17710 {
lab=word295}
N 360 17710 400 17710 {
lab=word295}
N 330 17700 330 17750 {
lab=GND}
N 330 17750 330 17760 {
lab=GND}
N 390 17700 390 17750 {
lab=Y4}
N 390 17750 390 17760 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 17730 1 0 {name=M1285
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 17760 440 17760 {
lab=GND}
N 440 17750 440 17760 {
lab=GND}
N 400 17710 440 17710 {
lab=word295}
N 440 17710 480 17710 {
lab=word295}
N 410 17700 410 17750 {
lab=GND}
N 410 17750 410 17760 {
lab=GND}
N 470 17700 470 17750 {
lab=Y5}
N 470 17750 470 17760 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 17730 1 0 {name=M1286
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 17710 520 17710 {
lab=word295}
N 520 17710 560 17710 {
lab=word295}
N 490 17700 490 17750 {
lab=GND}
N 490 17750 490 17760 {
lab=GND}
N 550 17700 550 17750 {
lab=Y6}
N 550 17750 550 17760 {
lab=Y6}

N 570 17760 600 17760 {
lab=GND}
N 600 17750 600 17760 {
lab=GND}
N 560 17710 600 17710 {
lab=word295}
N 600 17710 640 17710 {
lab=word295}
N 570 17700 570 17750 {
lab=GND}
N 570 17750 570 17760 {
lab=GND}
N 630 17700 630 17750 {
lab=Y7}
N 630 17750 630 17760 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17730 1 0 {name=M1287
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17770 0 0 {name=p319 lab=word296}
N 0 17770 40 17770 {
lab=word296}
N 40 17770 80 17770 {
lab=word296}
N 10 17760 10 17810 {
lab=GND}
N 10 17810 10 17820 {
lab=GND}
N 70 17760 70 17810 {
lab=Y0}
N 70 17810 70 17820 {
lab=Y0}

N 90 17820 120 17820 {
lab=GND}
N 120 17810 120 17820 {
lab=GND}
N 80 17770 120 17770 {
lab=word296}
N 120 17770 160 17770 {
lab=word296}
N 90 17760 90 17810 {
lab=GND}
N 90 17810 90 17820 {
lab=GND}
N 150 17760 150 17810 {
lab=Y1}
N 150 17810 150 17820 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 17790 1 0 {name=M1288
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 17770 200 17770 {
lab=word296}
N 200 17770 240 17770 {
lab=word296}
N 170 17760 170 17810 {
lab=GND}
N 170 17810 170 17820 {
lab=GND}
N 230 17760 230 17810 {
lab=Y2}
N 230 17810 230 17820 {
lab=Y2}
N 240 17770 280 17770 {
lab=word296}
N 280 17770 320 17770 {
lab=word296}
N 250 17760 250 17810 {
lab=GND}
N 250 17810 250 17820 {
lab=GND}
N 310 17760 310 17810 {
lab=Y3}
N 310 17810 310 17820 {
lab=Y3}

N 330 17820 360 17820 {
lab=GND}
N 360 17810 360 17820 {
lab=GND}
N 320 17770 360 17770 {
lab=word296}
N 360 17770 400 17770 {
lab=word296}
N 330 17760 330 17810 {
lab=GND}
N 330 17810 330 17820 {
lab=GND}
N 390 17760 390 17810 {
lab=Y4}
N 390 17810 390 17820 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 17790 1 0 {name=M1289
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 17820 440 17820 {
lab=GND}
N 440 17810 440 17820 {
lab=GND}
N 400 17770 440 17770 {
lab=word296}
N 440 17770 480 17770 {
lab=word296}
N 410 17760 410 17810 {
lab=GND}
N 410 17810 410 17820 {
lab=GND}
N 470 17760 470 17810 {
lab=Y5}
N 470 17810 470 17820 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 17790 1 0 {name=M1290
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 17820 520 17820 {
lab=GND}
N 520 17810 520 17820 {
lab=GND}
N 480 17770 520 17770 {
lab=word296}
N 520 17770 560 17770 {
lab=word296}
N 490 17760 490 17810 {
lab=GND}
N 490 17810 490 17820 {
lab=GND}
N 550 17760 550 17810 {
lab=Y6}
N 550 17810 550 17820 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 17790 1 0 {name=M1291
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 17820 600 17820 {
lab=GND}
N 600 17810 600 17820 {
lab=GND}
N 560 17770 600 17770 {
lab=word296}
N 600 17770 640 17770 {
lab=word296}
N 570 17760 570 17810 {
lab=GND}
N 570 17810 570 17820 {
lab=GND}
N 630 17760 630 17810 {
lab=Y7}
N 630 17810 630 17820 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17790 1 0 {name=M1292
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17830 0 0 {name=p320 lab=word297}
N 0 17830 40 17830 {
lab=word297}
N 40 17830 80 17830 {
lab=word297}
N 10 17820 10 17870 {
lab=GND}
N 10 17870 10 17880 {
lab=GND}
N 70 17820 70 17870 {
lab=Y0}
N 70 17870 70 17880 {
lab=Y0}

N 90 17880 120 17880 {
lab=GND}
N 120 17870 120 17880 {
lab=GND}
N 80 17830 120 17830 {
lab=word297}
N 120 17830 160 17830 {
lab=word297}
N 90 17820 90 17870 {
lab=GND}
N 90 17870 90 17880 {
lab=GND}
N 150 17820 150 17870 {
lab=Y1}
N 150 17870 150 17880 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 17850 1 0 {name=M1293
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 17830 200 17830 {
lab=word297}
N 200 17830 240 17830 {
lab=word297}
N 170 17820 170 17870 {
lab=GND}
N 170 17870 170 17880 {
lab=GND}
N 230 17820 230 17870 {
lab=Y2}
N 230 17870 230 17880 {
lab=Y2}

N 250 17880 280 17880 {
lab=GND}
N 280 17870 280 17880 {
lab=GND}
N 240 17830 280 17830 {
lab=word297}
N 280 17830 320 17830 {
lab=word297}
N 250 17820 250 17870 {
lab=GND}
N 250 17870 250 17880 {
lab=GND}
N 310 17820 310 17870 {
lab=Y3}
N 310 17870 310 17880 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 17850 1 0 {name=M1294
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 17830 360 17830 {
lab=word297}
N 360 17830 400 17830 {
lab=word297}
N 330 17820 330 17870 {
lab=GND}
N 330 17870 330 17880 {
lab=GND}
N 390 17820 390 17870 {
lab=Y4}
N 390 17870 390 17880 {
lab=Y4}
N 400 17830 440 17830 {
lab=word297}
N 440 17830 480 17830 {
lab=word297}
N 410 17820 410 17870 {
lab=GND}
N 410 17870 410 17880 {
lab=GND}
N 470 17820 470 17870 {
lab=Y5}
N 470 17870 470 17880 {
lab=Y5}
N 480 17830 520 17830 {
lab=word297}
N 520 17830 560 17830 {
lab=word297}
N 490 17820 490 17870 {
lab=GND}
N 490 17870 490 17880 {
lab=GND}
N 550 17820 550 17870 {
lab=Y6}
N 550 17870 550 17880 {
lab=Y6}

N 570 17880 600 17880 {
lab=GND}
N 600 17870 600 17880 {
lab=GND}
N 560 17830 600 17830 {
lab=word297}
N 600 17830 640 17830 {
lab=word297}
N 570 17820 570 17870 {
lab=GND}
N 570 17870 570 17880 {
lab=GND}
N 630 17820 630 17870 {
lab=Y7}
N 630 17870 630 17880 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17850 1 0 {name=M1295
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17890 0 0 {name=p321 lab=word298}
N 0 17890 40 17890 {
lab=word298}
N 40 17890 80 17890 {
lab=word298}
N 10 17880 10 17930 {
lab=GND}
N 10 17930 10 17940 {
lab=GND}
N 70 17880 70 17930 {
lab=Y0}
N 70 17930 70 17940 {
lab=Y0}

N 90 17940 120 17940 {
lab=GND}
N 120 17930 120 17940 {
lab=GND}
N 80 17890 120 17890 {
lab=word298}
N 120 17890 160 17890 {
lab=word298}
N 90 17880 90 17930 {
lab=GND}
N 90 17930 90 17940 {
lab=GND}
N 150 17880 150 17930 {
lab=Y1}
N 150 17930 150 17940 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 17910 1 0 {name=M1296
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 17890 200 17890 {
lab=word298}
N 200 17890 240 17890 {
lab=word298}
N 170 17880 170 17930 {
lab=GND}
N 170 17930 170 17940 {
lab=GND}
N 230 17880 230 17930 {
lab=Y2}
N 230 17930 230 17940 {
lab=Y2}

N 250 17940 280 17940 {
lab=GND}
N 280 17930 280 17940 {
lab=GND}
N 240 17890 280 17890 {
lab=word298}
N 280 17890 320 17890 {
lab=word298}
N 250 17880 250 17930 {
lab=GND}
N 250 17930 250 17940 {
lab=GND}
N 310 17880 310 17930 {
lab=Y3}
N 310 17930 310 17940 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 17910 1 0 {name=M1297
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 17890 360 17890 {
lab=word298}
N 360 17890 400 17890 {
lab=word298}
N 330 17880 330 17930 {
lab=GND}
N 330 17930 330 17940 {
lab=GND}
N 390 17880 390 17930 {
lab=Y4}
N 390 17930 390 17940 {
lab=Y4}
N 400 17890 440 17890 {
lab=word298}
N 440 17890 480 17890 {
lab=word298}
N 410 17880 410 17930 {
lab=GND}
N 410 17930 410 17940 {
lab=GND}
N 470 17880 470 17930 {
lab=Y5}
N 470 17930 470 17940 {
lab=Y5}

N 490 17940 520 17940 {
lab=GND}
N 520 17930 520 17940 {
lab=GND}
N 480 17890 520 17890 {
lab=word298}
N 520 17890 560 17890 {
lab=word298}
N 490 17880 490 17930 {
lab=GND}
N 490 17930 490 17940 {
lab=GND}
N 550 17880 550 17930 {
lab=Y6}
N 550 17930 550 17940 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 17910 1 0 {name=M1298
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 17940 600 17940 {
lab=GND}
N 600 17930 600 17940 {
lab=GND}
N 560 17890 600 17890 {
lab=word298}
N 600 17890 640 17890 {
lab=word298}
N 570 17880 570 17930 {
lab=GND}
N 570 17930 570 17940 {
lab=GND}
N 630 17880 630 17930 {
lab=Y7}
N 630 17930 630 17940 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17910 1 0 {name=M1299
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 17950 0 0 {name=p322 lab=word299}
N 0 17950 40 17950 {
lab=word299}
N 40 17950 80 17950 {
lab=word299}
N 10 17940 10 17990 {
lab=GND}
N 10 17990 10 18000 {
lab=GND}
N 70 17940 70 17990 {
lab=Y0}
N 70 17990 70 18000 {
lab=Y0}

N 90 18000 120 18000 {
lab=GND}
N 120 17990 120 18000 {
lab=GND}
N 80 17950 120 17950 {
lab=word299}
N 120 17950 160 17950 {
lab=word299}
N 90 17940 90 17990 {
lab=GND}
N 90 17990 90 18000 {
lab=GND}
N 150 17940 150 17990 {
lab=Y1}
N 150 17990 150 18000 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 17970 1 0 {name=M1300
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 17950 200 17950 {
lab=word299}
N 200 17950 240 17950 {
lab=word299}
N 170 17940 170 17990 {
lab=GND}
N 170 17990 170 18000 {
lab=GND}
N 230 17940 230 17990 {
lab=Y2}
N 230 17990 230 18000 {
lab=Y2}

N 250 18000 280 18000 {
lab=GND}
N 280 17990 280 18000 {
lab=GND}
N 240 17950 280 17950 {
lab=word299}
N 280 17950 320 17950 {
lab=word299}
N 250 17940 250 17990 {
lab=GND}
N 250 17990 250 18000 {
lab=GND}
N 310 17940 310 17990 {
lab=Y3}
N 310 17990 310 18000 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 17970 1 0 {name=M1301
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 17950 360 17950 {
lab=word299}
N 360 17950 400 17950 {
lab=word299}
N 330 17940 330 17990 {
lab=GND}
N 330 17990 330 18000 {
lab=GND}
N 390 17940 390 17990 {
lab=Y4}
N 390 17990 390 18000 {
lab=Y4}

N 410 18000 440 18000 {
lab=GND}
N 440 17990 440 18000 {
lab=GND}
N 400 17950 440 17950 {
lab=word299}
N 440 17950 480 17950 {
lab=word299}
N 410 17940 410 17990 {
lab=GND}
N 410 17990 410 18000 {
lab=GND}
N 470 17940 470 17990 {
lab=Y5}
N 470 17990 470 18000 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 17970 1 0 {name=M1302
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 17950 520 17950 {
lab=word299}
N 520 17950 560 17950 {
lab=word299}
N 490 17940 490 17990 {
lab=GND}
N 490 17990 490 18000 {
lab=GND}
N 550 17940 550 17990 {
lab=Y6}
N 550 17990 550 18000 {
lab=Y6}

N 570 18000 600 18000 {
lab=GND}
N 600 17990 600 18000 {
lab=GND}
N 560 17950 600 17950 {
lab=word299}
N 600 17950 640 17950 {
lab=word299}
N 570 17940 570 17990 {
lab=GND}
N 570 17990 570 18000 {
lab=GND}
N 630 17940 630 17990 {
lab=Y7}
N 630 17990 630 18000 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 17970 1 0 {name=M1303
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18010 0 0 {name=p323 lab=word300}
N 0 18010 40 18010 {
lab=word300}
N 40 18010 80 18010 {
lab=word300}
N 10 18000 10 18050 {
lab=GND}
N 10 18050 10 18060 {
lab=GND}
N 70 18000 70 18050 {
lab=Y0}
N 70 18050 70 18060 {
lab=Y0}

N 90 18060 120 18060 {
lab=GND}
N 120 18050 120 18060 {
lab=GND}
N 80 18010 120 18010 {
lab=word300}
N 120 18010 160 18010 {
lab=word300}
N 90 18000 90 18050 {
lab=GND}
N 90 18050 90 18060 {
lab=GND}
N 150 18000 150 18050 {
lab=Y1}
N 150 18050 150 18060 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18030 1 0 {name=M1304
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 18010 200 18010 {
lab=word300}
N 200 18010 240 18010 {
lab=word300}
N 170 18000 170 18050 {
lab=GND}
N 170 18050 170 18060 {
lab=GND}
N 230 18000 230 18050 {
lab=Y2}
N 230 18050 230 18060 {
lab=Y2}

N 250 18060 280 18060 {
lab=GND}
N 280 18050 280 18060 {
lab=GND}
N 240 18010 280 18010 {
lab=word300}
N 280 18010 320 18010 {
lab=word300}
N 250 18000 250 18050 {
lab=GND}
N 250 18050 250 18060 {
lab=GND}
N 310 18000 310 18050 {
lab=Y3}
N 310 18050 310 18060 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 18030 1 0 {name=M1305
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 18010 360 18010 {
lab=word300}
N 360 18010 400 18010 {
lab=word300}
N 330 18000 330 18050 {
lab=GND}
N 330 18050 330 18060 {
lab=GND}
N 390 18000 390 18050 {
lab=Y4}
N 390 18050 390 18060 {
lab=Y4}

N 410 18060 440 18060 {
lab=GND}
N 440 18050 440 18060 {
lab=GND}
N 400 18010 440 18010 {
lab=word300}
N 440 18010 480 18010 {
lab=word300}
N 410 18000 410 18050 {
lab=GND}
N 410 18050 410 18060 {
lab=GND}
N 470 18000 470 18050 {
lab=Y5}
N 470 18050 470 18060 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 18030 1 0 {name=M1306
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 18060 520 18060 {
lab=GND}
N 520 18050 520 18060 {
lab=GND}
N 480 18010 520 18010 {
lab=word300}
N 520 18010 560 18010 {
lab=word300}
N 490 18000 490 18050 {
lab=GND}
N 490 18050 490 18060 {
lab=GND}
N 550 18000 550 18050 {
lab=Y6}
N 550 18050 550 18060 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 18030 1 0 {name=M1307
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 18060 600 18060 {
lab=GND}
N 600 18050 600 18060 {
lab=GND}
N 560 18010 600 18010 {
lab=word300}
N 600 18010 640 18010 {
lab=word300}
N 570 18000 570 18050 {
lab=GND}
N 570 18050 570 18060 {
lab=GND}
N 630 18000 630 18050 {
lab=Y7}
N 630 18050 630 18060 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18030 1 0 {name=M1308
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18070 0 0 {name=p324 lab=word301}
N 0 18070 40 18070 {
lab=word301}
N 40 18070 80 18070 {
lab=word301}
N 10 18060 10 18110 {
lab=GND}
N 10 18110 10 18120 {
lab=GND}
N 70 18060 70 18110 {
lab=Y0}
N 70 18110 70 18120 {
lab=Y0}

N 90 18120 120 18120 {
lab=GND}
N 120 18110 120 18120 {
lab=GND}
N 80 18070 120 18070 {
lab=word301}
N 120 18070 160 18070 {
lab=word301}
N 90 18060 90 18110 {
lab=GND}
N 90 18110 90 18120 {
lab=GND}
N 150 18060 150 18110 {
lab=Y1}
N 150 18110 150 18120 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18090 1 0 {name=M1309
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 18070 200 18070 {
lab=word301}
N 200 18070 240 18070 {
lab=word301}
N 170 18060 170 18110 {
lab=GND}
N 170 18110 170 18120 {
lab=GND}
N 230 18060 230 18110 {
lab=Y2}
N 230 18110 230 18120 {
lab=Y2}

N 250 18120 280 18120 {
lab=GND}
N 280 18110 280 18120 {
lab=GND}
N 240 18070 280 18070 {
lab=word301}
N 280 18070 320 18070 {
lab=word301}
N 250 18060 250 18110 {
lab=GND}
N 250 18110 250 18120 {
lab=GND}
N 310 18060 310 18110 {
lab=Y3}
N 310 18110 310 18120 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 18090 1 0 {name=M1310
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 18120 360 18120 {
lab=GND}
N 360 18110 360 18120 {
lab=GND}
N 320 18070 360 18070 {
lab=word301}
N 360 18070 400 18070 {
lab=word301}
N 330 18060 330 18110 {
lab=GND}
N 330 18110 330 18120 {
lab=GND}
N 390 18060 390 18110 {
lab=Y4}
N 390 18110 390 18120 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 18090 1 0 {name=M1311
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 18070 440 18070 {
lab=word301}
N 440 18070 480 18070 {
lab=word301}
N 410 18060 410 18110 {
lab=GND}
N 410 18110 410 18120 {
lab=GND}
N 470 18060 470 18110 {
lab=Y5}
N 470 18110 470 18120 {
lab=Y5}
N 480 18070 520 18070 {
lab=word301}
N 520 18070 560 18070 {
lab=word301}
N 490 18060 490 18110 {
lab=GND}
N 490 18110 490 18120 {
lab=GND}
N 550 18060 550 18110 {
lab=Y6}
N 550 18110 550 18120 {
lab=Y6}

N 570 18120 600 18120 {
lab=GND}
N 600 18110 600 18120 {
lab=GND}
N 560 18070 600 18070 {
lab=word301}
N 600 18070 640 18070 {
lab=word301}
N 570 18060 570 18110 {
lab=GND}
N 570 18110 570 18120 {
lab=GND}
N 630 18060 630 18110 {
lab=Y7}
N 630 18110 630 18120 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18090 1 0 {name=M1312
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18130 0 0 {name=p325 lab=word302}
N 0 18130 40 18130 {
lab=word302}
N 40 18130 80 18130 {
lab=word302}
N 10 18120 10 18170 {
lab=GND}
N 10 18170 10 18180 {
lab=GND}
N 70 18120 70 18170 {
lab=Y0}
N 70 18170 70 18180 {
lab=Y0}

N 90 18180 120 18180 {
lab=GND}
N 120 18170 120 18180 {
lab=GND}
N 80 18130 120 18130 {
lab=word302}
N 120 18130 160 18130 {
lab=word302}
N 90 18120 90 18170 {
lab=GND}
N 90 18170 90 18180 {
lab=GND}
N 150 18120 150 18170 {
lab=Y1}
N 150 18170 150 18180 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18150 1 0 {name=M1313
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 18130 200 18130 {
lab=word302}
N 200 18130 240 18130 {
lab=word302}
N 170 18120 170 18170 {
lab=GND}
N 170 18170 170 18180 {
lab=GND}
N 230 18120 230 18170 {
lab=Y2}
N 230 18170 230 18180 {
lab=Y2}

N 250 18180 280 18180 {
lab=GND}
N 280 18170 280 18180 {
lab=GND}
N 240 18130 280 18130 {
lab=word302}
N 280 18130 320 18130 {
lab=word302}
N 250 18120 250 18170 {
lab=GND}
N 250 18170 250 18180 {
lab=GND}
N 310 18120 310 18170 {
lab=Y3}
N 310 18170 310 18180 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 18150 1 0 {name=M1314
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 18180 360 18180 {
lab=GND}
N 360 18170 360 18180 {
lab=GND}
N 320 18130 360 18130 {
lab=word302}
N 360 18130 400 18130 {
lab=word302}
N 330 18120 330 18170 {
lab=GND}
N 330 18170 330 18180 {
lab=GND}
N 390 18120 390 18170 {
lab=Y4}
N 390 18170 390 18180 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 18150 1 0 {name=M1315
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 18130 440 18130 {
lab=word302}
N 440 18130 480 18130 {
lab=word302}
N 410 18120 410 18170 {
lab=GND}
N 410 18170 410 18180 {
lab=GND}
N 470 18120 470 18170 {
lab=Y5}
N 470 18170 470 18180 {
lab=Y5}

N 490 18180 520 18180 {
lab=GND}
N 520 18170 520 18180 {
lab=GND}
N 480 18130 520 18130 {
lab=word302}
N 520 18130 560 18130 {
lab=word302}
N 490 18120 490 18170 {
lab=GND}
N 490 18170 490 18180 {
lab=GND}
N 550 18120 550 18170 {
lab=Y6}
N 550 18170 550 18180 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 18150 1 0 {name=M1316
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 18180 600 18180 {
lab=GND}
N 600 18170 600 18180 {
lab=GND}
N 560 18130 600 18130 {
lab=word302}
N 600 18130 640 18130 {
lab=word302}
N 570 18120 570 18170 {
lab=GND}
N 570 18170 570 18180 {
lab=GND}
N 630 18120 630 18170 {
lab=Y7}
N 630 18170 630 18180 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18150 1 0 {name=M1317
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18190 0 0 {name=p326 lab=word303}
N 0 18190 40 18190 {
lab=word303}
N 40 18190 80 18190 {
lab=word303}
N 10 18180 10 18230 {
lab=GND}
N 10 18230 10 18240 {
lab=GND}
N 70 18180 70 18230 {
lab=Y0}
N 70 18230 70 18240 {
lab=Y0}

N 90 18240 120 18240 {
lab=GND}
N 120 18230 120 18240 {
lab=GND}
N 80 18190 120 18190 {
lab=word303}
N 120 18190 160 18190 {
lab=word303}
N 90 18180 90 18230 {
lab=GND}
N 90 18230 90 18240 {
lab=GND}
N 150 18180 150 18230 {
lab=Y1}
N 150 18230 150 18240 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18210 1 0 {name=M1318
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 18190 200 18190 {
lab=word303}
N 200 18190 240 18190 {
lab=word303}
N 170 18180 170 18230 {
lab=GND}
N 170 18230 170 18240 {
lab=GND}
N 230 18180 230 18230 {
lab=Y2}
N 230 18230 230 18240 {
lab=Y2}

N 250 18240 280 18240 {
lab=GND}
N 280 18230 280 18240 {
lab=GND}
N 240 18190 280 18190 {
lab=word303}
N 280 18190 320 18190 {
lab=word303}
N 250 18180 250 18230 {
lab=GND}
N 250 18230 250 18240 {
lab=GND}
N 310 18180 310 18230 {
lab=Y3}
N 310 18230 310 18240 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 18210 1 0 {name=M1319
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 18240 360 18240 {
lab=GND}
N 360 18230 360 18240 {
lab=GND}
N 320 18190 360 18190 {
lab=word303}
N 360 18190 400 18190 {
lab=word303}
N 330 18180 330 18230 {
lab=GND}
N 330 18230 330 18240 {
lab=GND}
N 390 18180 390 18230 {
lab=Y4}
N 390 18230 390 18240 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 18210 1 0 {name=M1320
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 18240 440 18240 {
lab=GND}
N 440 18230 440 18240 {
lab=GND}
N 400 18190 440 18190 {
lab=word303}
N 440 18190 480 18190 {
lab=word303}
N 410 18180 410 18230 {
lab=GND}
N 410 18230 410 18240 {
lab=GND}
N 470 18180 470 18230 {
lab=Y5}
N 470 18230 470 18240 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 18210 1 0 {name=M1321
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 18190 520 18190 {
lab=word303}
N 520 18190 560 18190 {
lab=word303}
N 490 18180 490 18230 {
lab=GND}
N 490 18230 490 18240 {
lab=GND}
N 550 18180 550 18230 {
lab=Y6}
N 550 18230 550 18240 {
lab=Y6}

N 570 18240 600 18240 {
lab=GND}
N 600 18230 600 18240 {
lab=GND}
N 560 18190 600 18190 {
lab=word303}
N 600 18190 640 18190 {
lab=word303}
N 570 18180 570 18230 {
lab=GND}
N 570 18230 570 18240 {
lab=GND}
N 630 18180 630 18230 {
lab=Y7}
N 630 18230 630 18240 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18210 1 0 {name=M1322
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18250 0 0 {name=p327 lab=word304}
N 0 18250 40 18250 {
lab=word304}
N 40 18250 80 18250 {
lab=word304}
N 10 18240 10 18290 {
lab=GND}
N 10 18290 10 18300 {
lab=GND}
N 70 18240 70 18290 {
lab=Y0}
N 70 18290 70 18300 {
lab=Y0}

N 90 18300 120 18300 {
lab=GND}
N 120 18290 120 18300 {
lab=GND}
N 80 18250 120 18250 {
lab=word304}
N 120 18250 160 18250 {
lab=word304}
N 90 18240 90 18290 {
lab=GND}
N 90 18290 90 18300 {
lab=GND}
N 150 18240 150 18290 {
lab=Y1}
N 150 18290 150 18300 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18270 1 0 {name=M1323
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 18250 200 18250 {
lab=word304}
N 200 18250 240 18250 {
lab=word304}
N 170 18240 170 18290 {
lab=GND}
N 170 18290 170 18300 {
lab=GND}
N 230 18240 230 18290 {
lab=Y2}
N 230 18290 230 18300 {
lab=Y2}

N 250 18300 280 18300 {
lab=GND}
N 280 18290 280 18300 {
lab=GND}
N 240 18250 280 18250 {
lab=word304}
N 280 18250 320 18250 {
lab=word304}
N 250 18240 250 18290 {
lab=GND}
N 250 18290 250 18300 {
lab=GND}
N 310 18240 310 18290 {
lab=Y3}
N 310 18290 310 18300 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 18270 1 0 {name=M1324
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 18300 360 18300 {
lab=GND}
N 360 18290 360 18300 {
lab=GND}
N 320 18250 360 18250 {
lab=word304}
N 360 18250 400 18250 {
lab=word304}
N 330 18240 330 18290 {
lab=GND}
N 330 18290 330 18300 {
lab=GND}
N 390 18240 390 18290 {
lab=Y4}
N 390 18290 390 18300 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 18270 1 0 {name=M1325
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 18300 440 18300 {
lab=GND}
N 440 18290 440 18300 {
lab=GND}
N 400 18250 440 18250 {
lab=word304}
N 440 18250 480 18250 {
lab=word304}
N 410 18240 410 18290 {
lab=GND}
N 410 18290 410 18300 {
lab=GND}
N 470 18240 470 18290 {
lab=Y5}
N 470 18290 470 18300 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 18270 1 0 {name=M1326
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 18300 520 18300 {
lab=GND}
N 520 18290 520 18300 {
lab=GND}
N 480 18250 520 18250 {
lab=word304}
N 520 18250 560 18250 {
lab=word304}
N 490 18240 490 18290 {
lab=GND}
N 490 18290 490 18300 {
lab=GND}
N 550 18240 550 18290 {
lab=Y6}
N 550 18290 550 18300 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 18270 1 0 {name=M1327
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 18300 600 18300 {
lab=GND}
N 600 18290 600 18300 {
lab=GND}
N 560 18250 600 18250 {
lab=word304}
N 600 18250 640 18250 {
lab=word304}
N 570 18240 570 18290 {
lab=GND}
N 570 18290 570 18300 {
lab=GND}
N 630 18240 630 18290 {
lab=Y7}
N 630 18290 630 18300 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18270 1 0 {name=M1328
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18310 0 0 {name=p328 lab=word305}
N 0 18310 40 18310 {
lab=word305}
N 40 18310 80 18310 {
lab=word305}
N 10 18300 10 18350 {
lab=GND}
N 10 18350 10 18360 {
lab=GND}
N 70 18300 70 18350 {
lab=Y0}
N 70 18350 70 18360 {
lab=Y0}

N 90 18360 120 18360 {
lab=GND}
N 120 18350 120 18360 {
lab=GND}
N 80 18310 120 18310 {
lab=word305}
N 120 18310 160 18310 {
lab=word305}
N 90 18300 90 18350 {
lab=GND}
N 90 18350 90 18360 {
lab=GND}
N 150 18300 150 18350 {
lab=Y1}
N 150 18350 150 18360 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18330 1 0 {name=M1329
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 18360 200 18360 {
lab=GND}
N 200 18350 200 18360 {
lab=GND}
N 160 18310 200 18310 {
lab=word305}
N 200 18310 240 18310 {
lab=word305}
N 170 18300 170 18350 {
lab=GND}
N 170 18350 170 18360 {
lab=GND}
N 230 18300 230 18350 {
lab=Y2}
N 230 18350 230 18360 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 18330 1 0 {name=M1330
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 18310 280 18310 {
lab=word305}
N 280 18310 320 18310 {
lab=word305}
N 250 18300 250 18350 {
lab=GND}
N 250 18350 250 18360 {
lab=GND}
N 310 18300 310 18350 {
lab=Y3}
N 310 18350 310 18360 {
lab=Y3}
N 320 18310 360 18310 {
lab=word305}
N 360 18310 400 18310 {
lab=word305}
N 330 18300 330 18350 {
lab=GND}
N 330 18350 330 18360 {
lab=GND}
N 390 18300 390 18350 {
lab=Y4}
N 390 18350 390 18360 {
lab=Y4}
N 400 18310 440 18310 {
lab=word305}
N 440 18310 480 18310 {
lab=word305}
N 410 18300 410 18350 {
lab=GND}
N 410 18350 410 18360 {
lab=GND}
N 470 18300 470 18350 {
lab=Y5}
N 470 18350 470 18360 {
lab=Y5}
N 480 18310 520 18310 {
lab=word305}
N 520 18310 560 18310 {
lab=word305}
N 490 18300 490 18350 {
lab=GND}
N 490 18350 490 18360 {
lab=GND}
N 550 18300 550 18350 {
lab=Y6}
N 550 18350 550 18360 {
lab=Y6}

N 570 18360 600 18360 {
lab=GND}
N 600 18350 600 18360 {
lab=GND}
N 560 18310 600 18310 {
lab=word305}
N 600 18310 640 18310 {
lab=word305}
N 570 18300 570 18350 {
lab=GND}
N 570 18350 570 18360 {
lab=GND}
N 630 18300 630 18350 {
lab=Y7}
N 630 18350 630 18360 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18330 1 0 {name=M1331
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18370 0 0 {name=p329 lab=word306}
N 0 18370 40 18370 {
lab=word306}
N 40 18370 80 18370 {
lab=word306}
N 10 18360 10 18410 {
lab=GND}
N 10 18410 10 18420 {
lab=GND}
N 70 18360 70 18410 {
lab=Y0}
N 70 18410 70 18420 {
lab=Y0}

N 90 18420 120 18420 {
lab=GND}
N 120 18410 120 18420 {
lab=GND}
N 80 18370 120 18370 {
lab=word306}
N 120 18370 160 18370 {
lab=word306}
N 90 18360 90 18410 {
lab=GND}
N 90 18410 90 18420 {
lab=GND}
N 150 18360 150 18410 {
lab=Y1}
N 150 18410 150 18420 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18390 1 0 {name=M1332
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 18420 200 18420 {
lab=GND}
N 200 18410 200 18420 {
lab=GND}
N 160 18370 200 18370 {
lab=word306}
N 200 18370 240 18370 {
lab=word306}
N 170 18360 170 18410 {
lab=GND}
N 170 18410 170 18420 {
lab=GND}
N 230 18360 230 18410 {
lab=Y2}
N 230 18410 230 18420 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 18390 1 0 {name=M1333
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 18370 280 18370 {
lab=word306}
N 280 18370 320 18370 {
lab=word306}
N 250 18360 250 18410 {
lab=GND}
N 250 18410 250 18420 {
lab=GND}
N 310 18360 310 18410 {
lab=Y3}
N 310 18410 310 18420 {
lab=Y3}
N 320 18370 360 18370 {
lab=word306}
N 360 18370 400 18370 {
lab=word306}
N 330 18360 330 18410 {
lab=GND}
N 330 18410 330 18420 {
lab=GND}
N 390 18360 390 18410 {
lab=Y4}
N 390 18410 390 18420 {
lab=Y4}
N 400 18370 440 18370 {
lab=word306}
N 440 18370 480 18370 {
lab=word306}
N 410 18360 410 18410 {
lab=GND}
N 410 18410 410 18420 {
lab=GND}
N 470 18360 470 18410 {
lab=Y5}
N 470 18410 470 18420 {
lab=Y5}

N 490 18420 520 18420 {
lab=GND}
N 520 18410 520 18420 {
lab=GND}
N 480 18370 520 18370 {
lab=word306}
N 520 18370 560 18370 {
lab=word306}
N 490 18360 490 18410 {
lab=GND}
N 490 18410 490 18420 {
lab=GND}
N 550 18360 550 18410 {
lab=Y6}
N 550 18410 550 18420 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 18390 1 0 {name=M1334
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 18420 600 18420 {
lab=GND}
N 600 18410 600 18420 {
lab=GND}
N 560 18370 600 18370 {
lab=word306}
N 600 18370 640 18370 {
lab=word306}
N 570 18360 570 18410 {
lab=GND}
N 570 18410 570 18420 {
lab=GND}
N 630 18360 630 18410 {
lab=Y7}
N 630 18410 630 18420 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18390 1 0 {name=M1335
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18430 0 0 {name=p330 lab=word307}
N 0 18430 40 18430 {
lab=word307}
N 40 18430 80 18430 {
lab=word307}
N 10 18420 10 18470 {
lab=GND}
N 10 18470 10 18480 {
lab=GND}
N 70 18420 70 18470 {
lab=Y0}
N 70 18470 70 18480 {
lab=Y0}

N 90 18480 120 18480 {
lab=GND}
N 120 18470 120 18480 {
lab=GND}
N 80 18430 120 18430 {
lab=word307}
N 120 18430 160 18430 {
lab=word307}
N 90 18420 90 18470 {
lab=GND}
N 90 18470 90 18480 {
lab=GND}
N 150 18420 150 18470 {
lab=Y1}
N 150 18470 150 18480 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18450 1 0 {name=M1336
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 18480 200 18480 {
lab=GND}
N 200 18470 200 18480 {
lab=GND}
N 160 18430 200 18430 {
lab=word307}
N 200 18430 240 18430 {
lab=word307}
N 170 18420 170 18470 {
lab=GND}
N 170 18470 170 18480 {
lab=GND}
N 230 18420 230 18470 {
lab=Y2}
N 230 18470 230 18480 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 18450 1 0 {name=M1337
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 18430 280 18430 {
lab=word307}
N 280 18430 320 18430 {
lab=word307}
N 250 18420 250 18470 {
lab=GND}
N 250 18470 250 18480 {
lab=GND}
N 310 18420 310 18470 {
lab=Y3}
N 310 18470 310 18480 {
lab=Y3}
N 320 18430 360 18430 {
lab=word307}
N 360 18430 400 18430 {
lab=word307}
N 330 18420 330 18470 {
lab=GND}
N 330 18470 330 18480 {
lab=GND}
N 390 18420 390 18470 {
lab=Y4}
N 390 18470 390 18480 {
lab=Y4}

N 410 18480 440 18480 {
lab=GND}
N 440 18470 440 18480 {
lab=GND}
N 400 18430 440 18430 {
lab=word307}
N 440 18430 480 18430 {
lab=word307}
N 410 18420 410 18470 {
lab=GND}
N 410 18470 410 18480 {
lab=GND}
N 470 18420 470 18470 {
lab=Y5}
N 470 18470 470 18480 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 18450 1 0 {name=M1338
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 18430 520 18430 {
lab=word307}
N 520 18430 560 18430 {
lab=word307}
N 490 18420 490 18470 {
lab=GND}
N 490 18470 490 18480 {
lab=GND}
N 550 18420 550 18470 {
lab=Y6}
N 550 18470 550 18480 {
lab=Y6}

N 570 18480 600 18480 {
lab=GND}
N 600 18470 600 18480 {
lab=GND}
N 560 18430 600 18430 {
lab=word307}
N 600 18430 640 18430 {
lab=word307}
N 570 18420 570 18470 {
lab=GND}
N 570 18470 570 18480 {
lab=GND}
N 630 18420 630 18470 {
lab=Y7}
N 630 18470 630 18480 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18450 1 0 {name=M1339
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18490 0 0 {name=p331 lab=word308}
N 0 18490 40 18490 {
lab=word308}
N 40 18490 80 18490 {
lab=word308}
N 10 18480 10 18530 {
lab=GND}
N 10 18530 10 18540 {
lab=GND}
N 70 18480 70 18530 {
lab=Y0}
N 70 18530 70 18540 {
lab=Y0}

N 90 18540 120 18540 {
lab=GND}
N 120 18530 120 18540 {
lab=GND}
N 80 18490 120 18490 {
lab=word308}
N 120 18490 160 18490 {
lab=word308}
N 90 18480 90 18530 {
lab=GND}
N 90 18530 90 18540 {
lab=GND}
N 150 18480 150 18530 {
lab=Y1}
N 150 18530 150 18540 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18510 1 0 {name=M1340
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 18540 200 18540 {
lab=GND}
N 200 18530 200 18540 {
lab=GND}
N 160 18490 200 18490 {
lab=word308}
N 200 18490 240 18490 {
lab=word308}
N 170 18480 170 18530 {
lab=GND}
N 170 18530 170 18540 {
lab=GND}
N 230 18480 230 18530 {
lab=Y2}
N 230 18530 230 18540 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 18510 1 0 {name=M1341
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 18490 280 18490 {
lab=word308}
N 280 18490 320 18490 {
lab=word308}
N 250 18480 250 18530 {
lab=GND}
N 250 18530 250 18540 {
lab=GND}
N 310 18480 310 18530 {
lab=Y3}
N 310 18530 310 18540 {
lab=Y3}
N 320 18490 360 18490 {
lab=word308}
N 360 18490 400 18490 {
lab=word308}
N 330 18480 330 18530 {
lab=GND}
N 330 18530 330 18540 {
lab=GND}
N 390 18480 390 18530 {
lab=Y4}
N 390 18530 390 18540 {
lab=Y4}

N 410 18540 440 18540 {
lab=GND}
N 440 18530 440 18540 {
lab=GND}
N 400 18490 440 18490 {
lab=word308}
N 440 18490 480 18490 {
lab=word308}
N 410 18480 410 18530 {
lab=GND}
N 410 18530 410 18540 {
lab=GND}
N 470 18480 470 18530 {
lab=Y5}
N 470 18530 470 18540 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 18510 1 0 {name=M1342
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 18540 520 18540 {
lab=GND}
N 520 18530 520 18540 {
lab=GND}
N 480 18490 520 18490 {
lab=word308}
N 520 18490 560 18490 {
lab=word308}
N 490 18480 490 18530 {
lab=GND}
N 490 18530 490 18540 {
lab=GND}
N 550 18480 550 18530 {
lab=Y6}
N 550 18530 550 18540 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 18510 1 0 {name=M1343
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 18540 600 18540 {
lab=GND}
N 600 18530 600 18540 {
lab=GND}
N 560 18490 600 18490 {
lab=word308}
N 600 18490 640 18490 {
lab=word308}
N 570 18480 570 18530 {
lab=GND}
N 570 18530 570 18540 {
lab=GND}
N 630 18480 630 18530 {
lab=Y7}
N 630 18530 630 18540 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18510 1 0 {name=M1344
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18550 0 0 {name=p332 lab=word309}
N 0 18550 40 18550 {
lab=word309}
N 40 18550 80 18550 {
lab=word309}
N 10 18540 10 18590 {
lab=GND}
N 10 18590 10 18600 {
lab=GND}
N 70 18540 70 18590 {
lab=Y0}
N 70 18590 70 18600 {
lab=Y0}

N 90 18600 120 18600 {
lab=GND}
N 120 18590 120 18600 {
lab=GND}
N 80 18550 120 18550 {
lab=word309}
N 120 18550 160 18550 {
lab=word309}
N 90 18540 90 18590 {
lab=GND}
N 90 18590 90 18600 {
lab=GND}
N 150 18540 150 18590 {
lab=Y1}
N 150 18590 150 18600 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18570 1 0 {name=M1345
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 18600 200 18600 {
lab=GND}
N 200 18590 200 18600 {
lab=GND}
N 160 18550 200 18550 {
lab=word309}
N 200 18550 240 18550 {
lab=word309}
N 170 18540 170 18590 {
lab=GND}
N 170 18590 170 18600 {
lab=GND}
N 230 18540 230 18590 {
lab=Y2}
N 230 18590 230 18600 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 18570 1 0 {name=M1346
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 18550 280 18550 {
lab=word309}
N 280 18550 320 18550 {
lab=word309}
N 250 18540 250 18590 {
lab=GND}
N 250 18590 250 18600 {
lab=GND}
N 310 18540 310 18590 {
lab=Y3}
N 310 18590 310 18600 {
lab=Y3}

N 330 18600 360 18600 {
lab=GND}
N 360 18590 360 18600 {
lab=GND}
N 320 18550 360 18550 {
lab=word309}
N 360 18550 400 18550 {
lab=word309}
N 330 18540 330 18590 {
lab=GND}
N 330 18590 330 18600 {
lab=GND}
N 390 18540 390 18590 {
lab=Y4}
N 390 18590 390 18600 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 18570 1 0 {name=M1347
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 18550 440 18550 {
lab=word309}
N 440 18550 480 18550 {
lab=word309}
N 410 18540 410 18590 {
lab=GND}
N 410 18590 410 18600 {
lab=GND}
N 470 18540 470 18590 {
lab=Y5}
N 470 18590 470 18600 {
lab=Y5}
N 480 18550 520 18550 {
lab=word309}
N 520 18550 560 18550 {
lab=word309}
N 490 18540 490 18590 {
lab=GND}
N 490 18590 490 18600 {
lab=GND}
N 550 18540 550 18590 {
lab=Y6}
N 550 18590 550 18600 {
lab=Y6}

N 570 18600 600 18600 {
lab=GND}
N 600 18590 600 18600 {
lab=GND}
N 560 18550 600 18550 {
lab=word309}
N 600 18550 640 18550 {
lab=word309}
N 570 18540 570 18590 {
lab=GND}
N 570 18590 570 18600 {
lab=GND}
N 630 18540 630 18590 {
lab=Y7}
N 630 18590 630 18600 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18570 1 0 {name=M1348
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18610 0 0 {name=p333 lab=word310}
N 0 18610 40 18610 {
lab=word310}
N 40 18610 80 18610 {
lab=word310}
N 10 18600 10 18650 {
lab=GND}
N 10 18650 10 18660 {
lab=GND}
N 70 18600 70 18650 {
lab=Y0}
N 70 18650 70 18660 {
lab=Y0}

N 90 18660 120 18660 {
lab=GND}
N 120 18650 120 18660 {
lab=GND}
N 80 18610 120 18610 {
lab=word310}
N 120 18610 160 18610 {
lab=word310}
N 90 18600 90 18650 {
lab=GND}
N 90 18650 90 18660 {
lab=GND}
N 150 18600 150 18650 {
lab=Y1}
N 150 18650 150 18660 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18630 1 0 {name=M1349
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 18660 200 18660 {
lab=GND}
N 200 18650 200 18660 {
lab=GND}
N 160 18610 200 18610 {
lab=word310}
N 200 18610 240 18610 {
lab=word310}
N 170 18600 170 18650 {
lab=GND}
N 170 18650 170 18660 {
lab=GND}
N 230 18600 230 18650 {
lab=Y2}
N 230 18650 230 18660 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 18630 1 0 {name=M1350
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 18610 280 18610 {
lab=word310}
N 280 18610 320 18610 {
lab=word310}
N 250 18600 250 18650 {
lab=GND}
N 250 18650 250 18660 {
lab=GND}
N 310 18600 310 18650 {
lab=Y3}
N 310 18650 310 18660 {
lab=Y3}

N 330 18660 360 18660 {
lab=GND}
N 360 18650 360 18660 {
lab=GND}
N 320 18610 360 18610 {
lab=word310}
N 360 18610 400 18610 {
lab=word310}
N 330 18600 330 18650 {
lab=GND}
N 330 18650 330 18660 {
lab=GND}
N 390 18600 390 18650 {
lab=Y4}
N 390 18650 390 18660 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 18630 1 0 {name=M1351
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 18610 440 18610 {
lab=word310}
N 440 18610 480 18610 {
lab=word310}
N 410 18600 410 18650 {
lab=GND}
N 410 18650 410 18660 {
lab=GND}
N 470 18600 470 18650 {
lab=Y5}
N 470 18650 470 18660 {
lab=Y5}

N 490 18660 520 18660 {
lab=GND}
N 520 18650 520 18660 {
lab=GND}
N 480 18610 520 18610 {
lab=word310}
N 520 18610 560 18610 {
lab=word310}
N 490 18600 490 18650 {
lab=GND}
N 490 18650 490 18660 {
lab=GND}
N 550 18600 550 18650 {
lab=Y6}
N 550 18650 550 18660 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 18630 1 0 {name=M1352
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 18660 600 18660 {
lab=GND}
N 600 18650 600 18660 {
lab=GND}
N 560 18610 600 18610 {
lab=word310}
N 600 18610 640 18610 {
lab=word310}
N 570 18600 570 18650 {
lab=GND}
N 570 18650 570 18660 {
lab=GND}
N 630 18600 630 18650 {
lab=Y7}
N 630 18650 630 18660 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18630 1 0 {name=M1353
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18670 0 0 {name=p334 lab=word311}
N 0 18670 40 18670 {
lab=word311}
N 40 18670 80 18670 {
lab=word311}
N 10 18660 10 18710 {
lab=GND}
N 10 18710 10 18720 {
lab=GND}
N 70 18660 70 18710 {
lab=Y0}
N 70 18710 70 18720 {
lab=Y0}

N 90 18720 120 18720 {
lab=GND}
N 120 18710 120 18720 {
lab=GND}
N 80 18670 120 18670 {
lab=word311}
N 120 18670 160 18670 {
lab=word311}
N 90 18660 90 18710 {
lab=GND}
N 90 18710 90 18720 {
lab=GND}
N 150 18660 150 18710 {
lab=Y1}
N 150 18710 150 18720 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18690 1 0 {name=M1354
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 18720 200 18720 {
lab=GND}
N 200 18710 200 18720 {
lab=GND}
N 160 18670 200 18670 {
lab=word311}
N 200 18670 240 18670 {
lab=word311}
N 170 18660 170 18710 {
lab=GND}
N 170 18710 170 18720 {
lab=GND}
N 230 18660 230 18710 {
lab=Y2}
N 230 18710 230 18720 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 18690 1 0 {name=M1355
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 18670 280 18670 {
lab=word311}
N 280 18670 320 18670 {
lab=word311}
N 250 18660 250 18710 {
lab=GND}
N 250 18710 250 18720 {
lab=GND}
N 310 18660 310 18710 {
lab=Y3}
N 310 18710 310 18720 {
lab=Y3}

N 330 18720 360 18720 {
lab=GND}
N 360 18710 360 18720 {
lab=GND}
N 320 18670 360 18670 {
lab=word311}
N 360 18670 400 18670 {
lab=word311}
N 330 18660 330 18710 {
lab=GND}
N 330 18710 330 18720 {
lab=GND}
N 390 18660 390 18710 {
lab=Y4}
N 390 18710 390 18720 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 18690 1 0 {name=M1356
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 18720 440 18720 {
lab=GND}
N 440 18710 440 18720 {
lab=GND}
N 400 18670 440 18670 {
lab=word311}
N 440 18670 480 18670 {
lab=word311}
N 410 18660 410 18710 {
lab=GND}
N 410 18710 410 18720 {
lab=GND}
N 470 18660 470 18710 {
lab=Y5}
N 470 18710 470 18720 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 18690 1 0 {name=M1357
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 18670 520 18670 {
lab=word311}
N 520 18670 560 18670 {
lab=word311}
N 490 18660 490 18710 {
lab=GND}
N 490 18710 490 18720 {
lab=GND}
N 550 18660 550 18710 {
lab=Y6}
N 550 18710 550 18720 {
lab=Y6}

N 570 18720 600 18720 {
lab=GND}
N 600 18710 600 18720 {
lab=GND}
N 560 18670 600 18670 {
lab=word311}
N 600 18670 640 18670 {
lab=word311}
N 570 18660 570 18710 {
lab=GND}
N 570 18710 570 18720 {
lab=GND}
N 630 18660 630 18710 {
lab=Y7}
N 630 18710 630 18720 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18690 1 0 {name=M1358
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18730 0 0 {name=p335 lab=word312}
N 0 18730 40 18730 {
lab=word312}
N 40 18730 80 18730 {
lab=word312}
N 10 18720 10 18770 {
lab=GND}
N 10 18770 10 18780 {
lab=GND}
N 70 18720 70 18770 {
lab=Y0}
N 70 18770 70 18780 {
lab=Y0}

N 90 18780 120 18780 {
lab=GND}
N 120 18770 120 18780 {
lab=GND}
N 80 18730 120 18730 {
lab=word312}
N 120 18730 160 18730 {
lab=word312}
N 90 18720 90 18770 {
lab=GND}
N 90 18770 90 18780 {
lab=GND}
N 150 18720 150 18770 {
lab=Y1}
N 150 18770 150 18780 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18750 1 0 {name=M1359
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 18780 200 18780 {
lab=GND}
N 200 18770 200 18780 {
lab=GND}
N 160 18730 200 18730 {
lab=word312}
N 200 18730 240 18730 {
lab=word312}
N 170 18720 170 18770 {
lab=GND}
N 170 18770 170 18780 {
lab=GND}
N 230 18720 230 18770 {
lab=Y2}
N 230 18770 230 18780 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 18750 1 0 {name=M1360
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 18730 280 18730 {
lab=word312}
N 280 18730 320 18730 {
lab=word312}
N 250 18720 250 18770 {
lab=GND}
N 250 18770 250 18780 {
lab=GND}
N 310 18720 310 18770 {
lab=Y3}
N 310 18770 310 18780 {
lab=Y3}

N 330 18780 360 18780 {
lab=GND}
N 360 18770 360 18780 {
lab=GND}
N 320 18730 360 18730 {
lab=word312}
N 360 18730 400 18730 {
lab=word312}
N 330 18720 330 18770 {
lab=GND}
N 330 18770 330 18780 {
lab=GND}
N 390 18720 390 18770 {
lab=Y4}
N 390 18770 390 18780 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 18750 1 0 {name=M1361
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 18780 440 18780 {
lab=GND}
N 440 18770 440 18780 {
lab=GND}
N 400 18730 440 18730 {
lab=word312}
N 440 18730 480 18730 {
lab=word312}
N 410 18720 410 18770 {
lab=GND}
N 410 18770 410 18780 {
lab=GND}
N 470 18720 470 18770 {
lab=Y5}
N 470 18770 470 18780 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 18750 1 0 {name=M1362
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 18780 520 18780 {
lab=GND}
N 520 18770 520 18780 {
lab=GND}
N 480 18730 520 18730 {
lab=word312}
N 520 18730 560 18730 {
lab=word312}
N 490 18720 490 18770 {
lab=GND}
N 490 18770 490 18780 {
lab=GND}
N 550 18720 550 18770 {
lab=Y6}
N 550 18770 550 18780 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 18750 1 0 {name=M1363
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 18780 600 18780 {
lab=GND}
N 600 18770 600 18780 {
lab=GND}
N 560 18730 600 18730 {
lab=word312}
N 600 18730 640 18730 {
lab=word312}
N 570 18720 570 18770 {
lab=GND}
N 570 18770 570 18780 {
lab=GND}
N 630 18720 630 18770 {
lab=Y7}
N 630 18770 630 18780 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18750 1 0 {name=M1364
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18790 0 0 {name=p336 lab=word313}
N 0 18790 40 18790 {
lab=word313}
N 40 18790 80 18790 {
lab=word313}
N 10 18780 10 18830 {
lab=GND}
N 10 18830 10 18840 {
lab=GND}
N 70 18780 70 18830 {
lab=Y0}
N 70 18830 70 18840 {
lab=Y0}

N 90 18840 120 18840 {
lab=GND}
N 120 18830 120 18840 {
lab=GND}
N 80 18790 120 18790 {
lab=word313}
N 120 18790 160 18790 {
lab=word313}
N 90 18780 90 18830 {
lab=GND}
N 90 18830 90 18840 {
lab=GND}
N 150 18780 150 18830 {
lab=Y1}
N 150 18830 150 18840 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18810 1 0 {name=M1365
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 18840 200 18840 {
lab=GND}
N 200 18830 200 18840 {
lab=GND}
N 160 18790 200 18790 {
lab=word313}
N 200 18790 240 18790 {
lab=word313}
N 170 18780 170 18830 {
lab=GND}
N 170 18830 170 18840 {
lab=GND}
N 230 18780 230 18830 {
lab=Y2}
N 230 18830 230 18840 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 18810 1 0 {name=M1366
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 18840 280 18840 {
lab=GND}
N 280 18830 280 18840 {
lab=GND}
N 240 18790 280 18790 {
lab=word313}
N 280 18790 320 18790 {
lab=word313}
N 250 18780 250 18830 {
lab=GND}
N 250 18830 250 18840 {
lab=GND}
N 310 18780 310 18830 {
lab=Y3}
N 310 18830 310 18840 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 18810 1 0 {name=M1367
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 18790 360 18790 {
lab=word313}
N 360 18790 400 18790 {
lab=word313}
N 330 18780 330 18830 {
lab=GND}
N 330 18830 330 18840 {
lab=GND}
N 390 18780 390 18830 {
lab=Y4}
N 390 18830 390 18840 {
lab=Y4}
N 400 18790 440 18790 {
lab=word313}
N 440 18790 480 18790 {
lab=word313}
N 410 18780 410 18830 {
lab=GND}
N 410 18830 410 18840 {
lab=GND}
N 470 18780 470 18830 {
lab=Y5}
N 470 18830 470 18840 {
lab=Y5}
N 480 18790 520 18790 {
lab=word313}
N 520 18790 560 18790 {
lab=word313}
N 490 18780 490 18830 {
lab=GND}
N 490 18830 490 18840 {
lab=GND}
N 550 18780 550 18830 {
lab=Y6}
N 550 18830 550 18840 {
lab=Y6}

N 570 18840 600 18840 {
lab=GND}
N 600 18830 600 18840 {
lab=GND}
N 560 18790 600 18790 {
lab=word313}
N 600 18790 640 18790 {
lab=word313}
N 570 18780 570 18830 {
lab=GND}
N 570 18830 570 18840 {
lab=GND}
N 630 18780 630 18830 {
lab=Y7}
N 630 18830 630 18840 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18810 1 0 {name=M1368
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18850 0 0 {name=p337 lab=word314}
N 0 18850 40 18850 {
lab=word314}
N 40 18850 80 18850 {
lab=word314}
N 10 18840 10 18890 {
lab=GND}
N 10 18890 10 18900 {
lab=GND}
N 70 18840 70 18890 {
lab=Y0}
N 70 18890 70 18900 {
lab=Y0}

N 90 18900 120 18900 {
lab=GND}
N 120 18890 120 18900 {
lab=GND}
N 80 18850 120 18850 {
lab=word314}
N 120 18850 160 18850 {
lab=word314}
N 90 18840 90 18890 {
lab=GND}
N 90 18890 90 18900 {
lab=GND}
N 150 18840 150 18890 {
lab=Y1}
N 150 18890 150 18900 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18870 1 0 {name=M1369
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 18900 200 18900 {
lab=GND}
N 200 18890 200 18900 {
lab=GND}
N 160 18850 200 18850 {
lab=word314}
N 200 18850 240 18850 {
lab=word314}
N 170 18840 170 18890 {
lab=GND}
N 170 18890 170 18900 {
lab=GND}
N 230 18840 230 18890 {
lab=Y2}
N 230 18890 230 18900 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 18870 1 0 {name=M1370
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 18900 280 18900 {
lab=GND}
N 280 18890 280 18900 {
lab=GND}
N 240 18850 280 18850 {
lab=word314}
N 280 18850 320 18850 {
lab=word314}
N 250 18840 250 18890 {
lab=GND}
N 250 18890 250 18900 {
lab=GND}
N 310 18840 310 18890 {
lab=Y3}
N 310 18890 310 18900 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 18870 1 0 {name=M1371
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 18850 360 18850 {
lab=word314}
N 360 18850 400 18850 {
lab=word314}
N 330 18840 330 18890 {
lab=GND}
N 330 18890 330 18900 {
lab=GND}
N 390 18840 390 18890 {
lab=Y4}
N 390 18890 390 18900 {
lab=Y4}
N 400 18850 440 18850 {
lab=word314}
N 440 18850 480 18850 {
lab=word314}
N 410 18840 410 18890 {
lab=GND}
N 410 18890 410 18900 {
lab=GND}
N 470 18840 470 18890 {
lab=Y5}
N 470 18890 470 18900 {
lab=Y5}

N 490 18900 520 18900 {
lab=GND}
N 520 18890 520 18900 {
lab=GND}
N 480 18850 520 18850 {
lab=word314}
N 520 18850 560 18850 {
lab=word314}
N 490 18840 490 18890 {
lab=GND}
N 490 18890 490 18900 {
lab=GND}
N 550 18840 550 18890 {
lab=Y6}
N 550 18890 550 18900 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 18870 1 0 {name=M1372
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 18900 600 18900 {
lab=GND}
N 600 18890 600 18900 {
lab=GND}
N 560 18850 600 18850 {
lab=word314}
N 600 18850 640 18850 {
lab=word314}
N 570 18840 570 18890 {
lab=GND}
N 570 18890 570 18900 {
lab=GND}
N 630 18840 630 18890 {
lab=Y7}
N 630 18890 630 18900 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18870 1 0 {name=M1373
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18910 0 0 {name=p338 lab=word315}
N 0 18910 40 18910 {
lab=word315}
N 40 18910 80 18910 {
lab=word315}
N 10 18900 10 18950 {
lab=GND}
N 10 18950 10 18960 {
lab=GND}
N 70 18900 70 18950 {
lab=Y0}
N 70 18950 70 18960 {
lab=Y0}

N 90 18960 120 18960 {
lab=GND}
N 120 18950 120 18960 {
lab=GND}
N 80 18910 120 18910 {
lab=word315}
N 120 18910 160 18910 {
lab=word315}
N 90 18900 90 18950 {
lab=GND}
N 90 18950 90 18960 {
lab=GND}
N 150 18900 150 18950 {
lab=Y1}
N 150 18950 150 18960 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18930 1 0 {name=M1374
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 18960 200 18960 {
lab=GND}
N 200 18950 200 18960 {
lab=GND}
N 160 18910 200 18910 {
lab=word315}
N 200 18910 240 18910 {
lab=word315}
N 170 18900 170 18950 {
lab=GND}
N 170 18950 170 18960 {
lab=GND}
N 230 18900 230 18950 {
lab=Y2}
N 230 18950 230 18960 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 18930 1 0 {name=M1375
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 18960 280 18960 {
lab=GND}
N 280 18950 280 18960 {
lab=GND}
N 240 18910 280 18910 {
lab=word315}
N 280 18910 320 18910 {
lab=word315}
N 250 18900 250 18950 {
lab=GND}
N 250 18950 250 18960 {
lab=GND}
N 310 18900 310 18950 {
lab=Y3}
N 310 18950 310 18960 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 18930 1 0 {name=M1376
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 18910 360 18910 {
lab=word315}
N 360 18910 400 18910 {
lab=word315}
N 330 18900 330 18950 {
lab=GND}
N 330 18950 330 18960 {
lab=GND}
N 390 18900 390 18950 {
lab=Y4}
N 390 18950 390 18960 {
lab=Y4}

N 410 18960 440 18960 {
lab=GND}
N 440 18950 440 18960 {
lab=GND}
N 400 18910 440 18910 {
lab=word315}
N 440 18910 480 18910 {
lab=word315}
N 410 18900 410 18950 {
lab=GND}
N 410 18950 410 18960 {
lab=GND}
N 470 18900 470 18950 {
lab=Y5}
N 470 18950 470 18960 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 18930 1 0 {name=M1377
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 18910 520 18910 {
lab=word315}
N 520 18910 560 18910 {
lab=word315}
N 490 18900 490 18950 {
lab=GND}
N 490 18950 490 18960 {
lab=GND}
N 550 18900 550 18950 {
lab=Y6}
N 550 18950 550 18960 {
lab=Y6}

N 570 18960 600 18960 {
lab=GND}
N 600 18950 600 18960 {
lab=GND}
N 560 18910 600 18910 {
lab=word315}
N 600 18910 640 18910 {
lab=word315}
N 570 18900 570 18950 {
lab=GND}
N 570 18950 570 18960 {
lab=GND}
N 630 18900 630 18950 {
lab=Y7}
N 630 18950 630 18960 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18930 1 0 {name=M1378
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 18970 0 0 {name=p339 lab=word316}
N 0 18970 40 18970 {
lab=word316}
N 40 18970 80 18970 {
lab=word316}
N 10 18960 10 19010 {
lab=GND}
N 10 19010 10 19020 {
lab=GND}
N 70 18960 70 19010 {
lab=Y0}
N 70 19010 70 19020 {
lab=Y0}

N 90 19020 120 19020 {
lab=GND}
N 120 19010 120 19020 {
lab=GND}
N 80 18970 120 18970 {
lab=word316}
N 120 18970 160 18970 {
lab=word316}
N 90 18960 90 19010 {
lab=GND}
N 90 19010 90 19020 {
lab=GND}
N 150 18960 150 19010 {
lab=Y1}
N 150 19010 150 19020 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 18990 1 0 {name=M1379
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 19020 200 19020 {
lab=GND}
N 200 19010 200 19020 {
lab=GND}
N 160 18970 200 18970 {
lab=word316}
N 200 18970 240 18970 {
lab=word316}
N 170 18960 170 19010 {
lab=GND}
N 170 19010 170 19020 {
lab=GND}
N 230 18960 230 19010 {
lab=Y2}
N 230 19010 230 19020 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 18990 1 0 {name=M1380
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 19020 280 19020 {
lab=GND}
N 280 19010 280 19020 {
lab=GND}
N 240 18970 280 18970 {
lab=word316}
N 280 18970 320 18970 {
lab=word316}
N 250 18960 250 19010 {
lab=GND}
N 250 19010 250 19020 {
lab=GND}
N 310 18960 310 19010 {
lab=Y3}
N 310 19010 310 19020 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 18990 1 0 {name=M1381
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 18970 360 18970 {
lab=word316}
N 360 18970 400 18970 {
lab=word316}
N 330 18960 330 19010 {
lab=GND}
N 330 19010 330 19020 {
lab=GND}
N 390 18960 390 19010 {
lab=Y4}
N 390 19010 390 19020 {
lab=Y4}

N 410 19020 440 19020 {
lab=GND}
N 440 19010 440 19020 {
lab=GND}
N 400 18970 440 18970 {
lab=word316}
N 440 18970 480 18970 {
lab=word316}
N 410 18960 410 19010 {
lab=GND}
N 410 19010 410 19020 {
lab=GND}
N 470 18960 470 19010 {
lab=Y5}
N 470 19010 470 19020 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 18990 1 0 {name=M1382
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 19020 520 19020 {
lab=GND}
N 520 19010 520 19020 {
lab=GND}
N 480 18970 520 18970 {
lab=word316}
N 520 18970 560 18970 {
lab=word316}
N 490 18960 490 19010 {
lab=GND}
N 490 19010 490 19020 {
lab=GND}
N 550 18960 550 19010 {
lab=Y6}
N 550 19010 550 19020 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 18990 1 0 {name=M1383
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 19020 600 19020 {
lab=GND}
N 600 19010 600 19020 {
lab=GND}
N 560 18970 600 18970 {
lab=word316}
N 600 18970 640 18970 {
lab=word316}
N 570 18960 570 19010 {
lab=GND}
N 570 19010 570 19020 {
lab=GND}
N 630 18960 630 19010 {
lab=Y7}
N 630 19010 630 19020 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 18990 1 0 {name=M1384
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19030 0 0 {name=p340 lab=word317}
N 0 19030 40 19030 {
lab=word317}
N 40 19030 80 19030 {
lab=word317}
N 10 19020 10 19070 {
lab=GND}
N 10 19070 10 19080 {
lab=GND}
N 70 19020 70 19070 {
lab=Y0}
N 70 19070 70 19080 {
lab=Y0}

N 90 19080 120 19080 {
lab=GND}
N 120 19070 120 19080 {
lab=GND}
N 80 19030 120 19030 {
lab=word317}
N 120 19030 160 19030 {
lab=word317}
N 90 19020 90 19070 {
lab=GND}
N 90 19070 90 19080 {
lab=GND}
N 150 19020 150 19070 {
lab=Y1}
N 150 19070 150 19080 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 19050 1 0 {name=M1385
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 19080 200 19080 {
lab=GND}
N 200 19070 200 19080 {
lab=GND}
N 160 19030 200 19030 {
lab=word317}
N 200 19030 240 19030 {
lab=word317}
N 170 19020 170 19070 {
lab=GND}
N 170 19070 170 19080 {
lab=GND}
N 230 19020 230 19070 {
lab=Y2}
N 230 19070 230 19080 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 19050 1 0 {name=M1386
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 19080 280 19080 {
lab=GND}
N 280 19070 280 19080 {
lab=GND}
N 240 19030 280 19030 {
lab=word317}
N 280 19030 320 19030 {
lab=word317}
N 250 19020 250 19070 {
lab=GND}
N 250 19070 250 19080 {
lab=GND}
N 310 19020 310 19070 {
lab=Y3}
N 310 19070 310 19080 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 19050 1 0 {name=M1387
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 19080 360 19080 {
lab=GND}
N 360 19070 360 19080 {
lab=GND}
N 320 19030 360 19030 {
lab=word317}
N 360 19030 400 19030 {
lab=word317}
N 330 19020 330 19070 {
lab=GND}
N 330 19070 330 19080 {
lab=GND}
N 390 19020 390 19070 {
lab=Y4}
N 390 19070 390 19080 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 19050 1 0 {name=M1388
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 19030 440 19030 {
lab=word317}
N 440 19030 480 19030 {
lab=word317}
N 410 19020 410 19070 {
lab=GND}
N 410 19070 410 19080 {
lab=GND}
N 470 19020 470 19070 {
lab=Y5}
N 470 19070 470 19080 {
lab=Y5}
N 480 19030 520 19030 {
lab=word317}
N 520 19030 560 19030 {
lab=word317}
N 490 19020 490 19070 {
lab=GND}
N 490 19070 490 19080 {
lab=GND}
N 550 19020 550 19070 {
lab=Y6}
N 550 19070 550 19080 {
lab=Y6}

N 570 19080 600 19080 {
lab=GND}
N 600 19070 600 19080 {
lab=GND}
N 560 19030 600 19030 {
lab=word317}
N 600 19030 640 19030 {
lab=word317}
N 570 19020 570 19070 {
lab=GND}
N 570 19070 570 19080 {
lab=GND}
N 630 19020 630 19070 {
lab=Y7}
N 630 19070 630 19080 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19050 1 0 {name=M1389
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19090 0 0 {name=p341 lab=word318}
N 0 19090 40 19090 {
lab=word318}
N 40 19090 80 19090 {
lab=word318}
N 10 19080 10 19130 {
lab=GND}
N 10 19130 10 19140 {
lab=GND}
N 70 19080 70 19130 {
lab=Y0}
N 70 19130 70 19140 {
lab=Y0}

N 90 19140 120 19140 {
lab=GND}
N 120 19130 120 19140 {
lab=GND}
N 80 19090 120 19090 {
lab=word318}
N 120 19090 160 19090 {
lab=word318}
N 90 19080 90 19130 {
lab=GND}
N 90 19130 90 19140 {
lab=GND}
N 150 19080 150 19130 {
lab=Y1}
N 150 19130 150 19140 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 19110 1 0 {name=M1390
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 19140 200 19140 {
lab=GND}
N 200 19130 200 19140 {
lab=GND}
N 160 19090 200 19090 {
lab=word318}
N 200 19090 240 19090 {
lab=word318}
N 170 19080 170 19130 {
lab=GND}
N 170 19130 170 19140 {
lab=GND}
N 230 19080 230 19130 {
lab=Y2}
N 230 19130 230 19140 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 19110 1 0 {name=M1391
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 19140 280 19140 {
lab=GND}
N 280 19130 280 19140 {
lab=GND}
N 240 19090 280 19090 {
lab=word318}
N 280 19090 320 19090 {
lab=word318}
N 250 19080 250 19130 {
lab=GND}
N 250 19130 250 19140 {
lab=GND}
N 310 19080 310 19130 {
lab=Y3}
N 310 19130 310 19140 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 19110 1 0 {name=M1392
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 19140 360 19140 {
lab=GND}
N 360 19130 360 19140 {
lab=GND}
N 320 19090 360 19090 {
lab=word318}
N 360 19090 400 19090 {
lab=word318}
N 330 19080 330 19130 {
lab=GND}
N 330 19130 330 19140 {
lab=GND}
N 390 19080 390 19130 {
lab=Y4}
N 390 19130 390 19140 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 19110 1 0 {name=M1393
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 19090 440 19090 {
lab=word318}
N 440 19090 480 19090 {
lab=word318}
N 410 19080 410 19130 {
lab=GND}
N 410 19130 410 19140 {
lab=GND}
N 470 19080 470 19130 {
lab=Y5}
N 470 19130 470 19140 {
lab=Y5}

N 490 19140 520 19140 {
lab=GND}
N 520 19130 520 19140 {
lab=GND}
N 480 19090 520 19090 {
lab=word318}
N 520 19090 560 19090 {
lab=word318}
N 490 19080 490 19130 {
lab=GND}
N 490 19130 490 19140 {
lab=GND}
N 550 19080 550 19130 {
lab=Y6}
N 550 19130 550 19140 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 19110 1 0 {name=M1394
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 19140 600 19140 {
lab=GND}
N 600 19130 600 19140 {
lab=GND}
N 560 19090 600 19090 {
lab=word318}
N 600 19090 640 19090 {
lab=word318}
N 570 19080 570 19130 {
lab=GND}
N 570 19130 570 19140 {
lab=GND}
N 630 19080 630 19130 {
lab=Y7}
N 630 19130 630 19140 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19110 1 0 {name=M1395
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19150 0 0 {name=p342 lab=word319}
N 0 19150 40 19150 {
lab=word319}
N 40 19150 80 19150 {
lab=word319}
N 10 19140 10 19190 {
lab=GND}
N 10 19190 10 19200 {
lab=GND}
N 70 19140 70 19190 {
lab=Y0}
N 70 19190 70 19200 {
lab=Y0}

N 90 19200 120 19200 {
lab=GND}
N 120 19190 120 19200 {
lab=GND}
N 80 19150 120 19150 {
lab=word319}
N 120 19150 160 19150 {
lab=word319}
N 90 19140 90 19190 {
lab=GND}
N 90 19190 90 19200 {
lab=GND}
N 150 19140 150 19190 {
lab=Y1}
N 150 19190 150 19200 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 19170 1 0 {name=M1396
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 19200 200 19200 {
lab=GND}
N 200 19190 200 19200 {
lab=GND}
N 160 19150 200 19150 {
lab=word319}
N 200 19150 240 19150 {
lab=word319}
N 170 19140 170 19190 {
lab=GND}
N 170 19190 170 19200 {
lab=GND}
N 230 19140 230 19190 {
lab=Y2}
N 230 19190 230 19200 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 19170 1 0 {name=M1397
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 19200 280 19200 {
lab=GND}
N 280 19190 280 19200 {
lab=GND}
N 240 19150 280 19150 {
lab=word319}
N 280 19150 320 19150 {
lab=word319}
N 250 19140 250 19190 {
lab=GND}
N 250 19190 250 19200 {
lab=GND}
N 310 19140 310 19190 {
lab=Y3}
N 310 19190 310 19200 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 19170 1 0 {name=M1398
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 19200 360 19200 {
lab=GND}
N 360 19190 360 19200 {
lab=GND}
N 320 19150 360 19150 {
lab=word319}
N 360 19150 400 19150 {
lab=word319}
N 330 19140 330 19190 {
lab=GND}
N 330 19190 330 19200 {
lab=GND}
N 390 19140 390 19190 {
lab=Y4}
N 390 19190 390 19200 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 19170 1 0 {name=M1399
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 19200 440 19200 {
lab=GND}
N 440 19190 440 19200 {
lab=GND}
N 400 19150 440 19150 {
lab=word319}
N 440 19150 480 19150 {
lab=word319}
N 410 19140 410 19190 {
lab=GND}
N 410 19190 410 19200 {
lab=GND}
N 470 19140 470 19190 {
lab=Y5}
N 470 19190 470 19200 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 19170 1 0 {name=M1400
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 19150 520 19150 {
lab=word319}
N 520 19150 560 19150 {
lab=word319}
N 490 19140 490 19190 {
lab=GND}
N 490 19190 490 19200 {
lab=GND}
N 550 19140 550 19190 {
lab=Y6}
N 550 19190 550 19200 {
lab=Y6}

N 570 19200 600 19200 {
lab=GND}
N 600 19190 600 19200 {
lab=GND}
N 560 19150 600 19150 {
lab=word319}
N 600 19150 640 19150 {
lab=word319}
N 570 19140 570 19190 {
lab=GND}
N 570 19190 570 19200 {
lab=GND}
N 630 19140 630 19190 {
lab=Y7}
N 630 19190 630 19200 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19170 1 0 {name=M1401
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19210 0 0 {name=p343 lab=word320}
N 0 19210 40 19210 {
lab=word320}
N 40 19210 80 19210 {
lab=word320}
N 10 19200 10 19250 {
lab=GND}
N 10 19250 10 19260 {
lab=GND}
N 70 19200 70 19250 {
lab=Y0}
N 70 19250 70 19260 {
lab=Y0}

N 90 19260 120 19260 {
lab=GND}
N 120 19250 120 19260 {
lab=GND}
N 80 19210 120 19210 {
lab=word320}
N 120 19210 160 19210 {
lab=word320}
N 90 19200 90 19250 {
lab=GND}
N 90 19250 90 19260 {
lab=GND}
N 150 19200 150 19250 {
lab=Y1}
N 150 19250 150 19260 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 19230 1 0 {name=M1402
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 19260 200 19260 {
lab=GND}
N 200 19250 200 19260 {
lab=GND}
N 160 19210 200 19210 {
lab=word320}
N 200 19210 240 19210 {
lab=word320}
N 170 19200 170 19250 {
lab=GND}
N 170 19250 170 19260 {
lab=GND}
N 230 19200 230 19250 {
lab=Y2}
N 230 19250 230 19260 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 19230 1 0 {name=M1403
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 19260 280 19260 {
lab=GND}
N 280 19250 280 19260 {
lab=GND}
N 240 19210 280 19210 {
lab=word320}
N 280 19210 320 19210 {
lab=word320}
N 250 19200 250 19250 {
lab=GND}
N 250 19250 250 19260 {
lab=GND}
N 310 19200 310 19250 {
lab=Y3}
N 310 19250 310 19260 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 19230 1 0 {name=M1404
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 19260 360 19260 {
lab=GND}
N 360 19250 360 19260 {
lab=GND}
N 320 19210 360 19210 {
lab=word320}
N 360 19210 400 19210 {
lab=word320}
N 330 19200 330 19250 {
lab=GND}
N 330 19250 330 19260 {
lab=GND}
N 390 19200 390 19250 {
lab=Y4}
N 390 19250 390 19260 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 19230 1 0 {name=M1405
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 19260 440 19260 {
lab=GND}
N 440 19250 440 19260 {
lab=GND}
N 400 19210 440 19210 {
lab=word320}
N 440 19210 480 19210 {
lab=word320}
N 410 19200 410 19250 {
lab=GND}
N 410 19250 410 19260 {
lab=GND}
N 470 19200 470 19250 {
lab=Y5}
N 470 19250 470 19260 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 19230 1 0 {name=M1406
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 19260 520 19260 {
lab=GND}
N 520 19250 520 19260 {
lab=GND}
N 480 19210 520 19210 {
lab=word320}
N 520 19210 560 19210 {
lab=word320}
N 490 19200 490 19250 {
lab=GND}
N 490 19250 490 19260 {
lab=GND}
N 550 19200 550 19250 {
lab=Y6}
N 550 19250 550 19260 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 19230 1 0 {name=M1407
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 19260 600 19260 {
lab=GND}
N 600 19250 600 19260 {
lab=GND}
N 560 19210 600 19210 {
lab=word320}
N 600 19210 640 19210 {
lab=word320}
N 570 19200 570 19250 {
lab=GND}
N 570 19250 570 19260 {
lab=GND}
N 630 19200 630 19250 {
lab=Y7}
N 630 19250 630 19260 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19230 1 0 {name=M1408
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19270 0 0 {name=p344 lab=word321}

N 10 19320 40 19320 {
lab=GND}
N 40 19310 40 19320 {
lab=GND}
N 0 19270 40 19270 {
lab=word321}
N 40 19270 80 19270 {
lab=word321}
N 10 19260 10 19310 {
lab=GND}
N 10 19310 10 19320 {
lab=GND}
N 70 19260 70 19310 {
lab=Y0}
N 70 19310 70 19320 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 19290 1 0 {name=M1409
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19270 120 19270 {
lab=word321}
N 120 19270 160 19270 {
lab=word321}
N 90 19260 90 19310 {
lab=GND}
N 90 19310 90 19320 {
lab=GND}
N 150 19260 150 19310 {
lab=Y1}
N 150 19310 150 19320 {
lab=Y1}
N 160 19270 200 19270 {
lab=word321}
N 200 19270 240 19270 {
lab=word321}
N 170 19260 170 19310 {
lab=GND}
N 170 19310 170 19320 {
lab=GND}
N 230 19260 230 19310 {
lab=Y2}
N 230 19310 230 19320 {
lab=Y2}
N 240 19270 280 19270 {
lab=word321}
N 280 19270 320 19270 {
lab=word321}
N 250 19260 250 19310 {
lab=GND}
N 250 19310 250 19320 {
lab=GND}
N 310 19260 310 19310 {
lab=Y3}
N 310 19310 310 19320 {
lab=Y3}
N 320 19270 360 19270 {
lab=word321}
N 360 19270 400 19270 {
lab=word321}
N 330 19260 330 19310 {
lab=GND}
N 330 19310 330 19320 {
lab=GND}
N 390 19260 390 19310 {
lab=Y4}
N 390 19310 390 19320 {
lab=Y4}
N 400 19270 440 19270 {
lab=word321}
N 440 19270 480 19270 {
lab=word321}
N 410 19260 410 19310 {
lab=GND}
N 410 19310 410 19320 {
lab=GND}
N 470 19260 470 19310 {
lab=Y5}
N 470 19310 470 19320 {
lab=Y5}
N 480 19270 520 19270 {
lab=word321}
N 520 19270 560 19270 {
lab=word321}
N 490 19260 490 19310 {
lab=GND}
N 490 19310 490 19320 {
lab=GND}
N 550 19260 550 19310 {
lab=Y6}
N 550 19310 550 19320 {
lab=Y6}

N 570 19320 600 19320 {
lab=GND}
N 600 19310 600 19320 {
lab=GND}
N 560 19270 600 19270 {
lab=word321}
N 600 19270 640 19270 {
lab=word321}
N 570 19260 570 19310 {
lab=GND}
N 570 19310 570 19320 {
lab=GND}
N 630 19260 630 19310 {
lab=Y7}
N 630 19310 630 19320 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19290 1 0 {name=M1410
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19330 0 0 {name=p345 lab=word322}

N 10 19380 40 19380 {
lab=GND}
N 40 19370 40 19380 {
lab=GND}
N 0 19330 40 19330 {
lab=word322}
N 40 19330 80 19330 {
lab=word322}
N 10 19320 10 19370 {
lab=GND}
N 10 19370 10 19380 {
lab=GND}
N 70 19320 70 19370 {
lab=Y0}
N 70 19370 70 19380 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 19350 1 0 {name=M1411
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19330 120 19330 {
lab=word322}
N 120 19330 160 19330 {
lab=word322}
N 90 19320 90 19370 {
lab=GND}
N 90 19370 90 19380 {
lab=GND}
N 150 19320 150 19370 {
lab=Y1}
N 150 19370 150 19380 {
lab=Y1}
N 160 19330 200 19330 {
lab=word322}
N 200 19330 240 19330 {
lab=word322}
N 170 19320 170 19370 {
lab=GND}
N 170 19370 170 19380 {
lab=GND}
N 230 19320 230 19370 {
lab=Y2}
N 230 19370 230 19380 {
lab=Y2}
N 240 19330 280 19330 {
lab=word322}
N 280 19330 320 19330 {
lab=word322}
N 250 19320 250 19370 {
lab=GND}
N 250 19370 250 19380 {
lab=GND}
N 310 19320 310 19370 {
lab=Y3}
N 310 19370 310 19380 {
lab=Y3}
N 320 19330 360 19330 {
lab=word322}
N 360 19330 400 19330 {
lab=word322}
N 330 19320 330 19370 {
lab=GND}
N 330 19370 330 19380 {
lab=GND}
N 390 19320 390 19370 {
lab=Y4}
N 390 19370 390 19380 {
lab=Y4}
N 400 19330 440 19330 {
lab=word322}
N 440 19330 480 19330 {
lab=word322}
N 410 19320 410 19370 {
lab=GND}
N 410 19370 410 19380 {
lab=GND}
N 470 19320 470 19370 {
lab=Y5}
N 470 19370 470 19380 {
lab=Y5}

N 490 19380 520 19380 {
lab=GND}
N 520 19370 520 19380 {
lab=GND}
N 480 19330 520 19330 {
lab=word322}
N 520 19330 560 19330 {
lab=word322}
N 490 19320 490 19370 {
lab=GND}
N 490 19370 490 19380 {
lab=GND}
N 550 19320 550 19370 {
lab=Y6}
N 550 19370 550 19380 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 19350 1 0 {name=M1412
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 19380 600 19380 {
lab=GND}
N 600 19370 600 19380 {
lab=GND}
N 560 19330 600 19330 {
lab=word322}
N 600 19330 640 19330 {
lab=word322}
N 570 19320 570 19370 {
lab=GND}
N 570 19370 570 19380 {
lab=GND}
N 630 19320 630 19370 {
lab=Y7}
N 630 19370 630 19380 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19350 1 0 {name=M1413
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19390 0 0 {name=p346 lab=word323}

N 10 19440 40 19440 {
lab=GND}
N 40 19430 40 19440 {
lab=GND}
N 0 19390 40 19390 {
lab=word323}
N 40 19390 80 19390 {
lab=word323}
N 10 19380 10 19430 {
lab=GND}
N 10 19430 10 19440 {
lab=GND}
N 70 19380 70 19430 {
lab=Y0}
N 70 19430 70 19440 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 19410 1 0 {name=M1414
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19390 120 19390 {
lab=word323}
N 120 19390 160 19390 {
lab=word323}
N 90 19380 90 19430 {
lab=GND}
N 90 19430 90 19440 {
lab=GND}
N 150 19380 150 19430 {
lab=Y1}
N 150 19430 150 19440 {
lab=Y1}
N 160 19390 200 19390 {
lab=word323}
N 200 19390 240 19390 {
lab=word323}
N 170 19380 170 19430 {
lab=GND}
N 170 19430 170 19440 {
lab=GND}
N 230 19380 230 19430 {
lab=Y2}
N 230 19430 230 19440 {
lab=Y2}
N 240 19390 280 19390 {
lab=word323}
N 280 19390 320 19390 {
lab=word323}
N 250 19380 250 19430 {
lab=GND}
N 250 19430 250 19440 {
lab=GND}
N 310 19380 310 19430 {
lab=Y3}
N 310 19430 310 19440 {
lab=Y3}
N 320 19390 360 19390 {
lab=word323}
N 360 19390 400 19390 {
lab=word323}
N 330 19380 330 19430 {
lab=GND}
N 330 19430 330 19440 {
lab=GND}
N 390 19380 390 19430 {
lab=Y4}
N 390 19430 390 19440 {
lab=Y4}

N 410 19440 440 19440 {
lab=GND}
N 440 19430 440 19440 {
lab=GND}
N 400 19390 440 19390 {
lab=word323}
N 440 19390 480 19390 {
lab=word323}
N 410 19380 410 19430 {
lab=GND}
N 410 19430 410 19440 {
lab=GND}
N 470 19380 470 19430 {
lab=Y5}
N 470 19430 470 19440 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 19410 1 0 {name=M1415
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 19390 520 19390 {
lab=word323}
N 520 19390 560 19390 {
lab=word323}
N 490 19380 490 19430 {
lab=GND}
N 490 19430 490 19440 {
lab=GND}
N 550 19380 550 19430 {
lab=Y6}
N 550 19430 550 19440 {
lab=Y6}

N 570 19440 600 19440 {
lab=GND}
N 600 19430 600 19440 {
lab=GND}
N 560 19390 600 19390 {
lab=word323}
N 600 19390 640 19390 {
lab=word323}
N 570 19380 570 19430 {
lab=GND}
N 570 19430 570 19440 {
lab=GND}
N 630 19380 630 19430 {
lab=Y7}
N 630 19430 630 19440 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19410 1 0 {name=M1416
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19450 0 0 {name=p347 lab=word324}

N 10 19500 40 19500 {
lab=GND}
N 40 19490 40 19500 {
lab=GND}
N 0 19450 40 19450 {
lab=word324}
N 40 19450 80 19450 {
lab=word324}
N 10 19440 10 19490 {
lab=GND}
N 10 19490 10 19500 {
lab=GND}
N 70 19440 70 19490 {
lab=Y0}
N 70 19490 70 19500 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 19470 1 0 {name=M1417
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19450 120 19450 {
lab=word324}
N 120 19450 160 19450 {
lab=word324}
N 90 19440 90 19490 {
lab=GND}
N 90 19490 90 19500 {
lab=GND}
N 150 19440 150 19490 {
lab=Y1}
N 150 19490 150 19500 {
lab=Y1}
N 160 19450 200 19450 {
lab=word324}
N 200 19450 240 19450 {
lab=word324}
N 170 19440 170 19490 {
lab=GND}
N 170 19490 170 19500 {
lab=GND}
N 230 19440 230 19490 {
lab=Y2}
N 230 19490 230 19500 {
lab=Y2}
N 240 19450 280 19450 {
lab=word324}
N 280 19450 320 19450 {
lab=word324}
N 250 19440 250 19490 {
lab=GND}
N 250 19490 250 19500 {
lab=GND}
N 310 19440 310 19490 {
lab=Y3}
N 310 19490 310 19500 {
lab=Y3}
N 320 19450 360 19450 {
lab=word324}
N 360 19450 400 19450 {
lab=word324}
N 330 19440 330 19490 {
lab=GND}
N 330 19490 330 19500 {
lab=GND}
N 390 19440 390 19490 {
lab=Y4}
N 390 19490 390 19500 {
lab=Y4}

N 410 19500 440 19500 {
lab=GND}
N 440 19490 440 19500 {
lab=GND}
N 400 19450 440 19450 {
lab=word324}
N 440 19450 480 19450 {
lab=word324}
N 410 19440 410 19490 {
lab=GND}
N 410 19490 410 19500 {
lab=GND}
N 470 19440 470 19490 {
lab=Y5}
N 470 19490 470 19500 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 19470 1 0 {name=M1418
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 19500 520 19500 {
lab=GND}
N 520 19490 520 19500 {
lab=GND}
N 480 19450 520 19450 {
lab=word324}
N 520 19450 560 19450 {
lab=word324}
N 490 19440 490 19490 {
lab=GND}
N 490 19490 490 19500 {
lab=GND}
N 550 19440 550 19490 {
lab=Y6}
N 550 19490 550 19500 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 19470 1 0 {name=M1419
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 19500 600 19500 {
lab=GND}
N 600 19490 600 19500 {
lab=GND}
N 560 19450 600 19450 {
lab=word324}
N 600 19450 640 19450 {
lab=word324}
N 570 19440 570 19490 {
lab=GND}
N 570 19490 570 19500 {
lab=GND}
N 630 19440 630 19490 {
lab=Y7}
N 630 19490 630 19500 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19470 1 0 {name=M1420
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19510 0 0 {name=p348 lab=word325}

N 10 19560 40 19560 {
lab=GND}
N 40 19550 40 19560 {
lab=GND}
N 0 19510 40 19510 {
lab=word325}
N 40 19510 80 19510 {
lab=word325}
N 10 19500 10 19550 {
lab=GND}
N 10 19550 10 19560 {
lab=GND}
N 70 19500 70 19550 {
lab=Y0}
N 70 19550 70 19560 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 19530 1 0 {name=M1421
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19510 120 19510 {
lab=word325}
N 120 19510 160 19510 {
lab=word325}
N 90 19500 90 19550 {
lab=GND}
N 90 19550 90 19560 {
lab=GND}
N 150 19500 150 19550 {
lab=Y1}
N 150 19550 150 19560 {
lab=Y1}
N 160 19510 200 19510 {
lab=word325}
N 200 19510 240 19510 {
lab=word325}
N 170 19500 170 19550 {
lab=GND}
N 170 19550 170 19560 {
lab=GND}
N 230 19500 230 19550 {
lab=Y2}
N 230 19550 230 19560 {
lab=Y2}
N 240 19510 280 19510 {
lab=word325}
N 280 19510 320 19510 {
lab=word325}
N 250 19500 250 19550 {
lab=GND}
N 250 19550 250 19560 {
lab=GND}
N 310 19500 310 19550 {
lab=Y3}
N 310 19550 310 19560 {
lab=Y3}

N 330 19560 360 19560 {
lab=GND}
N 360 19550 360 19560 {
lab=GND}
N 320 19510 360 19510 {
lab=word325}
N 360 19510 400 19510 {
lab=word325}
N 330 19500 330 19550 {
lab=GND}
N 330 19550 330 19560 {
lab=GND}
N 390 19500 390 19550 {
lab=Y4}
N 390 19550 390 19560 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 19530 1 0 {name=M1422
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 19510 440 19510 {
lab=word325}
N 440 19510 480 19510 {
lab=word325}
N 410 19500 410 19550 {
lab=GND}
N 410 19550 410 19560 {
lab=GND}
N 470 19500 470 19550 {
lab=Y5}
N 470 19550 470 19560 {
lab=Y5}
N 480 19510 520 19510 {
lab=word325}
N 520 19510 560 19510 {
lab=word325}
N 490 19500 490 19550 {
lab=GND}
N 490 19550 490 19560 {
lab=GND}
N 550 19500 550 19550 {
lab=Y6}
N 550 19550 550 19560 {
lab=Y6}

N 570 19560 600 19560 {
lab=GND}
N 600 19550 600 19560 {
lab=GND}
N 560 19510 600 19510 {
lab=word325}
N 600 19510 640 19510 {
lab=word325}
N 570 19500 570 19550 {
lab=GND}
N 570 19550 570 19560 {
lab=GND}
N 630 19500 630 19550 {
lab=Y7}
N 630 19550 630 19560 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19530 1 0 {name=M1423
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19570 0 0 {name=p349 lab=word326}

N 10 19620 40 19620 {
lab=GND}
N 40 19610 40 19620 {
lab=GND}
N 0 19570 40 19570 {
lab=word326}
N 40 19570 80 19570 {
lab=word326}
N 10 19560 10 19610 {
lab=GND}
N 10 19610 10 19620 {
lab=GND}
N 70 19560 70 19610 {
lab=Y0}
N 70 19610 70 19620 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 19590 1 0 {name=M1424
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19570 120 19570 {
lab=word326}
N 120 19570 160 19570 {
lab=word326}
N 90 19560 90 19610 {
lab=GND}
N 90 19610 90 19620 {
lab=GND}
N 150 19560 150 19610 {
lab=Y1}
N 150 19610 150 19620 {
lab=Y1}
N 160 19570 200 19570 {
lab=word326}
N 200 19570 240 19570 {
lab=word326}
N 170 19560 170 19610 {
lab=GND}
N 170 19610 170 19620 {
lab=GND}
N 230 19560 230 19610 {
lab=Y2}
N 230 19610 230 19620 {
lab=Y2}
N 240 19570 280 19570 {
lab=word326}
N 280 19570 320 19570 {
lab=word326}
N 250 19560 250 19610 {
lab=GND}
N 250 19610 250 19620 {
lab=GND}
N 310 19560 310 19610 {
lab=Y3}
N 310 19610 310 19620 {
lab=Y3}

N 330 19620 360 19620 {
lab=GND}
N 360 19610 360 19620 {
lab=GND}
N 320 19570 360 19570 {
lab=word326}
N 360 19570 400 19570 {
lab=word326}
N 330 19560 330 19610 {
lab=GND}
N 330 19610 330 19620 {
lab=GND}
N 390 19560 390 19610 {
lab=Y4}
N 390 19610 390 19620 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 19590 1 0 {name=M1425
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 19570 440 19570 {
lab=word326}
N 440 19570 480 19570 {
lab=word326}
N 410 19560 410 19610 {
lab=GND}
N 410 19610 410 19620 {
lab=GND}
N 470 19560 470 19610 {
lab=Y5}
N 470 19610 470 19620 {
lab=Y5}

N 490 19620 520 19620 {
lab=GND}
N 520 19610 520 19620 {
lab=GND}
N 480 19570 520 19570 {
lab=word326}
N 520 19570 560 19570 {
lab=word326}
N 490 19560 490 19610 {
lab=GND}
N 490 19610 490 19620 {
lab=GND}
N 550 19560 550 19610 {
lab=Y6}
N 550 19610 550 19620 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 19590 1 0 {name=M1426
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 19620 600 19620 {
lab=GND}
N 600 19610 600 19620 {
lab=GND}
N 560 19570 600 19570 {
lab=word326}
N 600 19570 640 19570 {
lab=word326}
N 570 19560 570 19610 {
lab=GND}
N 570 19610 570 19620 {
lab=GND}
N 630 19560 630 19610 {
lab=Y7}
N 630 19610 630 19620 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19590 1 0 {name=M1427
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19630 0 0 {name=p350 lab=word327}

N 10 19680 40 19680 {
lab=GND}
N 40 19670 40 19680 {
lab=GND}
N 0 19630 40 19630 {
lab=word327}
N 40 19630 80 19630 {
lab=word327}
N 10 19620 10 19670 {
lab=GND}
N 10 19670 10 19680 {
lab=GND}
N 70 19620 70 19670 {
lab=Y0}
N 70 19670 70 19680 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 19650 1 0 {name=M1428
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19630 120 19630 {
lab=word327}
N 120 19630 160 19630 {
lab=word327}
N 90 19620 90 19670 {
lab=GND}
N 90 19670 90 19680 {
lab=GND}
N 150 19620 150 19670 {
lab=Y1}
N 150 19670 150 19680 {
lab=Y1}
N 160 19630 200 19630 {
lab=word327}
N 200 19630 240 19630 {
lab=word327}
N 170 19620 170 19670 {
lab=GND}
N 170 19670 170 19680 {
lab=GND}
N 230 19620 230 19670 {
lab=Y2}
N 230 19670 230 19680 {
lab=Y2}
N 240 19630 280 19630 {
lab=word327}
N 280 19630 320 19630 {
lab=word327}
N 250 19620 250 19670 {
lab=GND}
N 250 19670 250 19680 {
lab=GND}
N 310 19620 310 19670 {
lab=Y3}
N 310 19670 310 19680 {
lab=Y3}

N 330 19680 360 19680 {
lab=GND}
N 360 19670 360 19680 {
lab=GND}
N 320 19630 360 19630 {
lab=word327}
N 360 19630 400 19630 {
lab=word327}
N 330 19620 330 19670 {
lab=GND}
N 330 19670 330 19680 {
lab=GND}
N 390 19620 390 19670 {
lab=Y4}
N 390 19670 390 19680 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 19650 1 0 {name=M1429
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 19680 440 19680 {
lab=GND}
N 440 19670 440 19680 {
lab=GND}
N 400 19630 440 19630 {
lab=word327}
N 440 19630 480 19630 {
lab=word327}
N 410 19620 410 19670 {
lab=GND}
N 410 19670 410 19680 {
lab=GND}
N 470 19620 470 19670 {
lab=Y5}
N 470 19670 470 19680 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 19650 1 0 {name=M1430
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 19630 520 19630 {
lab=word327}
N 520 19630 560 19630 {
lab=word327}
N 490 19620 490 19670 {
lab=GND}
N 490 19670 490 19680 {
lab=GND}
N 550 19620 550 19670 {
lab=Y6}
N 550 19670 550 19680 {
lab=Y6}

N 570 19680 600 19680 {
lab=GND}
N 600 19670 600 19680 {
lab=GND}
N 560 19630 600 19630 {
lab=word327}
N 600 19630 640 19630 {
lab=word327}
N 570 19620 570 19670 {
lab=GND}
N 570 19670 570 19680 {
lab=GND}
N 630 19620 630 19670 {
lab=Y7}
N 630 19670 630 19680 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19650 1 0 {name=M1431
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19690 0 0 {name=p351 lab=word328}

N 10 19740 40 19740 {
lab=GND}
N 40 19730 40 19740 {
lab=GND}
N 0 19690 40 19690 {
lab=word328}
N 40 19690 80 19690 {
lab=word328}
N 10 19680 10 19730 {
lab=GND}
N 10 19730 10 19740 {
lab=GND}
N 70 19680 70 19730 {
lab=Y0}
N 70 19730 70 19740 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 19710 1 0 {name=M1432
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19690 120 19690 {
lab=word328}
N 120 19690 160 19690 {
lab=word328}
N 90 19680 90 19730 {
lab=GND}
N 90 19730 90 19740 {
lab=GND}
N 150 19680 150 19730 {
lab=Y1}
N 150 19730 150 19740 {
lab=Y1}
N 160 19690 200 19690 {
lab=word328}
N 200 19690 240 19690 {
lab=word328}
N 170 19680 170 19730 {
lab=GND}
N 170 19730 170 19740 {
lab=GND}
N 230 19680 230 19730 {
lab=Y2}
N 230 19730 230 19740 {
lab=Y2}
N 240 19690 280 19690 {
lab=word328}
N 280 19690 320 19690 {
lab=word328}
N 250 19680 250 19730 {
lab=GND}
N 250 19730 250 19740 {
lab=GND}
N 310 19680 310 19730 {
lab=Y3}
N 310 19730 310 19740 {
lab=Y3}

N 330 19740 360 19740 {
lab=GND}
N 360 19730 360 19740 {
lab=GND}
N 320 19690 360 19690 {
lab=word328}
N 360 19690 400 19690 {
lab=word328}
N 330 19680 330 19730 {
lab=GND}
N 330 19730 330 19740 {
lab=GND}
N 390 19680 390 19730 {
lab=Y4}
N 390 19730 390 19740 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 19710 1 0 {name=M1433
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 19740 440 19740 {
lab=GND}
N 440 19730 440 19740 {
lab=GND}
N 400 19690 440 19690 {
lab=word328}
N 440 19690 480 19690 {
lab=word328}
N 410 19680 410 19730 {
lab=GND}
N 410 19730 410 19740 {
lab=GND}
N 470 19680 470 19730 {
lab=Y5}
N 470 19730 470 19740 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 19710 1 0 {name=M1434
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 19740 520 19740 {
lab=GND}
N 520 19730 520 19740 {
lab=GND}
N 480 19690 520 19690 {
lab=word328}
N 520 19690 560 19690 {
lab=word328}
N 490 19680 490 19730 {
lab=GND}
N 490 19730 490 19740 {
lab=GND}
N 550 19680 550 19730 {
lab=Y6}
N 550 19730 550 19740 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 19710 1 0 {name=M1435
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 19740 600 19740 {
lab=GND}
N 600 19730 600 19740 {
lab=GND}
N 560 19690 600 19690 {
lab=word328}
N 600 19690 640 19690 {
lab=word328}
N 570 19680 570 19730 {
lab=GND}
N 570 19730 570 19740 {
lab=GND}
N 630 19680 630 19730 {
lab=Y7}
N 630 19730 630 19740 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19710 1 0 {name=M1436
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19750 0 0 {name=p352 lab=word329}

N 10 19800 40 19800 {
lab=GND}
N 40 19790 40 19800 {
lab=GND}
N 0 19750 40 19750 {
lab=word329}
N 40 19750 80 19750 {
lab=word329}
N 10 19740 10 19790 {
lab=GND}
N 10 19790 10 19800 {
lab=GND}
N 70 19740 70 19790 {
lab=Y0}
N 70 19790 70 19800 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 19770 1 0 {name=M1437
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19750 120 19750 {
lab=word329}
N 120 19750 160 19750 {
lab=word329}
N 90 19740 90 19790 {
lab=GND}
N 90 19790 90 19800 {
lab=GND}
N 150 19740 150 19790 {
lab=Y1}
N 150 19790 150 19800 {
lab=Y1}
N 160 19750 200 19750 {
lab=word329}
N 200 19750 240 19750 {
lab=word329}
N 170 19740 170 19790 {
lab=GND}
N 170 19790 170 19800 {
lab=GND}
N 230 19740 230 19790 {
lab=Y2}
N 230 19790 230 19800 {
lab=Y2}

N 250 19800 280 19800 {
lab=GND}
N 280 19790 280 19800 {
lab=GND}
N 240 19750 280 19750 {
lab=word329}
N 280 19750 320 19750 {
lab=word329}
N 250 19740 250 19790 {
lab=GND}
N 250 19790 250 19800 {
lab=GND}
N 310 19740 310 19790 {
lab=Y3}
N 310 19790 310 19800 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 19770 1 0 {name=M1438
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 19750 360 19750 {
lab=word329}
N 360 19750 400 19750 {
lab=word329}
N 330 19740 330 19790 {
lab=GND}
N 330 19790 330 19800 {
lab=GND}
N 390 19740 390 19790 {
lab=Y4}
N 390 19790 390 19800 {
lab=Y4}
N 400 19750 440 19750 {
lab=word329}
N 440 19750 480 19750 {
lab=word329}
N 410 19740 410 19790 {
lab=GND}
N 410 19790 410 19800 {
lab=GND}
N 470 19740 470 19790 {
lab=Y5}
N 470 19790 470 19800 {
lab=Y5}
N 480 19750 520 19750 {
lab=word329}
N 520 19750 560 19750 {
lab=word329}
N 490 19740 490 19790 {
lab=GND}
N 490 19790 490 19800 {
lab=GND}
N 550 19740 550 19790 {
lab=Y6}
N 550 19790 550 19800 {
lab=Y6}

N 570 19800 600 19800 {
lab=GND}
N 600 19790 600 19800 {
lab=GND}
N 560 19750 600 19750 {
lab=word329}
N 600 19750 640 19750 {
lab=word329}
N 570 19740 570 19790 {
lab=GND}
N 570 19790 570 19800 {
lab=GND}
N 630 19740 630 19790 {
lab=Y7}
N 630 19790 630 19800 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19770 1 0 {name=M1439
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19810 0 0 {name=p353 lab=word330}

N 10 19860 40 19860 {
lab=GND}
N 40 19850 40 19860 {
lab=GND}
N 0 19810 40 19810 {
lab=word330}
N 40 19810 80 19810 {
lab=word330}
N 10 19800 10 19850 {
lab=GND}
N 10 19850 10 19860 {
lab=GND}
N 70 19800 70 19850 {
lab=Y0}
N 70 19850 70 19860 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 19830 1 0 {name=M1440
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19810 120 19810 {
lab=word330}
N 120 19810 160 19810 {
lab=word330}
N 90 19800 90 19850 {
lab=GND}
N 90 19850 90 19860 {
lab=GND}
N 150 19800 150 19850 {
lab=Y1}
N 150 19850 150 19860 {
lab=Y1}
N 160 19810 200 19810 {
lab=word330}
N 200 19810 240 19810 {
lab=word330}
N 170 19800 170 19850 {
lab=GND}
N 170 19850 170 19860 {
lab=GND}
N 230 19800 230 19850 {
lab=Y2}
N 230 19850 230 19860 {
lab=Y2}

N 250 19860 280 19860 {
lab=GND}
N 280 19850 280 19860 {
lab=GND}
N 240 19810 280 19810 {
lab=word330}
N 280 19810 320 19810 {
lab=word330}
N 250 19800 250 19850 {
lab=GND}
N 250 19850 250 19860 {
lab=GND}
N 310 19800 310 19850 {
lab=Y3}
N 310 19850 310 19860 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 19830 1 0 {name=M1441
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 19810 360 19810 {
lab=word330}
N 360 19810 400 19810 {
lab=word330}
N 330 19800 330 19850 {
lab=GND}
N 330 19850 330 19860 {
lab=GND}
N 390 19800 390 19850 {
lab=Y4}
N 390 19850 390 19860 {
lab=Y4}
N 400 19810 440 19810 {
lab=word330}
N 440 19810 480 19810 {
lab=word330}
N 410 19800 410 19850 {
lab=GND}
N 410 19850 410 19860 {
lab=GND}
N 470 19800 470 19850 {
lab=Y5}
N 470 19850 470 19860 {
lab=Y5}

N 490 19860 520 19860 {
lab=GND}
N 520 19850 520 19860 {
lab=GND}
N 480 19810 520 19810 {
lab=word330}
N 520 19810 560 19810 {
lab=word330}
N 490 19800 490 19850 {
lab=GND}
N 490 19850 490 19860 {
lab=GND}
N 550 19800 550 19850 {
lab=Y6}
N 550 19850 550 19860 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 19830 1 0 {name=M1442
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 19860 600 19860 {
lab=GND}
N 600 19850 600 19860 {
lab=GND}
N 560 19810 600 19810 {
lab=word330}
N 600 19810 640 19810 {
lab=word330}
N 570 19800 570 19850 {
lab=GND}
N 570 19850 570 19860 {
lab=GND}
N 630 19800 630 19850 {
lab=Y7}
N 630 19850 630 19860 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19830 1 0 {name=M1443
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19870 0 0 {name=p354 lab=word331}

N 10 19920 40 19920 {
lab=GND}
N 40 19910 40 19920 {
lab=GND}
N 0 19870 40 19870 {
lab=word331}
N 40 19870 80 19870 {
lab=word331}
N 10 19860 10 19910 {
lab=GND}
N 10 19910 10 19920 {
lab=GND}
N 70 19860 70 19910 {
lab=Y0}
N 70 19910 70 19920 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 19890 1 0 {name=M1444
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19870 120 19870 {
lab=word331}
N 120 19870 160 19870 {
lab=word331}
N 90 19860 90 19910 {
lab=GND}
N 90 19910 90 19920 {
lab=GND}
N 150 19860 150 19910 {
lab=Y1}
N 150 19910 150 19920 {
lab=Y1}
N 160 19870 200 19870 {
lab=word331}
N 200 19870 240 19870 {
lab=word331}
N 170 19860 170 19910 {
lab=GND}
N 170 19910 170 19920 {
lab=GND}
N 230 19860 230 19910 {
lab=Y2}
N 230 19910 230 19920 {
lab=Y2}

N 250 19920 280 19920 {
lab=GND}
N 280 19910 280 19920 {
lab=GND}
N 240 19870 280 19870 {
lab=word331}
N 280 19870 320 19870 {
lab=word331}
N 250 19860 250 19910 {
lab=GND}
N 250 19910 250 19920 {
lab=GND}
N 310 19860 310 19910 {
lab=Y3}
N 310 19910 310 19920 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 19890 1 0 {name=M1445
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 19870 360 19870 {
lab=word331}
N 360 19870 400 19870 {
lab=word331}
N 330 19860 330 19910 {
lab=GND}
N 330 19910 330 19920 {
lab=GND}
N 390 19860 390 19910 {
lab=Y4}
N 390 19910 390 19920 {
lab=Y4}

N 410 19920 440 19920 {
lab=GND}
N 440 19910 440 19920 {
lab=GND}
N 400 19870 440 19870 {
lab=word331}
N 440 19870 480 19870 {
lab=word331}
N 410 19860 410 19910 {
lab=GND}
N 410 19910 410 19920 {
lab=GND}
N 470 19860 470 19910 {
lab=Y5}
N 470 19910 470 19920 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 19890 1 0 {name=M1446
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 19870 520 19870 {
lab=word331}
N 520 19870 560 19870 {
lab=word331}
N 490 19860 490 19910 {
lab=GND}
N 490 19910 490 19920 {
lab=GND}
N 550 19860 550 19910 {
lab=Y6}
N 550 19910 550 19920 {
lab=Y6}

N 570 19920 600 19920 {
lab=GND}
N 600 19910 600 19920 {
lab=GND}
N 560 19870 600 19870 {
lab=word331}
N 600 19870 640 19870 {
lab=word331}
N 570 19860 570 19910 {
lab=GND}
N 570 19910 570 19920 {
lab=GND}
N 630 19860 630 19910 {
lab=Y7}
N 630 19910 630 19920 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19890 1 0 {name=M1447
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19930 0 0 {name=p355 lab=word332}

N 10 19980 40 19980 {
lab=GND}
N 40 19970 40 19980 {
lab=GND}
N 0 19930 40 19930 {
lab=word332}
N 40 19930 80 19930 {
lab=word332}
N 10 19920 10 19970 {
lab=GND}
N 10 19970 10 19980 {
lab=GND}
N 70 19920 70 19970 {
lab=Y0}
N 70 19970 70 19980 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 19950 1 0 {name=M1448
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19930 120 19930 {
lab=word332}
N 120 19930 160 19930 {
lab=word332}
N 90 19920 90 19970 {
lab=GND}
N 90 19970 90 19980 {
lab=GND}
N 150 19920 150 19970 {
lab=Y1}
N 150 19970 150 19980 {
lab=Y1}
N 160 19930 200 19930 {
lab=word332}
N 200 19930 240 19930 {
lab=word332}
N 170 19920 170 19970 {
lab=GND}
N 170 19970 170 19980 {
lab=GND}
N 230 19920 230 19970 {
lab=Y2}
N 230 19970 230 19980 {
lab=Y2}

N 250 19980 280 19980 {
lab=GND}
N 280 19970 280 19980 {
lab=GND}
N 240 19930 280 19930 {
lab=word332}
N 280 19930 320 19930 {
lab=word332}
N 250 19920 250 19970 {
lab=GND}
N 250 19970 250 19980 {
lab=GND}
N 310 19920 310 19970 {
lab=Y3}
N 310 19970 310 19980 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 19950 1 0 {name=M1449
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 19930 360 19930 {
lab=word332}
N 360 19930 400 19930 {
lab=word332}
N 330 19920 330 19970 {
lab=GND}
N 330 19970 330 19980 {
lab=GND}
N 390 19920 390 19970 {
lab=Y4}
N 390 19970 390 19980 {
lab=Y4}

N 410 19980 440 19980 {
lab=GND}
N 440 19970 440 19980 {
lab=GND}
N 400 19930 440 19930 {
lab=word332}
N 440 19930 480 19930 {
lab=word332}
N 410 19920 410 19970 {
lab=GND}
N 410 19970 410 19980 {
lab=GND}
N 470 19920 470 19970 {
lab=Y5}
N 470 19970 470 19980 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 19950 1 0 {name=M1450
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 19980 520 19980 {
lab=GND}
N 520 19970 520 19980 {
lab=GND}
N 480 19930 520 19930 {
lab=word332}
N 520 19930 560 19930 {
lab=word332}
N 490 19920 490 19970 {
lab=GND}
N 490 19970 490 19980 {
lab=GND}
N 550 19920 550 19970 {
lab=Y6}
N 550 19970 550 19980 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 19950 1 0 {name=M1451
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 19980 600 19980 {
lab=GND}
N 600 19970 600 19980 {
lab=GND}
N 560 19930 600 19930 {
lab=word332}
N 600 19930 640 19930 {
lab=word332}
N 570 19920 570 19970 {
lab=GND}
N 570 19970 570 19980 {
lab=GND}
N 630 19920 630 19970 {
lab=Y7}
N 630 19970 630 19980 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 19950 1 0 {name=M1452
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 19990 0 0 {name=p356 lab=word333}

N 10 20040 40 20040 {
lab=GND}
N 40 20030 40 20040 {
lab=GND}
N 0 19990 40 19990 {
lab=word333}
N 40 19990 80 19990 {
lab=word333}
N 10 19980 10 20030 {
lab=GND}
N 10 20030 10 20040 {
lab=GND}
N 70 19980 70 20030 {
lab=Y0}
N 70 20030 70 20040 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20010 1 0 {name=M1453
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 19990 120 19990 {
lab=word333}
N 120 19990 160 19990 {
lab=word333}
N 90 19980 90 20030 {
lab=GND}
N 90 20030 90 20040 {
lab=GND}
N 150 19980 150 20030 {
lab=Y1}
N 150 20030 150 20040 {
lab=Y1}
N 160 19990 200 19990 {
lab=word333}
N 200 19990 240 19990 {
lab=word333}
N 170 19980 170 20030 {
lab=GND}
N 170 20030 170 20040 {
lab=GND}
N 230 19980 230 20030 {
lab=Y2}
N 230 20030 230 20040 {
lab=Y2}

N 250 20040 280 20040 {
lab=GND}
N 280 20030 280 20040 {
lab=GND}
N 240 19990 280 19990 {
lab=word333}
N 280 19990 320 19990 {
lab=word333}
N 250 19980 250 20030 {
lab=GND}
N 250 20030 250 20040 {
lab=GND}
N 310 19980 310 20030 {
lab=Y3}
N 310 20030 310 20040 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 20010 1 0 {name=M1454
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 20040 360 20040 {
lab=GND}
N 360 20030 360 20040 {
lab=GND}
N 320 19990 360 19990 {
lab=word333}
N 360 19990 400 19990 {
lab=word333}
N 330 19980 330 20030 {
lab=GND}
N 330 20030 330 20040 {
lab=GND}
N 390 19980 390 20030 {
lab=Y4}
N 390 20030 390 20040 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 20010 1 0 {name=M1455
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 19990 440 19990 {
lab=word333}
N 440 19990 480 19990 {
lab=word333}
N 410 19980 410 20030 {
lab=GND}
N 410 20030 410 20040 {
lab=GND}
N 470 19980 470 20030 {
lab=Y5}
N 470 20030 470 20040 {
lab=Y5}
N 480 19990 520 19990 {
lab=word333}
N 520 19990 560 19990 {
lab=word333}
N 490 19980 490 20030 {
lab=GND}
N 490 20030 490 20040 {
lab=GND}
N 550 19980 550 20030 {
lab=Y6}
N 550 20030 550 20040 {
lab=Y6}

N 570 20040 600 20040 {
lab=GND}
N 600 20030 600 20040 {
lab=GND}
N 560 19990 600 19990 {
lab=word333}
N 600 19990 640 19990 {
lab=word333}
N 570 19980 570 20030 {
lab=GND}
N 570 20030 570 20040 {
lab=GND}
N 630 19980 630 20030 {
lab=Y7}
N 630 20030 630 20040 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20010 1 0 {name=M1456
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20050 0 0 {name=p357 lab=word334}

N 10 20100 40 20100 {
lab=GND}
N 40 20090 40 20100 {
lab=GND}
N 0 20050 40 20050 {
lab=word334}
N 40 20050 80 20050 {
lab=word334}
N 10 20040 10 20090 {
lab=GND}
N 10 20090 10 20100 {
lab=GND}
N 70 20040 70 20090 {
lab=Y0}
N 70 20090 70 20100 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20070 1 0 {name=M1457
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20050 120 20050 {
lab=word334}
N 120 20050 160 20050 {
lab=word334}
N 90 20040 90 20090 {
lab=GND}
N 90 20090 90 20100 {
lab=GND}
N 150 20040 150 20090 {
lab=Y1}
N 150 20090 150 20100 {
lab=Y1}
N 160 20050 200 20050 {
lab=word334}
N 200 20050 240 20050 {
lab=word334}
N 170 20040 170 20090 {
lab=GND}
N 170 20090 170 20100 {
lab=GND}
N 230 20040 230 20090 {
lab=Y2}
N 230 20090 230 20100 {
lab=Y2}

N 250 20100 280 20100 {
lab=GND}
N 280 20090 280 20100 {
lab=GND}
N 240 20050 280 20050 {
lab=word334}
N 280 20050 320 20050 {
lab=word334}
N 250 20040 250 20090 {
lab=GND}
N 250 20090 250 20100 {
lab=GND}
N 310 20040 310 20090 {
lab=Y3}
N 310 20090 310 20100 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 20070 1 0 {name=M1458
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 20100 360 20100 {
lab=GND}
N 360 20090 360 20100 {
lab=GND}
N 320 20050 360 20050 {
lab=word334}
N 360 20050 400 20050 {
lab=word334}
N 330 20040 330 20090 {
lab=GND}
N 330 20090 330 20100 {
lab=GND}
N 390 20040 390 20090 {
lab=Y4}
N 390 20090 390 20100 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 20070 1 0 {name=M1459
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 20050 440 20050 {
lab=word334}
N 440 20050 480 20050 {
lab=word334}
N 410 20040 410 20090 {
lab=GND}
N 410 20090 410 20100 {
lab=GND}
N 470 20040 470 20090 {
lab=Y5}
N 470 20090 470 20100 {
lab=Y5}

N 490 20100 520 20100 {
lab=GND}
N 520 20090 520 20100 {
lab=GND}
N 480 20050 520 20050 {
lab=word334}
N 520 20050 560 20050 {
lab=word334}
N 490 20040 490 20090 {
lab=GND}
N 490 20090 490 20100 {
lab=GND}
N 550 20040 550 20090 {
lab=Y6}
N 550 20090 550 20100 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 20070 1 0 {name=M1460
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 20100 600 20100 {
lab=GND}
N 600 20090 600 20100 {
lab=GND}
N 560 20050 600 20050 {
lab=word334}
N 600 20050 640 20050 {
lab=word334}
N 570 20040 570 20090 {
lab=GND}
N 570 20090 570 20100 {
lab=GND}
N 630 20040 630 20090 {
lab=Y7}
N 630 20090 630 20100 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20070 1 0 {name=M1461
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20110 0 0 {name=p358 lab=word335}

N 10 20160 40 20160 {
lab=GND}
N 40 20150 40 20160 {
lab=GND}
N 0 20110 40 20110 {
lab=word335}
N 40 20110 80 20110 {
lab=word335}
N 10 20100 10 20150 {
lab=GND}
N 10 20150 10 20160 {
lab=GND}
N 70 20100 70 20150 {
lab=Y0}
N 70 20150 70 20160 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20130 1 0 {name=M1462
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20110 120 20110 {
lab=word335}
N 120 20110 160 20110 {
lab=word335}
N 90 20100 90 20150 {
lab=GND}
N 90 20150 90 20160 {
lab=GND}
N 150 20100 150 20150 {
lab=Y1}
N 150 20150 150 20160 {
lab=Y1}
N 160 20110 200 20110 {
lab=word335}
N 200 20110 240 20110 {
lab=word335}
N 170 20100 170 20150 {
lab=GND}
N 170 20150 170 20160 {
lab=GND}
N 230 20100 230 20150 {
lab=Y2}
N 230 20150 230 20160 {
lab=Y2}

N 250 20160 280 20160 {
lab=GND}
N 280 20150 280 20160 {
lab=GND}
N 240 20110 280 20110 {
lab=word335}
N 280 20110 320 20110 {
lab=word335}
N 250 20100 250 20150 {
lab=GND}
N 250 20150 250 20160 {
lab=GND}
N 310 20100 310 20150 {
lab=Y3}
N 310 20150 310 20160 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 20130 1 0 {name=M1463
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 20160 360 20160 {
lab=GND}
N 360 20150 360 20160 {
lab=GND}
N 320 20110 360 20110 {
lab=word335}
N 360 20110 400 20110 {
lab=word335}
N 330 20100 330 20150 {
lab=GND}
N 330 20150 330 20160 {
lab=GND}
N 390 20100 390 20150 {
lab=Y4}
N 390 20150 390 20160 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 20130 1 0 {name=M1464
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 20160 440 20160 {
lab=GND}
N 440 20150 440 20160 {
lab=GND}
N 400 20110 440 20110 {
lab=word335}
N 440 20110 480 20110 {
lab=word335}
N 410 20100 410 20150 {
lab=GND}
N 410 20150 410 20160 {
lab=GND}
N 470 20100 470 20150 {
lab=Y5}
N 470 20150 470 20160 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 20130 1 0 {name=M1465
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 20110 520 20110 {
lab=word335}
N 520 20110 560 20110 {
lab=word335}
N 490 20100 490 20150 {
lab=GND}
N 490 20150 490 20160 {
lab=GND}
N 550 20100 550 20150 {
lab=Y6}
N 550 20150 550 20160 {
lab=Y6}

N 570 20160 600 20160 {
lab=GND}
N 600 20150 600 20160 {
lab=GND}
N 560 20110 600 20110 {
lab=word335}
N 600 20110 640 20110 {
lab=word335}
N 570 20100 570 20150 {
lab=GND}
N 570 20150 570 20160 {
lab=GND}
N 630 20100 630 20150 {
lab=Y7}
N 630 20150 630 20160 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20130 1 0 {name=M1466
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20170 0 0 {name=p359 lab=word336}

N 10 20220 40 20220 {
lab=GND}
N 40 20210 40 20220 {
lab=GND}
N 0 20170 40 20170 {
lab=word336}
N 40 20170 80 20170 {
lab=word336}
N 10 20160 10 20210 {
lab=GND}
N 10 20210 10 20220 {
lab=GND}
N 70 20160 70 20210 {
lab=Y0}
N 70 20210 70 20220 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20190 1 0 {name=M1467
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20170 120 20170 {
lab=word336}
N 120 20170 160 20170 {
lab=word336}
N 90 20160 90 20210 {
lab=GND}
N 90 20210 90 20220 {
lab=GND}
N 150 20160 150 20210 {
lab=Y1}
N 150 20210 150 20220 {
lab=Y1}
N 160 20170 200 20170 {
lab=word336}
N 200 20170 240 20170 {
lab=word336}
N 170 20160 170 20210 {
lab=GND}
N 170 20210 170 20220 {
lab=GND}
N 230 20160 230 20210 {
lab=Y2}
N 230 20210 230 20220 {
lab=Y2}

N 250 20220 280 20220 {
lab=GND}
N 280 20210 280 20220 {
lab=GND}
N 240 20170 280 20170 {
lab=word336}
N 280 20170 320 20170 {
lab=word336}
N 250 20160 250 20210 {
lab=GND}
N 250 20210 250 20220 {
lab=GND}
N 310 20160 310 20210 {
lab=Y3}
N 310 20210 310 20220 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 20190 1 0 {name=M1468
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 20220 360 20220 {
lab=GND}
N 360 20210 360 20220 {
lab=GND}
N 320 20170 360 20170 {
lab=word336}
N 360 20170 400 20170 {
lab=word336}
N 330 20160 330 20210 {
lab=GND}
N 330 20210 330 20220 {
lab=GND}
N 390 20160 390 20210 {
lab=Y4}
N 390 20210 390 20220 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 20190 1 0 {name=M1469
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 20220 440 20220 {
lab=GND}
N 440 20210 440 20220 {
lab=GND}
N 400 20170 440 20170 {
lab=word336}
N 440 20170 480 20170 {
lab=word336}
N 410 20160 410 20210 {
lab=GND}
N 410 20210 410 20220 {
lab=GND}
N 470 20160 470 20210 {
lab=Y5}
N 470 20210 470 20220 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 20190 1 0 {name=M1470
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 20220 520 20220 {
lab=GND}
N 520 20210 520 20220 {
lab=GND}
N 480 20170 520 20170 {
lab=word336}
N 520 20170 560 20170 {
lab=word336}
N 490 20160 490 20210 {
lab=GND}
N 490 20210 490 20220 {
lab=GND}
N 550 20160 550 20210 {
lab=Y6}
N 550 20210 550 20220 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 20190 1 0 {name=M1471
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 20220 600 20220 {
lab=GND}
N 600 20210 600 20220 {
lab=GND}
N 560 20170 600 20170 {
lab=word336}
N 600 20170 640 20170 {
lab=word336}
N 570 20160 570 20210 {
lab=GND}
N 570 20210 570 20220 {
lab=GND}
N 630 20160 630 20210 {
lab=Y7}
N 630 20210 630 20220 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20190 1 0 {name=M1472
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20230 0 0 {name=p360 lab=word337}

N 10 20280 40 20280 {
lab=GND}
N 40 20270 40 20280 {
lab=GND}
N 0 20230 40 20230 {
lab=word337}
N 40 20230 80 20230 {
lab=word337}
N 10 20220 10 20270 {
lab=GND}
N 10 20270 10 20280 {
lab=GND}
N 70 20220 70 20270 {
lab=Y0}
N 70 20270 70 20280 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20250 1 0 {name=M1473
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20230 120 20230 {
lab=word337}
N 120 20230 160 20230 {
lab=word337}
N 90 20220 90 20270 {
lab=GND}
N 90 20270 90 20280 {
lab=GND}
N 150 20220 150 20270 {
lab=Y1}
N 150 20270 150 20280 {
lab=Y1}

N 170 20280 200 20280 {
lab=GND}
N 200 20270 200 20280 {
lab=GND}
N 160 20230 200 20230 {
lab=word337}
N 200 20230 240 20230 {
lab=word337}
N 170 20220 170 20270 {
lab=GND}
N 170 20270 170 20280 {
lab=GND}
N 230 20220 230 20270 {
lab=Y2}
N 230 20270 230 20280 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20250 1 0 {name=M1474
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 20230 280 20230 {
lab=word337}
N 280 20230 320 20230 {
lab=word337}
N 250 20220 250 20270 {
lab=GND}
N 250 20270 250 20280 {
lab=GND}
N 310 20220 310 20270 {
lab=Y3}
N 310 20270 310 20280 {
lab=Y3}
N 320 20230 360 20230 {
lab=word337}
N 360 20230 400 20230 {
lab=word337}
N 330 20220 330 20270 {
lab=GND}
N 330 20270 330 20280 {
lab=GND}
N 390 20220 390 20270 {
lab=Y4}
N 390 20270 390 20280 {
lab=Y4}
N 400 20230 440 20230 {
lab=word337}
N 440 20230 480 20230 {
lab=word337}
N 410 20220 410 20270 {
lab=GND}
N 410 20270 410 20280 {
lab=GND}
N 470 20220 470 20270 {
lab=Y5}
N 470 20270 470 20280 {
lab=Y5}
N 480 20230 520 20230 {
lab=word337}
N 520 20230 560 20230 {
lab=word337}
N 490 20220 490 20270 {
lab=GND}
N 490 20270 490 20280 {
lab=GND}
N 550 20220 550 20270 {
lab=Y6}
N 550 20270 550 20280 {
lab=Y6}

N 570 20280 600 20280 {
lab=GND}
N 600 20270 600 20280 {
lab=GND}
N 560 20230 600 20230 {
lab=word337}
N 600 20230 640 20230 {
lab=word337}
N 570 20220 570 20270 {
lab=GND}
N 570 20270 570 20280 {
lab=GND}
N 630 20220 630 20270 {
lab=Y7}
N 630 20270 630 20280 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20250 1 0 {name=M1475
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20290 0 0 {name=p361 lab=word338}

N 10 20340 40 20340 {
lab=GND}
N 40 20330 40 20340 {
lab=GND}
N 0 20290 40 20290 {
lab=word338}
N 40 20290 80 20290 {
lab=word338}
N 10 20280 10 20330 {
lab=GND}
N 10 20330 10 20340 {
lab=GND}
N 70 20280 70 20330 {
lab=Y0}
N 70 20330 70 20340 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20310 1 0 {name=M1476
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20290 120 20290 {
lab=word338}
N 120 20290 160 20290 {
lab=word338}
N 90 20280 90 20330 {
lab=GND}
N 90 20330 90 20340 {
lab=GND}
N 150 20280 150 20330 {
lab=Y1}
N 150 20330 150 20340 {
lab=Y1}

N 170 20340 200 20340 {
lab=GND}
N 200 20330 200 20340 {
lab=GND}
N 160 20290 200 20290 {
lab=word338}
N 200 20290 240 20290 {
lab=word338}
N 170 20280 170 20330 {
lab=GND}
N 170 20330 170 20340 {
lab=GND}
N 230 20280 230 20330 {
lab=Y2}
N 230 20330 230 20340 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20310 1 0 {name=M1477
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 20290 280 20290 {
lab=word338}
N 280 20290 320 20290 {
lab=word338}
N 250 20280 250 20330 {
lab=GND}
N 250 20330 250 20340 {
lab=GND}
N 310 20280 310 20330 {
lab=Y3}
N 310 20330 310 20340 {
lab=Y3}
N 320 20290 360 20290 {
lab=word338}
N 360 20290 400 20290 {
lab=word338}
N 330 20280 330 20330 {
lab=GND}
N 330 20330 330 20340 {
lab=GND}
N 390 20280 390 20330 {
lab=Y4}
N 390 20330 390 20340 {
lab=Y4}
N 400 20290 440 20290 {
lab=word338}
N 440 20290 480 20290 {
lab=word338}
N 410 20280 410 20330 {
lab=GND}
N 410 20330 410 20340 {
lab=GND}
N 470 20280 470 20330 {
lab=Y5}
N 470 20330 470 20340 {
lab=Y5}

N 490 20340 520 20340 {
lab=GND}
N 520 20330 520 20340 {
lab=GND}
N 480 20290 520 20290 {
lab=word338}
N 520 20290 560 20290 {
lab=word338}
N 490 20280 490 20330 {
lab=GND}
N 490 20330 490 20340 {
lab=GND}
N 550 20280 550 20330 {
lab=Y6}
N 550 20330 550 20340 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 20310 1 0 {name=M1478
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 20340 600 20340 {
lab=GND}
N 600 20330 600 20340 {
lab=GND}
N 560 20290 600 20290 {
lab=word338}
N 600 20290 640 20290 {
lab=word338}
N 570 20280 570 20330 {
lab=GND}
N 570 20330 570 20340 {
lab=GND}
N 630 20280 630 20330 {
lab=Y7}
N 630 20330 630 20340 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20310 1 0 {name=M1479
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20350 0 0 {name=p362 lab=word339}

N 10 20400 40 20400 {
lab=GND}
N 40 20390 40 20400 {
lab=GND}
N 0 20350 40 20350 {
lab=word339}
N 40 20350 80 20350 {
lab=word339}
N 10 20340 10 20390 {
lab=GND}
N 10 20390 10 20400 {
lab=GND}
N 70 20340 70 20390 {
lab=Y0}
N 70 20390 70 20400 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20370 1 0 {name=M1480
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20350 120 20350 {
lab=word339}
N 120 20350 160 20350 {
lab=word339}
N 90 20340 90 20390 {
lab=GND}
N 90 20390 90 20400 {
lab=GND}
N 150 20340 150 20390 {
lab=Y1}
N 150 20390 150 20400 {
lab=Y1}

N 170 20400 200 20400 {
lab=GND}
N 200 20390 200 20400 {
lab=GND}
N 160 20350 200 20350 {
lab=word339}
N 200 20350 240 20350 {
lab=word339}
N 170 20340 170 20390 {
lab=GND}
N 170 20390 170 20400 {
lab=GND}
N 230 20340 230 20390 {
lab=Y2}
N 230 20390 230 20400 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20370 1 0 {name=M1481
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 20350 280 20350 {
lab=word339}
N 280 20350 320 20350 {
lab=word339}
N 250 20340 250 20390 {
lab=GND}
N 250 20390 250 20400 {
lab=GND}
N 310 20340 310 20390 {
lab=Y3}
N 310 20390 310 20400 {
lab=Y3}
N 320 20350 360 20350 {
lab=word339}
N 360 20350 400 20350 {
lab=word339}
N 330 20340 330 20390 {
lab=GND}
N 330 20390 330 20400 {
lab=GND}
N 390 20340 390 20390 {
lab=Y4}
N 390 20390 390 20400 {
lab=Y4}

N 410 20400 440 20400 {
lab=GND}
N 440 20390 440 20400 {
lab=GND}
N 400 20350 440 20350 {
lab=word339}
N 440 20350 480 20350 {
lab=word339}
N 410 20340 410 20390 {
lab=GND}
N 410 20390 410 20400 {
lab=GND}
N 470 20340 470 20390 {
lab=Y5}
N 470 20390 470 20400 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 20370 1 0 {name=M1482
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 20350 520 20350 {
lab=word339}
N 520 20350 560 20350 {
lab=word339}
N 490 20340 490 20390 {
lab=GND}
N 490 20390 490 20400 {
lab=GND}
N 550 20340 550 20390 {
lab=Y6}
N 550 20390 550 20400 {
lab=Y6}

N 570 20400 600 20400 {
lab=GND}
N 600 20390 600 20400 {
lab=GND}
N 560 20350 600 20350 {
lab=word339}
N 600 20350 640 20350 {
lab=word339}
N 570 20340 570 20390 {
lab=GND}
N 570 20390 570 20400 {
lab=GND}
N 630 20340 630 20390 {
lab=Y7}
N 630 20390 630 20400 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20370 1 0 {name=M1483
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20410 0 0 {name=p363 lab=word340}

N 10 20460 40 20460 {
lab=GND}
N 40 20450 40 20460 {
lab=GND}
N 0 20410 40 20410 {
lab=word340}
N 40 20410 80 20410 {
lab=word340}
N 10 20400 10 20450 {
lab=GND}
N 10 20450 10 20460 {
lab=GND}
N 70 20400 70 20450 {
lab=Y0}
N 70 20450 70 20460 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20430 1 0 {name=M1484
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20410 120 20410 {
lab=word340}
N 120 20410 160 20410 {
lab=word340}
N 90 20400 90 20450 {
lab=GND}
N 90 20450 90 20460 {
lab=GND}
N 150 20400 150 20450 {
lab=Y1}
N 150 20450 150 20460 {
lab=Y1}

N 170 20460 200 20460 {
lab=GND}
N 200 20450 200 20460 {
lab=GND}
N 160 20410 200 20410 {
lab=word340}
N 200 20410 240 20410 {
lab=word340}
N 170 20400 170 20450 {
lab=GND}
N 170 20450 170 20460 {
lab=GND}
N 230 20400 230 20450 {
lab=Y2}
N 230 20450 230 20460 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20430 1 0 {name=M1485
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 20410 280 20410 {
lab=word340}
N 280 20410 320 20410 {
lab=word340}
N 250 20400 250 20450 {
lab=GND}
N 250 20450 250 20460 {
lab=GND}
N 310 20400 310 20450 {
lab=Y3}
N 310 20450 310 20460 {
lab=Y3}
N 320 20410 360 20410 {
lab=word340}
N 360 20410 400 20410 {
lab=word340}
N 330 20400 330 20450 {
lab=GND}
N 330 20450 330 20460 {
lab=GND}
N 390 20400 390 20450 {
lab=Y4}
N 390 20450 390 20460 {
lab=Y4}

N 410 20460 440 20460 {
lab=GND}
N 440 20450 440 20460 {
lab=GND}
N 400 20410 440 20410 {
lab=word340}
N 440 20410 480 20410 {
lab=word340}
N 410 20400 410 20450 {
lab=GND}
N 410 20450 410 20460 {
lab=GND}
N 470 20400 470 20450 {
lab=Y5}
N 470 20450 470 20460 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 20430 1 0 {name=M1486
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 20460 520 20460 {
lab=GND}
N 520 20450 520 20460 {
lab=GND}
N 480 20410 520 20410 {
lab=word340}
N 520 20410 560 20410 {
lab=word340}
N 490 20400 490 20450 {
lab=GND}
N 490 20450 490 20460 {
lab=GND}
N 550 20400 550 20450 {
lab=Y6}
N 550 20450 550 20460 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 20430 1 0 {name=M1487
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 20460 600 20460 {
lab=GND}
N 600 20450 600 20460 {
lab=GND}
N 560 20410 600 20410 {
lab=word340}
N 600 20410 640 20410 {
lab=word340}
N 570 20400 570 20450 {
lab=GND}
N 570 20450 570 20460 {
lab=GND}
N 630 20400 630 20450 {
lab=Y7}
N 630 20450 630 20460 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20430 1 0 {name=M1488
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20470 0 0 {name=p364 lab=word341}

N 10 20520 40 20520 {
lab=GND}
N 40 20510 40 20520 {
lab=GND}
N 0 20470 40 20470 {
lab=word341}
N 40 20470 80 20470 {
lab=word341}
N 10 20460 10 20510 {
lab=GND}
N 10 20510 10 20520 {
lab=GND}
N 70 20460 70 20510 {
lab=Y0}
N 70 20510 70 20520 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20490 1 0 {name=M1489
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20470 120 20470 {
lab=word341}
N 120 20470 160 20470 {
lab=word341}
N 90 20460 90 20510 {
lab=GND}
N 90 20510 90 20520 {
lab=GND}
N 150 20460 150 20510 {
lab=Y1}
N 150 20510 150 20520 {
lab=Y1}

N 170 20520 200 20520 {
lab=GND}
N 200 20510 200 20520 {
lab=GND}
N 160 20470 200 20470 {
lab=word341}
N 200 20470 240 20470 {
lab=word341}
N 170 20460 170 20510 {
lab=GND}
N 170 20510 170 20520 {
lab=GND}
N 230 20460 230 20510 {
lab=Y2}
N 230 20510 230 20520 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20490 1 0 {name=M1490
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 20470 280 20470 {
lab=word341}
N 280 20470 320 20470 {
lab=word341}
N 250 20460 250 20510 {
lab=GND}
N 250 20510 250 20520 {
lab=GND}
N 310 20460 310 20510 {
lab=Y3}
N 310 20510 310 20520 {
lab=Y3}

N 330 20520 360 20520 {
lab=GND}
N 360 20510 360 20520 {
lab=GND}
N 320 20470 360 20470 {
lab=word341}
N 360 20470 400 20470 {
lab=word341}
N 330 20460 330 20510 {
lab=GND}
N 330 20510 330 20520 {
lab=GND}
N 390 20460 390 20510 {
lab=Y4}
N 390 20510 390 20520 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 20490 1 0 {name=M1491
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 20470 440 20470 {
lab=word341}
N 440 20470 480 20470 {
lab=word341}
N 410 20460 410 20510 {
lab=GND}
N 410 20510 410 20520 {
lab=GND}
N 470 20460 470 20510 {
lab=Y5}
N 470 20510 470 20520 {
lab=Y5}
N 480 20470 520 20470 {
lab=word341}
N 520 20470 560 20470 {
lab=word341}
N 490 20460 490 20510 {
lab=GND}
N 490 20510 490 20520 {
lab=GND}
N 550 20460 550 20510 {
lab=Y6}
N 550 20510 550 20520 {
lab=Y6}

N 570 20520 600 20520 {
lab=GND}
N 600 20510 600 20520 {
lab=GND}
N 560 20470 600 20470 {
lab=word341}
N 600 20470 640 20470 {
lab=word341}
N 570 20460 570 20510 {
lab=GND}
N 570 20510 570 20520 {
lab=GND}
N 630 20460 630 20510 {
lab=Y7}
N 630 20510 630 20520 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20490 1 0 {name=M1492
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20530 0 0 {name=p365 lab=word342}

N 10 20580 40 20580 {
lab=GND}
N 40 20570 40 20580 {
lab=GND}
N 0 20530 40 20530 {
lab=word342}
N 40 20530 80 20530 {
lab=word342}
N 10 20520 10 20570 {
lab=GND}
N 10 20570 10 20580 {
lab=GND}
N 70 20520 70 20570 {
lab=Y0}
N 70 20570 70 20580 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20550 1 0 {name=M1493
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20530 120 20530 {
lab=word342}
N 120 20530 160 20530 {
lab=word342}
N 90 20520 90 20570 {
lab=GND}
N 90 20570 90 20580 {
lab=GND}
N 150 20520 150 20570 {
lab=Y1}
N 150 20570 150 20580 {
lab=Y1}

N 170 20580 200 20580 {
lab=GND}
N 200 20570 200 20580 {
lab=GND}
N 160 20530 200 20530 {
lab=word342}
N 200 20530 240 20530 {
lab=word342}
N 170 20520 170 20570 {
lab=GND}
N 170 20570 170 20580 {
lab=GND}
N 230 20520 230 20570 {
lab=Y2}
N 230 20570 230 20580 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20550 1 0 {name=M1494
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 20530 280 20530 {
lab=word342}
N 280 20530 320 20530 {
lab=word342}
N 250 20520 250 20570 {
lab=GND}
N 250 20570 250 20580 {
lab=GND}
N 310 20520 310 20570 {
lab=Y3}
N 310 20570 310 20580 {
lab=Y3}

N 330 20580 360 20580 {
lab=GND}
N 360 20570 360 20580 {
lab=GND}
N 320 20530 360 20530 {
lab=word342}
N 360 20530 400 20530 {
lab=word342}
N 330 20520 330 20570 {
lab=GND}
N 330 20570 330 20580 {
lab=GND}
N 390 20520 390 20570 {
lab=Y4}
N 390 20570 390 20580 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 20550 1 0 {name=M1495
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 20530 440 20530 {
lab=word342}
N 440 20530 480 20530 {
lab=word342}
N 410 20520 410 20570 {
lab=GND}
N 410 20570 410 20580 {
lab=GND}
N 470 20520 470 20570 {
lab=Y5}
N 470 20570 470 20580 {
lab=Y5}

N 490 20580 520 20580 {
lab=GND}
N 520 20570 520 20580 {
lab=GND}
N 480 20530 520 20530 {
lab=word342}
N 520 20530 560 20530 {
lab=word342}
N 490 20520 490 20570 {
lab=GND}
N 490 20570 490 20580 {
lab=GND}
N 550 20520 550 20570 {
lab=Y6}
N 550 20570 550 20580 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 20550 1 0 {name=M1496
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 20580 600 20580 {
lab=GND}
N 600 20570 600 20580 {
lab=GND}
N 560 20530 600 20530 {
lab=word342}
N 600 20530 640 20530 {
lab=word342}
N 570 20520 570 20570 {
lab=GND}
N 570 20570 570 20580 {
lab=GND}
N 630 20520 630 20570 {
lab=Y7}
N 630 20570 630 20580 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20550 1 0 {name=M1497
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20590 0 0 {name=p366 lab=word343}

N 10 20640 40 20640 {
lab=GND}
N 40 20630 40 20640 {
lab=GND}
N 0 20590 40 20590 {
lab=word343}
N 40 20590 80 20590 {
lab=word343}
N 10 20580 10 20630 {
lab=GND}
N 10 20630 10 20640 {
lab=GND}
N 70 20580 70 20630 {
lab=Y0}
N 70 20630 70 20640 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20610 1 0 {name=M1498
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20590 120 20590 {
lab=word343}
N 120 20590 160 20590 {
lab=word343}
N 90 20580 90 20630 {
lab=GND}
N 90 20630 90 20640 {
lab=GND}
N 150 20580 150 20630 {
lab=Y1}
N 150 20630 150 20640 {
lab=Y1}

N 170 20640 200 20640 {
lab=GND}
N 200 20630 200 20640 {
lab=GND}
N 160 20590 200 20590 {
lab=word343}
N 200 20590 240 20590 {
lab=word343}
N 170 20580 170 20630 {
lab=GND}
N 170 20630 170 20640 {
lab=GND}
N 230 20580 230 20630 {
lab=Y2}
N 230 20630 230 20640 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20610 1 0 {name=M1499
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 20590 280 20590 {
lab=word343}
N 280 20590 320 20590 {
lab=word343}
N 250 20580 250 20630 {
lab=GND}
N 250 20630 250 20640 {
lab=GND}
N 310 20580 310 20630 {
lab=Y3}
N 310 20630 310 20640 {
lab=Y3}

N 330 20640 360 20640 {
lab=GND}
N 360 20630 360 20640 {
lab=GND}
N 320 20590 360 20590 {
lab=word343}
N 360 20590 400 20590 {
lab=word343}
N 330 20580 330 20630 {
lab=GND}
N 330 20630 330 20640 {
lab=GND}
N 390 20580 390 20630 {
lab=Y4}
N 390 20630 390 20640 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 20610 1 0 {name=M1500
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 20640 440 20640 {
lab=GND}
N 440 20630 440 20640 {
lab=GND}
N 400 20590 440 20590 {
lab=word343}
N 440 20590 480 20590 {
lab=word343}
N 410 20580 410 20630 {
lab=GND}
N 410 20630 410 20640 {
lab=GND}
N 470 20580 470 20630 {
lab=Y5}
N 470 20630 470 20640 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 20610 1 0 {name=M1501
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 20590 520 20590 {
lab=word343}
N 520 20590 560 20590 {
lab=word343}
N 490 20580 490 20630 {
lab=GND}
N 490 20630 490 20640 {
lab=GND}
N 550 20580 550 20630 {
lab=Y6}
N 550 20630 550 20640 {
lab=Y6}

N 570 20640 600 20640 {
lab=GND}
N 600 20630 600 20640 {
lab=GND}
N 560 20590 600 20590 {
lab=word343}
N 600 20590 640 20590 {
lab=word343}
N 570 20580 570 20630 {
lab=GND}
N 570 20630 570 20640 {
lab=GND}
N 630 20580 630 20630 {
lab=Y7}
N 630 20630 630 20640 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20610 1 0 {name=M1502
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20650 0 0 {name=p367 lab=word344}

N 10 20700 40 20700 {
lab=GND}
N 40 20690 40 20700 {
lab=GND}
N 0 20650 40 20650 {
lab=word344}
N 40 20650 80 20650 {
lab=word344}
N 10 20640 10 20690 {
lab=GND}
N 10 20690 10 20700 {
lab=GND}
N 70 20640 70 20690 {
lab=Y0}
N 70 20690 70 20700 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20670 1 0 {name=M1503
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20650 120 20650 {
lab=word344}
N 120 20650 160 20650 {
lab=word344}
N 90 20640 90 20690 {
lab=GND}
N 90 20690 90 20700 {
lab=GND}
N 150 20640 150 20690 {
lab=Y1}
N 150 20690 150 20700 {
lab=Y1}

N 170 20700 200 20700 {
lab=GND}
N 200 20690 200 20700 {
lab=GND}
N 160 20650 200 20650 {
lab=word344}
N 200 20650 240 20650 {
lab=word344}
N 170 20640 170 20690 {
lab=GND}
N 170 20690 170 20700 {
lab=GND}
N 230 20640 230 20690 {
lab=Y2}
N 230 20690 230 20700 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20670 1 0 {name=M1504
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 20650 280 20650 {
lab=word344}
N 280 20650 320 20650 {
lab=word344}
N 250 20640 250 20690 {
lab=GND}
N 250 20690 250 20700 {
lab=GND}
N 310 20640 310 20690 {
lab=Y3}
N 310 20690 310 20700 {
lab=Y3}

N 330 20700 360 20700 {
lab=GND}
N 360 20690 360 20700 {
lab=GND}
N 320 20650 360 20650 {
lab=word344}
N 360 20650 400 20650 {
lab=word344}
N 330 20640 330 20690 {
lab=GND}
N 330 20690 330 20700 {
lab=GND}
N 390 20640 390 20690 {
lab=Y4}
N 390 20690 390 20700 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 20670 1 0 {name=M1505
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 20700 440 20700 {
lab=GND}
N 440 20690 440 20700 {
lab=GND}
N 400 20650 440 20650 {
lab=word344}
N 440 20650 480 20650 {
lab=word344}
N 410 20640 410 20690 {
lab=GND}
N 410 20690 410 20700 {
lab=GND}
N 470 20640 470 20690 {
lab=Y5}
N 470 20690 470 20700 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 20670 1 0 {name=M1506
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 20700 520 20700 {
lab=GND}
N 520 20690 520 20700 {
lab=GND}
N 480 20650 520 20650 {
lab=word344}
N 520 20650 560 20650 {
lab=word344}
N 490 20640 490 20690 {
lab=GND}
N 490 20690 490 20700 {
lab=GND}
N 550 20640 550 20690 {
lab=Y6}
N 550 20690 550 20700 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 20670 1 0 {name=M1507
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 20700 600 20700 {
lab=GND}
N 600 20690 600 20700 {
lab=GND}
N 560 20650 600 20650 {
lab=word344}
N 600 20650 640 20650 {
lab=word344}
N 570 20640 570 20690 {
lab=GND}
N 570 20690 570 20700 {
lab=GND}
N 630 20640 630 20690 {
lab=Y7}
N 630 20690 630 20700 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20670 1 0 {name=M1508
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20710 0 0 {name=p368 lab=word345}

N 10 20760 40 20760 {
lab=GND}
N 40 20750 40 20760 {
lab=GND}
N 0 20710 40 20710 {
lab=word345}
N 40 20710 80 20710 {
lab=word345}
N 10 20700 10 20750 {
lab=GND}
N 10 20750 10 20760 {
lab=GND}
N 70 20700 70 20750 {
lab=Y0}
N 70 20750 70 20760 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20730 1 0 {name=M1509
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20710 120 20710 {
lab=word345}
N 120 20710 160 20710 {
lab=word345}
N 90 20700 90 20750 {
lab=GND}
N 90 20750 90 20760 {
lab=GND}
N 150 20700 150 20750 {
lab=Y1}
N 150 20750 150 20760 {
lab=Y1}

N 170 20760 200 20760 {
lab=GND}
N 200 20750 200 20760 {
lab=GND}
N 160 20710 200 20710 {
lab=word345}
N 200 20710 240 20710 {
lab=word345}
N 170 20700 170 20750 {
lab=GND}
N 170 20750 170 20760 {
lab=GND}
N 230 20700 230 20750 {
lab=Y2}
N 230 20750 230 20760 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20730 1 0 {name=M1510
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 20760 280 20760 {
lab=GND}
N 280 20750 280 20760 {
lab=GND}
N 240 20710 280 20710 {
lab=word345}
N 280 20710 320 20710 {
lab=word345}
N 250 20700 250 20750 {
lab=GND}
N 250 20750 250 20760 {
lab=GND}
N 310 20700 310 20750 {
lab=Y3}
N 310 20750 310 20760 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 20730 1 0 {name=M1511
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 20710 360 20710 {
lab=word345}
N 360 20710 400 20710 {
lab=word345}
N 330 20700 330 20750 {
lab=GND}
N 330 20750 330 20760 {
lab=GND}
N 390 20700 390 20750 {
lab=Y4}
N 390 20750 390 20760 {
lab=Y4}
N 400 20710 440 20710 {
lab=word345}
N 440 20710 480 20710 {
lab=word345}
N 410 20700 410 20750 {
lab=GND}
N 410 20750 410 20760 {
lab=GND}
N 470 20700 470 20750 {
lab=Y5}
N 470 20750 470 20760 {
lab=Y5}
N 480 20710 520 20710 {
lab=word345}
N 520 20710 560 20710 {
lab=word345}
N 490 20700 490 20750 {
lab=GND}
N 490 20750 490 20760 {
lab=GND}
N 550 20700 550 20750 {
lab=Y6}
N 550 20750 550 20760 {
lab=Y6}

N 570 20760 600 20760 {
lab=GND}
N 600 20750 600 20760 {
lab=GND}
N 560 20710 600 20710 {
lab=word345}
N 600 20710 640 20710 {
lab=word345}
N 570 20700 570 20750 {
lab=GND}
N 570 20750 570 20760 {
lab=GND}
N 630 20700 630 20750 {
lab=Y7}
N 630 20750 630 20760 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20730 1 0 {name=M1512
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20770 0 0 {name=p369 lab=word346}

N 10 20820 40 20820 {
lab=GND}
N 40 20810 40 20820 {
lab=GND}
N 0 20770 40 20770 {
lab=word346}
N 40 20770 80 20770 {
lab=word346}
N 10 20760 10 20810 {
lab=GND}
N 10 20810 10 20820 {
lab=GND}
N 70 20760 70 20810 {
lab=Y0}
N 70 20810 70 20820 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20790 1 0 {name=M1513
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20770 120 20770 {
lab=word346}
N 120 20770 160 20770 {
lab=word346}
N 90 20760 90 20810 {
lab=GND}
N 90 20810 90 20820 {
lab=GND}
N 150 20760 150 20810 {
lab=Y1}
N 150 20810 150 20820 {
lab=Y1}

N 170 20820 200 20820 {
lab=GND}
N 200 20810 200 20820 {
lab=GND}
N 160 20770 200 20770 {
lab=word346}
N 200 20770 240 20770 {
lab=word346}
N 170 20760 170 20810 {
lab=GND}
N 170 20810 170 20820 {
lab=GND}
N 230 20760 230 20810 {
lab=Y2}
N 230 20810 230 20820 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20790 1 0 {name=M1514
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 20820 280 20820 {
lab=GND}
N 280 20810 280 20820 {
lab=GND}
N 240 20770 280 20770 {
lab=word346}
N 280 20770 320 20770 {
lab=word346}
N 250 20760 250 20810 {
lab=GND}
N 250 20810 250 20820 {
lab=GND}
N 310 20760 310 20810 {
lab=Y3}
N 310 20810 310 20820 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 20790 1 0 {name=M1515
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 20770 360 20770 {
lab=word346}
N 360 20770 400 20770 {
lab=word346}
N 330 20760 330 20810 {
lab=GND}
N 330 20810 330 20820 {
lab=GND}
N 390 20760 390 20810 {
lab=Y4}
N 390 20810 390 20820 {
lab=Y4}
N 400 20770 440 20770 {
lab=word346}
N 440 20770 480 20770 {
lab=word346}
N 410 20760 410 20810 {
lab=GND}
N 410 20810 410 20820 {
lab=GND}
N 470 20760 470 20810 {
lab=Y5}
N 470 20810 470 20820 {
lab=Y5}

N 490 20820 520 20820 {
lab=GND}
N 520 20810 520 20820 {
lab=GND}
N 480 20770 520 20770 {
lab=word346}
N 520 20770 560 20770 {
lab=word346}
N 490 20760 490 20810 {
lab=GND}
N 490 20810 490 20820 {
lab=GND}
N 550 20760 550 20810 {
lab=Y6}
N 550 20810 550 20820 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 20790 1 0 {name=M1516
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 20820 600 20820 {
lab=GND}
N 600 20810 600 20820 {
lab=GND}
N 560 20770 600 20770 {
lab=word346}
N 600 20770 640 20770 {
lab=word346}
N 570 20760 570 20810 {
lab=GND}
N 570 20810 570 20820 {
lab=GND}
N 630 20760 630 20810 {
lab=Y7}
N 630 20810 630 20820 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20790 1 0 {name=M1517
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20830 0 0 {name=p370 lab=word347}

N 10 20880 40 20880 {
lab=GND}
N 40 20870 40 20880 {
lab=GND}
N 0 20830 40 20830 {
lab=word347}
N 40 20830 80 20830 {
lab=word347}
N 10 20820 10 20870 {
lab=GND}
N 10 20870 10 20880 {
lab=GND}
N 70 20820 70 20870 {
lab=Y0}
N 70 20870 70 20880 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20850 1 0 {name=M1518
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20830 120 20830 {
lab=word347}
N 120 20830 160 20830 {
lab=word347}
N 90 20820 90 20870 {
lab=GND}
N 90 20870 90 20880 {
lab=GND}
N 150 20820 150 20870 {
lab=Y1}
N 150 20870 150 20880 {
lab=Y1}

N 170 20880 200 20880 {
lab=GND}
N 200 20870 200 20880 {
lab=GND}
N 160 20830 200 20830 {
lab=word347}
N 200 20830 240 20830 {
lab=word347}
N 170 20820 170 20870 {
lab=GND}
N 170 20870 170 20880 {
lab=GND}
N 230 20820 230 20870 {
lab=Y2}
N 230 20870 230 20880 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20850 1 0 {name=M1519
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 20880 280 20880 {
lab=GND}
N 280 20870 280 20880 {
lab=GND}
N 240 20830 280 20830 {
lab=word347}
N 280 20830 320 20830 {
lab=word347}
N 250 20820 250 20870 {
lab=GND}
N 250 20870 250 20880 {
lab=GND}
N 310 20820 310 20870 {
lab=Y3}
N 310 20870 310 20880 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 20850 1 0 {name=M1520
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 20830 360 20830 {
lab=word347}
N 360 20830 400 20830 {
lab=word347}
N 330 20820 330 20870 {
lab=GND}
N 330 20870 330 20880 {
lab=GND}
N 390 20820 390 20870 {
lab=Y4}
N 390 20870 390 20880 {
lab=Y4}

N 410 20880 440 20880 {
lab=GND}
N 440 20870 440 20880 {
lab=GND}
N 400 20830 440 20830 {
lab=word347}
N 440 20830 480 20830 {
lab=word347}
N 410 20820 410 20870 {
lab=GND}
N 410 20870 410 20880 {
lab=GND}
N 470 20820 470 20870 {
lab=Y5}
N 470 20870 470 20880 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 20850 1 0 {name=M1521
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 20830 520 20830 {
lab=word347}
N 520 20830 560 20830 {
lab=word347}
N 490 20820 490 20870 {
lab=GND}
N 490 20870 490 20880 {
lab=GND}
N 550 20820 550 20870 {
lab=Y6}
N 550 20870 550 20880 {
lab=Y6}

N 570 20880 600 20880 {
lab=GND}
N 600 20870 600 20880 {
lab=GND}
N 560 20830 600 20830 {
lab=word347}
N 600 20830 640 20830 {
lab=word347}
N 570 20820 570 20870 {
lab=GND}
N 570 20870 570 20880 {
lab=GND}
N 630 20820 630 20870 {
lab=Y7}
N 630 20870 630 20880 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20850 1 0 {name=M1522
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20890 0 0 {name=p371 lab=word348}

N 10 20940 40 20940 {
lab=GND}
N 40 20930 40 20940 {
lab=GND}
N 0 20890 40 20890 {
lab=word348}
N 40 20890 80 20890 {
lab=word348}
N 10 20880 10 20930 {
lab=GND}
N 10 20930 10 20940 {
lab=GND}
N 70 20880 70 20930 {
lab=Y0}
N 70 20930 70 20940 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20910 1 0 {name=M1523
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20890 120 20890 {
lab=word348}
N 120 20890 160 20890 {
lab=word348}
N 90 20880 90 20930 {
lab=GND}
N 90 20930 90 20940 {
lab=GND}
N 150 20880 150 20930 {
lab=Y1}
N 150 20930 150 20940 {
lab=Y1}

N 170 20940 200 20940 {
lab=GND}
N 200 20930 200 20940 {
lab=GND}
N 160 20890 200 20890 {
lab=word348}
N 200 20890 240 20890 {
lab=word348}
N 170 20880 170 20930 {
lab=GND}
N 170 20930 170 20940 {
lab=GND}
N 230 20880 230 20930 {
lab=Y2}
N 230 20930 230 20940 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20910 1 0 {name=M1524
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 20940 280 20940 {
lab=GND}
N 280 20930 280 20940 {
lab=GND}
N 240 20890 280 20890 {
lab=word348}
N 280 20890 320 20890 {
lab=word348}
N 250 20880 250 20930 {
lab=GND}
N 250 20930 250 20940 {
lab=GND}
N 310 20880 310 20930 {
lab=Y3}
N 310 20930 310 20940 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 20910 1 0 {name=M1525
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 20890 360 20890 {
lab=word348}
N 360 20890 400 20890 {
lab=word348}
N 330 20880 330 20930 {
lab=GND}
N 330 20930 330 20940 {
lab=GND}
N 390 20880 390 20930 {
lab=Y4}
N 390 20930 390 20940 {
lab=Y4}

N 410 20940 440 20940 {
lab=GND}
N 440 20930 440 20940 {
lab=GND}
N 400 20890 440 20890 {
lab=word348}
N 440 20890 480 20890 {
lab=word348}
N 410 20880 410 20930 {
lab=GND}
N 410 20930 410 20940 {
lab=GND}
N 470 20880 470 20930 {
lab=Y5}
N 470 20930 470 20940 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 20910 1 0 {name=M1526
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 20940 520 20940 {
lab=GND}
N 520 20930 520 20940 {
lab=GND}
N 480 20890 520 20890 {
lab=word348}
N 520 20890 560 20890 {
lab=word348}
N 490 20880 490 20930 {
lab=GND}
N 490 20930 490 20940 {
lab=GND}
N 550 20880 550 20930 {
lab=Y6}
N 550 20930 550 20940 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 20910 1 0 {name=M1527
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 20940 600 20940 {
lab=GND}
N 600 20930 600 20940 {
lab=GND}
N 560 20890 600 20890 {
lab=word348}
N 600 20890 640 20890 {
lab=word348}
N 570 20880 570 20930 {
lab=GND}
N 570 20930 570 20940 {
lab=GND}
N 630 20880 630 20930 {
lab=Y7}
N 630 20930 630 20940 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20910 1 0 {name=M1528
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 20950 0 0 {name=p372 lab=word349}

N 10 21000 40 21000 {
lab=GND}
N 40 20990 40 21000 {
lab=GND}
N 0 20950 40 20950 {
lab=word349}
N 40 20950 80 20950 {
lab=word349}
N 10 20940 10 20990 {
lab=GND}
N 10 20990 10 21000 {
lab=GND}
N 70 20940 70 20990 {
lab=Y0}
N 70 20990 70 21000 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 20970 1 0 {name=M1529
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 20950 120 20950 {
lab=word349}
N 120 20950 160 20950 {
lab=word349}
N 90 20940 90 20990 {
lab=GND}
N 90 20990 90 21000 {
lab=GND}
N 150 20940 150 20990 {
lab=Y1}
N 150 20990 150 21000 {
lab=Y1}

N 170 21000 200 21000 {
lab=GND}
N 200 20990 200 21000 {
lab=GND}
N 160 20950 200 20950 {
lab=word349}
N 200 20950 240 20950 {
lab=word349}
N 170 20940 170 20990 {
lab=GND}
N 170 20990 170 21000 {
lab=GND}
N 230 20940 230 20990 {
lab=Y2}
N 230 20990 230 21000 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 20970 1 0 {name=M1530
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 21000 280 21000 {
lab=GND}
N 280 20990 280 21000 {
lab=GND}
N 240 20950 280 20950 {
lab=word349}
N 280 20950 320 20950 {
lab=word349}
N 250 20940 250 20990 {
lab=GND}
N 250 20990 250 21000 {
lab=GND}
N 310 20940 310 20990 {
lab=Y3}
N 310 20990 310 21000 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 20970 1 0 {name=M1531
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 21000 360 21000 {
lab=GND}
N 360 20990 360 21000 {
lab=GND}
N 320 20950 360 20950 {
lab=word349}
N 360 20950 400 20950 {
lab=word349}
N 330 20940 330 20990 {
lab=GND}
N 330 20990 330 21000 {
lab=GND}
N 390 20940 390 20990 {
lab=Y4}
N 390 20990 390 21000 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 20970 1 0 {name=M1532
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 20950 440 20950 {
lab=word349}
N 440 20950 480 20950 {
lab=word349}
N 410 20940 410 20990 {
lab=GND}
N 410 20990 410 21000 {
lab=GND}
N 470 20940 470 20990 {
lab=Y5}
N 470 20990 470 21000 {
lab=Y5}
N 480 20950 520 20950 {
lab=word349}
N 520 20950 560 20950 {
lab=word349}
N 490 20940 490 20990 {
lab=GND}
N 490 20990 490 21000 {
lab=GND}
N 550 20940 550 20990 {
lab=Y6}
N 550 20990 550 21000 {
lab=Y6}

N 570 21000 600 21000 {
lab=GND}
N 600 20990 600 21000 {
lab=GND}
N 560 20950 600 20950 {
lab=word349}
N 600 20950 640 20950 {
lab=word349}
N 570 20940 570 20990 {
lab=GND}
N 570 20990 570 21000 {
lab=GND}
N 630 20940 630 20990 {
lab=Y7}
N 630 20990 630 21000 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 20970 1 0 {name=M1533
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21010 0 0 {name=p373 lab=word350}

N 10 21060 40 21060 {
lab=GND}
N 40 21050 40 21060 {
lab=GND}
N 0 21010 40 21010 {
lab=word350}
N 40 21010 80 21010 {
lab=word350}
N 10 21000 10 21050 {
lab=GND}
N 10 21050 10 21060 {
lab=GND}
N 70 21000 70 21050 {
lab=Y0}
N 70 21050 70 21060 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21030 1 0 {name=M1534
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 21010 120 21010 {
lab=word350}
N 120 21010 160 21010 {
lab=word350}
N 90 21000 90 21050 {
lab=GND}
N 90 21050 90 21060 {
lab=GND}
N 150 21000 150 21050 {
lab=Y1}
N 150 21050 150 21060 {
lab=Y1}

N 170 21060 200 21060 {
lab=GND}
N 200 21050 200 21060 {
lab=GND}
N 160 21010 200 21010 {
lab=word350}
N 200 21010 240 21010 {
lab=word350}
N 170 21000 170 21050 {
lab=GND}
N 170 21050 170 21060 {
lab=GND}
N 230 21000 230 21050 {
lab=Y2}
N 230 21050 230 21060 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 21030 1 0 {name=M1535
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 21060 280 21060 {
lab=GND}
N 280 21050 280 21060 {
lab=GND}
N 240 21010 280 21010 {
lab=word350}
N 280 21010 320 21010 {
lab=word350}
N 250 21000 250 21050 {
lab=GND}
N 250 21050 250 21060 {
lab=GND}
N 310 21000 310 21050 {
lab=Y3}
N 310 21050 310 21060 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 21030 1 0 {name=M1536
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 21060 360 21060 {
lab=GND}
N 360 21050 360 21060 {
lab=GND}
N 320 21010 360 21010 {
lab=word350}
N 360 21010 400 21010 {
lab=word350}
N 330 21000 330 21050 {
lab=GND}
N 330 21050 330 21060 {
lab=GND}
N 390 21000 390 21050 {
lab=Y4}
N 390 21050 390 21060 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 21030 1 0 {name=M1537
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 21010 440 21010 {
lab=word350}
N 440 21010 480 21010 {
lab=word350}
N 410 21000 410 21050 {
lab=GND}
N 410 21050 410 21060 {
lab=GND}
N 470 21000 470 21050 {
lab=Y5}
N 470 21050 470 21060 {
lab=Y5}

N 490 21060 520 21060 {
lab=GND}
N 520 21050 520 21060 {
lab=GND}
N 480 21010 520 21010 {
lab=word350}
N 520 21010 560 21010 {
lab=word350}
N 490 21000 490 21050 {
lab=GND}
N 490 21050 490 21060 {
lab=GND}
N 550 21000 550 21050 {
lab=Y6}
N 550 21050 550 21060 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 21030 1 0 {name=M1538
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 21060 600 21060 {
lab=GND}
N 600 21050 600 21060 {
lab=GND}
N 560 21010 600 21010 {
lab=word350}
N 600 21010 640 21010 {
lab=word350}
N 570 21000 570 21050 {
lab=GND}
N 570 21050 570 21060 {
lab=GND}
N 630 21000 630 21050 {
lab=Y7}
N 630 21050 630 21060 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21030 1 0 {name=M1539
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21070 0 0 {name=p374 lab=word351}

N 10 21120 40 21120 {
lab=GND}
N 40 21110 40 21120 {
lab=GND}
N 0 21070 40 21070 {
lab=word351}
N 40 21070 80 21070 {
lab=word351}
N 10 21060 10 21110 {
lab=GND}
N 10 21110 10 21120 {
lab=GND}
N 70 21060 70 21110 {
lab=Y0}
N 70 21110 70 21120 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21090 1 0 {name=M1540
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 21070 120 21070 {
lab=word351}
N 120 21070 160 21070 {
lab=word351}
N 90 21060 90 21110 {
lab=GND}
N 90 21110 90 21120 {
lab=GND}
N 150 21060 150 21110 {
lab=Y1}
N 150 21110 150 21120 {
lab=Y1}

N 170 21120 200 21120 {
lab=GND}
N 200 21110 200 21120 {
lab=GND}
N 160 21070 200 21070 {
lab=word351}
N 200 21070 240 21070 {
lab=word351}
N 170 21060 170 21110 {
lab=GND}
N 170 21110 170 21120 {
lab=GND}
N 230 21060 230 21110 {
lab=Y2}
N 230 21110 230 21120 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 21090 1 0 {name=M1541
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 21120 280 21120 {
lab=GND}
N 280 21110 280 21120 {
lab=GND}
N 240 21070 280 21070 {
lab=word351}
N 280 21070 320 21070 {
lab=word351}
N 250 21060 250 21110 {
lab=GND}
N 250 21110 250 21120 {
lab=GND}
N 310 21060 310 21110 {
lab=Y3}
N 310 21110 310 21120 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 21090 1 0 {name=M1542
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 21120 360 21120 {
lab=GND}
N 360 21110 360 21120 {
lab=GND}
N 320 21070 360 21070 {
lab=word351}
N 360 21070 400 21070 {
lab=word351}
N 330 21060 330 21110 {
lab=GND}
N 330 21110 330 21120 {
lab=GND}
N 390 21060 390 21110 {
lab=Y4}
N 390 21110 390 21120 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 21090 1 0 {name=M1543
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 21120 440 21120 {
lab=GND}
N 440 21110 440 21120 {
lab=GND}
N 400 21070 440 21070 {
lab=word351}
N 440 21070 480 21070 {
lab=word351}
N 410 21060 410 21110 {
lab=GND}
N 410 21110 410 21120 {
lab=GND}
N 470 21060 470 21110 {
lab=Y5}
N 470 21110 470 21120 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 21090 1 0 {name=M1544
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 21070 520 21070 {
lab=word351}
N 520 21070 560 21070 {
lab=word351}
N 490 21060 490 21110 {
lab=GND}
N 490 21110 490 21120 {
lab=GND}
N 550 21060 550 21110 {
lab=Y6}
N 550 21110 550 21120 {
lab=Y6}

N 570 21120 600 21120 {
lab=GND}
N 600 21110 600 21120 {
lab=GND}
N 560 21070 600 21070 {
lab=word351}
N 600 21070 640 21070 {
lab=word351}
N 570 21060 570 21110 {
lab=GND}
N 570 21110 570 21120 {
lab=GND}
N 630 21060 630 21110 {
lab=Y7}
N 630 21110 630 21120 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21090 1 0 {name=M1545
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21130 0 0 {name=p375 lab=word352}

N 10 21180 40 21180 {
lab=GND}
N 40 21170 40 21180 {
lab=GND}
N 0 21130 40 21130 {
lab=word352}
N 40 21130 80 21130 {
lab=word352}
N 10 21120 10 21170 {
lab=GND}
N 10 21170 10 21180 {
lab=GND}
N 70 21120 70 21170 {
lab=Y0}
N 70 21170 70 21180 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21150 1 0 {name=M1546
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 80 21130 120 21130 {
lab=word352}
N 120 21130 160 21130 {
lab=word352}
N 90 21120 90 21170 {
lab=GND}
N 90 21170 90 21180 {
lab=GND}
N 150 21120 150 21170 {
lab=Y1}
N 150 21170 150 21180 {
lab=Y1}

N 170 21180 200 21180 {
lab=GND}
N 200 21170 200 21180 {
lab=GND}
N 160 21130 200 21130 {
lab=word352}
N 200 21130 240 21130 {
lab=word352}
N 170 21120 170 21170 {
lab=GND}
N 170 21170 170 21180 {
lab=GND}
N 230 21120 230 21170 {
lab=Y2}
N 230 21170 230 21180 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 21150 1 0 {name=M1547
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 21180 280 21180 {
lab=GND}
N 280 21170 280 21180 {
lab=GND}
N 240 21130 280 21130 {
lab=word352}
N 280 21130 320 21130 {
lab=word352}
N 250 21120 250 21170 {
lab=GND}
N 250 21170 250 21180 {
lab=GND}
N 310 21120 310 21170 {
lab=Y3}
N 310 21170 310 21180 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 21150 1 0 {name=M1548
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 21180 360 21180 {
lab=GND}
N 360 21170 360 21180 {
lab=GND}
N 320 21130 360 21130 {
lab=word352}
N 360 21130 400 21130 {
lab=word352}
N 330 21120 330 21170 {
lab=GND}
N 330 21170 330 21180 {
lab=GND}
N 390 21120 390 21170 {
lab=Y4}
N 390 21170 390 21180 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 21150 1 0 {name=M1549
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 21180 440 21180 {
lab=GND}
N 440 21170 440 21180 {
lab=GND}
N 400 21130 440 21130 {
lab=word352}
N 440 21130 480 21130 {
lab=word352}
N 410 21120 410 21170 {
lab=GND}
N 410 21170 410 21180 {
lab=GND}
N 470 21120 470 21170 {
lab=Y5}
N 470 21170 470 21180 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 21150 1 0 {name=M1550
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 21180 520 21180 {
lab=GND}
N 520 21170 520 21180 {
lab=GND}
N 480 21130 520 21130 {
lab=word352}
N 520 21130 560 21130 {
lab=word352}
N 490 21120 490 21170 {
lab=GND}
N 490 21170 490 21180 {
lab=GND}
N 550 21120 550 21170 {
lab=Y6}
N 550 21170 550 21180 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 21150 1 0 {name=M1551
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 21180 600 21180 {
lab=GND}
N 600 21170 600 21180 {
lab=GND}
N 560 21130 600 21130 {
lab=word352}
N 600 21130 640 21130 {
lab=word352}
N 570 21120 570 21170 {
lab=GND}
N 570 21170 570 21180 {
lab=GND}
N 630 21120 630 21170 {
lab=Y7}
N 630 21170 630 21180 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21150 1 0 {name=M1552
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21190 0 0 {name=p376 lab=word353}

N 10 21240 40 21240 {
lab=GND}
N 40 21230 40 21240 {
lab=GND}
N 0 21190 40 21190 {
lab=word353}
N 40 21190 80 21190 {
lab=word353}
N 10 21180 10 21230 {
lab=GND}
N 10 21230 10 21240 {
lab=GND}
N 70 21180 70 21230 {
lab=Y0}
N 70 21230 70 21240 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21210 1 0 {name=M1553
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21240 120 21240 {
lab=GND}
N 120 21230 120 21240 {
lab=GND}
N 80 21190 120 21190 {
lab=word353}
N 120 21190 160 21190 {
lab=word353}
N 90 21180 90 21230 {
lab=GND}
N 90 21230 90 21240 {
lab=GND}
N 150 21180 150 21230 {
lab=Y1}
N 150 21230 150 21240 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21210 1 0 {name=M1554
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21190 200 21190 {
lab=word353}
N 200 21190 240 21190 {
lab=word353}
N 170 21180 170 21230 {
lab=GND}
N 170 21230 170 21240 {
lab=GND}
N 230 21180 230 21230 {
lab=Y2}
N 230 21230 230 21240 {
lab=Y2}
N 240 21190 280 21190 {
lab=word353}
N 280 21190 320 21190 {
lab=word353}
N 250 21180 250 21230 {
lab=GND}
N 250 21230 250 21240 {
lab=GND}
N 310 21180 310 21230 {
lab=Y3}
N 310 21230 310 21240 {
lab=Y3}
N 320 21190 360 21190 {
lab=word353}
N 360 21190 400 21190 {
lab=word353}
N 330 21180 330 21230 {
lab=GND}
N 330 21230 330 21240 {
lab=GND}
N 390 21180 390 21230 {
lab=Y4}
N 390 21230 390 21240 {
lab=Y4}
N 400 21190 440 21190 {
lab=word353}
N 440 21190 480 21190 {
lab=word353}
N 410 21180 410 21230 {
lab=GND}
N 410 21230 410 21240 {
lab=GND}
N 470 21180 470 21230 {
lab=Y5}
N 470 21230 470 21240 {
lab=Y5}
N 480 21190 520 21190 {
lab=word353}
N 520 21190 560 21190 {
lab=word353}
N 490 21180 490 21230 {
lab=GND}
N 490 21230 490 21240 {
lab=GND}
N 550 21180 550 21230 {
lab=Y6}
N 550 21230 550 21240 {
lab=Y6}

N 570 21240 600 21240 {
lab=GND}
N 600 21230 600 21240 {
lab=GND}
N 560 21190 600 21190 {
lab=word353}
N 600 21190 640 21190 {
lab=word353}
N 570 21180 570 21230 {
lab=GND}
N 570 21230 570 21240 {
lab=GND}
N 630 21180 630 21230 {
lab=Y7}
N 630 21230 630 21240 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21210 1 0 {name=M1555
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21250 0 0 {name=p377 lab=word354}

N 10 21300 40 21300 {
lab=GND}
N 40 21290 40 21300 {
lab=GND}
N 0 21250 40 21250 {
lab=word354}
N 40 21250 80 21250 {
lab=word354}
N 10 21240 10 21290 {
lab=GND}
N 10 21290 10 21300 {
lab=GND}
N 70 21240 70 21290 {
lab=Y0}
N 70 21290 70 21300 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21270 1 0 {name=M1556
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21300 120 21300 {
lab=GND}
N 120 21290 120 21300 {
lab=GND}
N 80 21250 120 21250 {
lab=word354}
N 120 21250 160 21250 {
lab=word354}
N 90 21240 90 21290 {
lab=GND}
N 90 21290 90 21300 {
lab=GND}
N 150 21240 150 21290 {
lab=Y1}
N 150 21290 150 21300 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21270 1 0 {name=M1557
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21250 200 21250 {
lab=word354}
N 200 21250 240 21250 {
lab=word354}
N 170 21240 170 21290 {
lab=GND}
N 170 21290 170 21300 {
lab=GND}
N 230 21240 230 21290 {
lab=Y2}
N 230 21290 230 21300 {
lab=Y2}
N 240 21250 280 21250 {
lab=word354}
N 280 21250 320 21250 {
lab=word354}
N 250 21240 250 21290 {
lab=GND}
N 250 21290 250 21300 {
lab=GND}
N 310 21240 310 21290 {
lab=Y3}
N 310 21290 310 21300 {
lab=Y3}
N 320 21250 360 21250 {
lab=word354}
N 360 21250 400 21250 {
lab=word354}
N 330 21240 330 21290 {
lab=GND}
N 330 21290 330 21300 {
lab=GND}
N 390 21240 390 21290 {
lab=Y4}
N 390 21290 390 21300 {
lab=Y4}
N 400 21250 440 21250 {
lab=word354}
N 440 21250 480 21250 {
lab=word354}
N 410 21240 410 21290 {
lab=GND}
N 410 21290 410 21300 {
lab=GND}
N 470 21240 470 21290 {
lab=Y5}
N 470 21290 470 21300 {
lab=Y5}

N 490 21300 520 21300 {
lab=GND}
N 520 21290 520 21300 {
lab=GND}
N 480 21250 520 21250 {
lab=word354}
N 520 21250 560 21250 {
lab=word354}
N 490 21240 490 21290 {
lab=GND}
N 490 21290 490 21300 {
lab=GND}
N 550 21240 550 21290 {
lab=Y6}
N 550 21290 550 21300 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 21270 1 0 {name=M1558
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 21300 600 21300 {
lab=GND}
N 600 21290 600 21300 {
lab=GND}
N 560 21250 600 21250 {
lab=word354}
N 600 21250 640 21250 {
lab=word354}
N 570 21240 570 21290 {
lab=GND}
N 570 21290 570 21300 {
lab=GND}
N 630 21240 630 21290 {
lab=Y7}
N 630 21290 630 21300 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21270 1 0 {name=M1559
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21310 0 0 {name=p378 lab=word355}

N 10 21360 40 21360 {
lab=GND}
N 40 21350 40 21360 {
lab=GND}
N 0 21310 40 21310 {
lab=word355}
N 40 21310 80 21310 {
lab=word355}
N 10 21300 10 21350 {
lab=GND}
N 10 21350 10 21360 {
lab=GND}
N 70 21300 70 21350 {
lab=Y0}
N 70 21350 70 21360 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21330 1 0 {name=M1560
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21360 120 21360 {
lab=GND}
N 120 21350 120 21360 {
lab=GND}
N 80 21310 120 21310 {
lab=word355}
N 120 21310 160 21310 {
lab=word355}
N 90 21300 90 21350 {
lab=GND}
N 90 21350 90 21360 {
lab=GND}
N 150 21300 150 21350 {
lab=Y1}
N 150 21350 150 21360 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21330 1 0 {name=M1561
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21310 200 21310 {
lab=word355}
N 200 21310 240 21310 {
lab=word355}
N 170 21300 170 21350 {
lab=GND}
N 170 21350 170 21360 {
lab=GND}
N 230 21300 230 21350 {
lab=Y2}
N 230 21350 230 21360 {
lab=Y2}
N 240 21310 280 21310 {
lab=word355}
N 280 21310 320 21310 {
lab=word355}
N 250 21300 250 21350 {
lab=GND}
N 250 21350 250 21360 {
lab=GND}
N 310 21300 310 21350 {
lab=Y3}
N 310 21350 310 21360 {
lab=Y3}
N 320 21310 360 21310 {
lab=word355}
N 360 21310 400 21310 {
lab=word355}
N 330 21300 330 21350 {
lab=GND}
N 330 21350 330 21360 {
lab=GND}
N 390 21300 390 21350 {
lab=Y4}
N 390 21350 390 21360 {
lab=Y4}

N 410 21360 440 21360 {
lab=GND}
N 440 21350 440 21360 {
lab=GND}
N 400 21310 440 21310 {
lab=word355}
N 440 21310 480 21310 {
lab=word355}
N 410 21300 410 21350 {
lab=GND}
N 410 21350 410 21360 {
lab=GND}
N 470 21300 470 21350 {
lab=Y5}
N 470 21350 470 21360 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 21330 1 0 {name=M1562
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 21310 520 21310 {
lab=word355}
N 520 21310 560 21310 {
lab=word355}
N 490 21300 490 21350 {
lab=GND}
N 490 21350 490 21360 {
lab=GND}
N 550 21300 550 21350 {
lab=Y6}
N 550 21350 550 21360 {
lab=Y6}

N 570 21360 600 21360 {
lab=GND}
N 600 21350 600 21360 {
lab=GND}
N 560 21310 600 21310 {
lab=word355}
N 600 21310 640 21310 {
lab=word355}
N 570 21300 570 21350 {
lab=GND}
N 570 21350 570 21360 {
lab=GND}
N 630 21300 630 21350 {
lab=Y7}
N 630 21350 630 21360 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21330 1 0 {name=M1563
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21370 0 0 {name=p379 lab=word356}

N 10 21420 40 21420 {
lab=GND}
N 40 21410 40 21420 {
lab=GND}
N 0 21370 40 21370 {
lab=word356}
N 40 21370 80 21370 {
lab=word356}
N 10 21360 10 21410 {
lab=GND}
N 10 21410 10 21420 {
lab=GND}
N 70 21360 70 21410 {
lab=Y0}
N 70 21410 70 21420 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21390 1 0 {name=M1564
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21420 120 21420 {
lab=GND}
N 120 21410 120 21420 {
lab=GND}
N 80 21370 120 21370 {
lab=word356}
N 120 21370 160 21370 {
lab=word356}
N 90 21360 90 21410 {
lab=GND}
N 90 21410 90 21420 {
lab=GND}
N 150 21360 150 21410 {
lab=Y1}
N 150 21410 150 21420 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21390 1 0 {name=M1565
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21370 200 21370 {
lab=word356}
N 200 21370 240 21370 {
lab=word356}
N 170 21360 170 21410 {
lab=GND}
N 170 21410 170 21420 {
lab=GND}
N 230 21360 230 21410 {
lab=Y2}
N 230 21410 230 21420 {
lab=Y2}
N 240 21370 280 21370 {
lab=word356}
N 280 21370 320 21370 {
lab=word356}
N 250 21360 250 21410 {
lab=GND}
N 250 21410 250 21420 {
lab=GND}
N 310 21360 310 21410 {
lab=Y3}
N 310 21410 310 21420 {
lab=Y3}
N 320 21370 360 21370 {
lab=word356}
N 360 21370 400 21370 {
lab=word356}
N 330 21360 330 21410 {
lab=GND}
N 330 21410 330 21420 {
lab=GND}
N 390 21360 390 21410 {
lab=Y4}
N 390 21410 390 21420 {
lab=Y4}

N 410 21420 440 21420 {
lab=GND}
N 440 21410 440 21420 {
lab=GND}
N 400 21370 440 21370 {
lab=word356}
N 440 21370 480 21370 {
lab=word356}
N 410 21360 410 21410 {
lab=GND}
N 410 21410 410 21420 {
lab=GND}
N 470 21360 470 21410 {
lab=Y5}
N 470 21410 470 21420 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 21390 1 0 {name=M1566
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 21420 520 21420 {
lab=GND}
N 520 21410 520 21420 {
lab=GND}
N 480 21370 520 21370 {
lab=word356}
N 520 21370 560 21370 {
lab=word356}
N 490 21360 490 21410 {
lab=GND}
N 490 21410 490 21420 {
lab=GND}
N 550 21360 550 21410 {
lab=Y6}
N 550 21410 550 21420 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 21390 1 0 {name=M1567
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 21420 600 21420 {
lab=GND}
N 600 21410 600 21420 {
lab=GND}
N 560 21370 600 21370 {
lab=word356}
N 600 21370 640 21370 {
lab=word356}
N 570 21360 570 21410 {
lab=GND}
N 570 21410 570 21420 {
lab=GND}
N 630 21360 630 21410 {
lab=Y7}
N 630 21410 630 21420 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21390 1 0 {name=M1568
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21430 0 0 {name=p380 lab=word357}

N 10 21480 40 21480 {
lab=GND}
N 40 21470 40 21480 {
lab=GND}
N 0 21430 40 21430 {
lab=word357}
N 40 21430 80 21430 {
lab=word357}
N 10 21420 10 21470 {
lab=GND}
N 10 21470 10 21480 {
lab=GND}
N 70 21420 70 21470 {
lab=Y0}
N 70 21470 70 21480 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21450 1 0 {name=M1569
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21480 120 21480 {
lab=GND}
N 120 21470 120 21480 {
lab=GND}
N 80 21430 120 21430 {
lab=word357}
N 120 21430 160 21430 {
lab=word357}
N 90 21420 90 21470 {
lab=GND}
N 90 21470 90 21480 {
lab=GND}
N 150 21420 150 21470 {
lab=Y1}
N 150 21470 150 21480 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21450 1 0 {name=M1570
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21430 200 21430 {
lab=word357}
N 200 21430 240 21430 {
lab=word357}
N 170 21420 170 21470 {
lab=GND}
N 170 21470 170 21480 {
lab=GND}
N 230 21420 230 21470 {
lab=Y2}
N 230 21470 230 21480 {
lab=Y2}
N 240 21430 280 21430 {
lab=word357}
N 280 21430 320 21430 {
lab=word357}
N 250 21420 250 21470 {
lab=GND}
N 250 21470 250 21480 {
lab=GND}
N 310 21420 310 21470 {
lab=Y3}
N 310 21470 310 21480 {
lab=Y3}

N 330 21480 360 21480 {
lab=GND}
N 360 21470 360 21480 {
lab=GND}
N 320 21430 360 21430 {
lab=word357}
N 360 21430 400 21430 {
lab=word357}
N 330 21420 330 21470 {
lab=GND}
N 330 21470 330 21480 {
lab=GND}
N 390 21420 390 21470 {
lab=Y4}
N 390 21470 390 21480 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 21450 1 0 {name=M1571
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 21430 440 21430 {
lab=word357}
N 440 21430 480 21430 {
lab=word357}
N 410 21420 410 21470 {
lab=GND}
N 410 21470 410 21480 {
lab=GND}
N 470 21420 470 21470 {
lab=Y5}
N 470 21470 470 21480 {
lab=Y5}
N 480 21430 520 21430 {
lab=word357}
N 520 21430 560 21430 {
lab=word357}
N 490 21420 490 21470 {
lab=GND}
N 490 21470 490 21480 {
lab=GND}
N 550 21420 550 21470 {
lab=Y6}
N 550 21470 550 21480 {
lab=Y6}

N 570 21480 600 21480 {
lab=GND}
N 600 21470 600 21480 {
lab=GND}
N 560 21430 600 21430 {
lab=word357}
N 600 21430 640 21430 {
lab=word357}
N 570 21420 570 21470 {
lab=GND}
N 570 21470 570 21480 {
lab=GND}
N 630 21420 630 21470 {
lab=Y7}
N 630 21470 630 21480 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21450 1 0 {name=M1572
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21490 0 0 {name=p381 lab=word358}

N 10 21540 40 21540 {
lab=GND}
N 40 21530 40 21540 {
lab=GND}
N 0 21490 40 21490 {
lab=word358}
N 40 21490 80 21490 {
lab=word358}
N 10 21480 10 21530 {
lab=GND}
N 10 21530 10 21540 {
lab=GND}
N 70 21480 70 21530 {
lab=Y0}
N 70 21530 70 21540 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21510 1 0 {name=M1573
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21540 120 21540 {
lab=GND}
N 120 21530 120 21540 {
lab=GND}
N 80 21490 120 21490 {
lab=word358}
N 120 21490 160 21490 {
lab=word358}
N 90 21480 90 21530 {
lab=GND}
N 90 21530 90 21540 {
lab=GND}
N 150 21480 150 21530 {
lab=Y1}
N 150 21530 150 21540 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21510 1 0 {name=M1574
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21490 200 21490 {
lab=word358}
N 200 21490 240 21490 {
lab=word358}
N 170 21480 170 21530 {
lab=GND}
N 170 21530 170 21540 {
lab=GND}
N 230 21480 230 21530 {
lab=Y2}
N 230 21530 230 21540 {
lab=Y2}
N 240 21490 280 21490 {
lab=word358}
N 280 21490 320 21490 {
lab=word358}
N 250 21480 250 21530 {
lab=GND}
N 250 21530 250 21540 {
lab=GND}
N 310 21480 310 21530 {
lab=Y3}
N 310 21530 310 21540 {
lab=Y3}

N 330 21540 360 21540 {
lab=GND}
N 360 21530 360 21540 {
lab=GND}
N 320 21490 360 21490 {
lab=word358}
N 360 21490 400 21490 {
lab=word358}
N 330 21480 330 21530 {
lab=GND}
N 330 21530 330 21540 {
lab=GND}
N 390 21480 390 21530 {
lab=Y4}
N 390 21530 390 21540 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 21510 1 0 {name=M1575
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 21490 440 21490 {
lab=word358}
N 440 21490 480 21490 {
lab=word358}
N 410 21480 410 21530 {
lab=GND}
N 410 21530 410 21540 {
lab=GND}
N 470 21480 470 21530 {
lab=Y5}
N 470 21530 470 21540 {
lab=Y5}

N 490 21540 520 21540 {
lab=GND}
N 520 21530 520 21540 {
lab=GND}
N 480 21490 520 21490 {
lab=word358}
N 520 21490 560 21490 {
lab=word358}
N 490 21480 490 21530 {
lab=GND}
N 490 21530 490 21540 {
lab=GND}
N 550 21480 550 21530 {
lab=Y6}
N 550 21530 550 21540 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 21510 1 0 {name=M1576
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 21540 600 21540 {
lab=GND}
N 600 21530 600 21540 {
lab=GND}
N 560 21490 600 21490 {
lab=word358}
N 600 21490 640 21490 {
lab=word358}
N 570 21480 570 21530 {
lab=GND}
N 570 21530 570 21540 {
lab=GND}
N 630 21480 630 21530 {
lab=Y7}
N 630 21530 630 21540 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21510 1 0 {name=M1577
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21550 0 0 {name=p382 lab=word359}

N 10 21600 40 21600 {
lab=GND}
N 40 21590 40 21600 {
lab=GND}
N 0 21550 40 21550 {
lab=word359}
N 40 21550 80 21550 {
lab=word359}
N 10 21540 10 21590 {
lab=GND}
N 10 21590 10 21600 {
lab=GND}
N 70 21540 70 21590 {
lab=Y0}
N 70 21590 70 21600 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21570 1 0 {name=M1578
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21600 120 21600 {
lab=GND}
N 120 21590 120 21600 {
lab=GND}
N 80 21550 120 21550 {
lab=word359}
N 120 21550 160 21550 {
lab=word359}
N 90 21540 90 21590 {
lab=GND}
N 90 21590 90 21600 {
lab=GND}
N 150 21540 150 21590 {
lab=Y1}
N 150 21590 150 21600 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21570 1 0 {name=M1579
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21550 200 21550 {
lab=word359}
N 200 21550 240 21550 {
lab=word359}
N 170 21540 170 21590 {
lab=GND}
N 170 21590 170 21600 {
lab=GND}
N 230 21540 230 21590 {
lab=Y2}
N 230 21590 230 21600 {
lab=Y2}
N 240 21550 280 21550 {
lab=word359}
N 280 21550 320 21550 {
lab=word359}
N 250 21540 250 21590 {
lab=GND}
N 250 21590 250 21600 {
lab=GND}
N 310 21540 310 21590 {
lab=Y3}
N 310 21590 310 21600 {
lab=Y3}

N 330 21600 360 21600 {
lab=GND}
N 360 21590 360 21600 {
lab=GND}
N 320 21550 360 21550 {
lab=word359}
N 360 21550 400 21550 {
lab=word359}
N 330 21540 330 21590 {
lab=GND}
N 330 21590 330 21600 {
lab=GND}
N 390 21540 390 21590 {
lab=Y4}
N 390 21590 390 21600 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 21570 1 0 {name=M1580
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 21600 440 21600 {
lab=GND}
N 440 21590 440 21600 {
lab=GND}
N 400 21550 440 21550 {
lab=word359}
N 440 21550 480 21550 {
lab=word359}
N 410 21540 410 21590 {
lab=GND}
N 410 21590 410 21600 {
lab=GND}
N 470 21540 470 21590 {
lab=Y5}
N 470 21590 470 21600 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 21570 1 0 {name=M1581
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 21550 520 21550 {
lab=word359}
N 520 21550 560 21550 {
lab=word359}
N 490 21540 490 21590 {
lab=GND}
N 490 21590 490 21600 {
lab=GND}
N 550 21540 550 21590 {
lab=Y6}
N 550 21590 550 21600 {
lab=Y6}

N 570 21600 600 21600 {
lab=GND}
N 600 21590 600 21600 {
lab=GND}
N 560 21550 600 21550 {
lab=word359}
N 600 21550 640 21550 {
lab=word359}
N 570 21540 570 21590 {
lab=GND}
N 570 21590 570 21600 {
lab=GND}
N 630 21540 630 21590 {
lab=Y7}
N 630 21590 630 21600 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21570 1 0 {name=M1582
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21610 0 0 {name=p383 lab=word360}

N 10 21660 40 21660 {
lab=GND}
N 40 21650 40 21660 {
lab=GND}
N 0 21610 40 21610 {
lab=word360}
N 40 21610 80 21610 {
lab=word360}
N 10 21600 10 21650 {
lab=GND}
N 10 21650 10 21660 {
lab=GND}
N 70 21600 70 21650 {
lab=Y0}
N 70 21650 70 21660 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21630 1 0 {name=M1583
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21660 120 21660 {
lab=GND}
N 120 21650 120 21660 {
lab=GND}
N 80 21610 120 21610 {
lab=word360}
N 120 21610 160 21610 {
lab=word360}
N 90 21600 90 21650 {
lab=GND}
N 90 21650 90 21660 {
lab=GND}
N 150 21600 150 21650 {
lab=Y1}
N 150 21650 150 21660 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21630 1 0 {name=M1584
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21610 200 21610 {
lab=word360}
N 200 21610 240 21610 {
lab=word360}
N 170 21600 170 21650 {
lab=GND}
N 170 21650 170 21660 {
lab=GND}
N 230 21600 230 21650 {
lab=Y2}
N 230 21650 230 21660 {
lab=Y2}
N 240 21610 280 21610 {
lab=word360}
N 280 21610 320 21610 {
lab=word360}
N 250 21600 250 21650 {
lab=GND}
N 250 21650 250 21660 {
lab=GND}
N 310 21600 310 21650 {
lab=Y3}
N 310 21650 310 21660 {
lab=Y3}

N 330 21660 360 21660 {
lab=GND}
N 360 21650 360 21660 {
lab=GND}
N 320 21610 360 21610 {
lab=word360}
N 360 21610 400 21610 {
lab=word360}
N 330 21600 330 21650 {
lab=GND}
N 330 21650 330 21660 {
lab=GND}
N 390 21600 390 21650 {
lab=Y4}
N 390 21650 390 21660 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 21630 1 0 {name=M1585
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 21660 440 21660 {
lab=GND}
N 440 21650 440 21660 {
lab=GND}
N 400 21610 440 21610 {
lab=word360}
N 440 21610 480 21610 {
lab=word360}
N 410 21600 410 21650 {
lab=GND}
N 410 21650 410 21660 {
lab=GND}
N 470 21600 470 21650 {
lab=Y5}
N 470 21650 470 21660 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 21630 1 0 {name=M1586
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 21660 520 21660 {
lab=GND}
N 520 21650 520 21660 {
lab=GND}
N 480 21610 520 21610 {
lab=word360}
N 520 21610 560 21610 {
lab=word360}
N 490 21600 490 21650 {
lab=GND}
N 490 21650 490 21660 {
lab=GND}
N 550 21600 550 21650 {
lab=Y6}
N 550 21650 550 21660 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 21630 1 0 {name=M1587
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 21660 600 21660 {
lab=GND}
N 600 21650 600 21660 {
lab=GND}
N 560 21610 600 21610 {
lab=word360}
N 600 21610 640 21610 {
lab=word360}
N 570 21600 570 21650 {
lab=GND}
N 570 21650 570 21660 {
lab=GND}
N 630 21600 630 21650 {
lab=Y7}
N 630 21650 630 21660 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21630 1 0 {name=M1588
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21670 0 0 {name=p384 lab=word361}

N 10 21720 40 21720 {
lab=GND}
N 40 21710 40 21720 {
lab=GND}
N 0 21670 40 21670 {
lab=word361}
N 40 21670 80 21670 {
lab=word361}
N 10 21660 10 21710 {
lab=GND}
N 10 21710 10 21720 {
lab=GND}
N 70 21660 70 21710 {
lab=Y0}
N 70 21710 70 21720 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21690 1 0 {name=M1589
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21720 120 21720 {
lab=GND}
N 120 21710 120 21720 {
lab=GND}
N 80 21670 120 21670 {
lab=word361}
N 120 21670 160 21670 {
lab=word361}
N 90 21660 90 21710 {
lab=GND}
N 90 21710 90 21720 {
lab=GND}
N 150 21660 150 21710 {
lab=Y1}
N 150 21710 150 21720 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21690 1 0 {name=M1590
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21670 200 21670 {
lab=word361}
N 200 21670 240 21670 {
lab=word361}
N 170 21660 170 21710 {
lab=GND}
N 170 21710 170 21720 {
lab=GND}
N 230 21660 230 21710 {
lab=Y2}
N 230 21710 230 21720 {
lab=Y2}

N 250 21720 280 21720 {
lab=GND}
N 280 21710 280 21720 {
lab=GND}
N 240 21670 280 21670 {
lab=word361}
N 280 21670 320 21670 {
lab=word361}
N 250 21660 250 21710 {
lab=GND}
N 250 21710 250 21720 {
lab=GND}
N 310 21660 310 21710 {
lab=Y3}
N 310 21710 310 21720 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 21690 1 0 {name=M1591
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 21670 360 21670 {
lab=word361}
N 360 21670 400 21670 {
lab=word361}
N 330 21660 330 21710 {
lab=GND}
N 330 21710 330 21720 {
lab=GND}
N 390 21660 390 21710 {
lab=Y4}
N 390 21710 390 21720 {
lab=Y4}
N 400 21670 440 21670 {
lab=word361}
N 440 21670 480 21670 {
lab=word361}
N 410 21660 410 21710 {
lab=GND}
N 410 21710 410 21720 {
lab=GND}
N 470 21660 470 21710 {
lab=Y5}
N 470 21710 470 21720 {
lab=Y5}
N 480 21670 520 21670 {
lab=word361}
N 520 21670 560 21670 {
lab=word361}
N 490 21660 490 21710 {
lab=GND}
N 490 21710 490 21720 {
lab=GND}
N 550 21660 550 21710 {
lab=Y6}
N 550 21710 550 21720 {
lab=Y6}

N 570 21720 600 21720 {
lab=GND}
N 600 21710 600 21720 {
lab=GND}
N 560 21670 600 21670 {
lab=word361}
N 600 21670 640 21670 {
lab=word361}
N 570 21660 570 21710 {
lab=GND}
N 570 21710 570 21720 {
lab=GND}
N 630 21660 630 21710 {
lab=Y7}
N 630 21710 630 21720 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21690 1 0 {name=M1592
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21730 0 0 {name=p385 lab=word362}

N 10 21780 40 21780 {
lab=GND}
N 40 21770 40 21780 {
lab=GND}
N 0 21730 40 21730 {
lab=word362}
N 40 21730 80 21730 {
lab=word362}
N 10 21720 10 21770 {
lab=GND}
N 10 21770 10 21780 {
lab=GND}
N 70 21720 70 21770 {
lab=Y0}
N 70 21770 70 21780 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21750 1 0 {name=M1593
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21780 120 21780 {
lab=GND}
N 120 21770 120 21780 {
lab=GND}
N 80 21730 120 21730 {
lab=word362}
N 120 21730 160 21730 {
lab=word362}
N 90 21720 90 21770 {
lab=GND}
N 90 21770 90 21780 {
lab=GND}
N 150 21720 150 21770 {
lab=Y1}
N 150 21770 150 21780 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21750 1 0 {name=M1594
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21730 200 21730 {
lab=word362}
N 200 21730 240 21730 {
lab=word362}
N 170 21720 170 21770 {
lab=GND}
N 170 21770 170 21780 {
lab=GND}
N 230 21720 230 21770 {
lab=Y2}
N 230 21770 230 21780 {
lab=Y2}

N 250 21780 280 21780 {
lab=GND}
N 280 21770 280 21780 {
lab=GND}
N 240 21730 280 21730 {
lab=word362}
N 280 21730 320 21730 {
lab=word362}
N 250 21720 250 21770 {
lab=GND}
N 250 21770 250 21780 {
lab=GND}
N 310 21720 310 21770 {
lab=Y3}
N 310 21770 310 21780 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 21750 1 0 {name=M1595
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 21730 360 21730 {
lab=word362}
N 360 21730 400 21730 {
lab=word362}
N 330 21720 330 21770 {
lab=GND}
N 330 21770 330 21780 {
lab=GND}
N 390 21720 390 21770 {
lab=Y4}
N 390 21770 390 21780 {
lab=Y4}
N 400 21730 440 21730 {
lab=word362}
N 440 21730 480 21730 {
lab=word362}
N 410 21720 410 21770 {
lab=GND}
N 410 21770 410 21780 {
lab=GND}
N 470 21720 470 21770 {
lab=Y5}
N 470 21770 470 21780 {
lab=Y5}

N 490 21780 520 21780 {
lab=GND}
N 520 21770 520 21780 {
lab=GND}
N 480 21730 520 21730 {
lab=word362}
N 520 21730 560 21730 {
lab=word362}
N 490 21720 490 21770 {
lab=GND}
N 490 21770 490 21780 {
lab=GND}
N 550 21720 550 21770 {
lab=Y6}
N 550 21770 550 21780 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 21750 1 0 {name=M1596
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 21780 600 21780 {
lab=GND}
N 600 21770 600 21780 {
lab=GND}
N 560 21730 600 21730 {
lab=word362}
N 600 21730 640 21730 {
lab=word362}
N 570 21720 570 21770 {
lab=GND}
N 570 21770 570 21780 {
lab=GND}
N 630 21720 630 21770 {
lab=Y7}
N 630 21770 630 21780 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21750 1 0 {name=M1597
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21790 0 0 {name=p386 lab=word363}

N 10 21840 40 21840 {
lab=GND}
N 40 21830 40 21840 {
lab=GND}
N 0 21790 40 21790 {
lab=word363}
N 40 21790 80 21790 {
lab=word363}
N 10 21780 10 21830 {
lab=GND}
N 10 21830 10 21840 {
lab=GND}
N 70 21780 70 21830 {
lab=Y0}
N 70 21830 70 21840 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21810 1 0 {name=M1598
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21840 120 21840 {
lab=GND}
N 120 21830 120 21840 {
lab=GND}
N 80 21790 120 21790 {
lab=word363}
N 120 21790 160 21790 {
lab=word363}
N 90 21780 90 21830 {
lab=GND}
N 90 21830 90 21840 {
lab=GND}
N 150 21780 150 21830 {
lab=Y1}
N 150 21830 150 21840 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21810 1 0 {name=M1599
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21790 200 21790 {
lab=word363}
N 200 21790 240 21790 {
lab=word363}
N 170 21780 170 21830 {
lab=GND}
N 170 21830 170 21840 {
lab=GND}
N 230 21780 230 21830 {
lab=Y2}
N 230 21830 230 21840 {
lab=Y2}

N 250 21840 280 21840 {
lab=GND}
N 280 21830 280 21840 {
lab=GND}
N 240 21790 280 21790 {
lab=word363}
N 280 21790 320 21790 {
lab=word363}
N 250 21780 250 21830 {
lab=GND}
N 250 21830 250 21840 {
lab=GND}
N 310 21780 310 21830 {
lab=Y3}
N 310 21830 310 21840 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 21810 1 0 {name=M1600
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 21790 360 21790 {
lab=word363}
N 360 21790 400 21790 {
lab=word363}
N 330 21780 330 21830 {
lab=GND}
N 330 21830 330 21840 {
lab=GND}
N 390 21780 390 21830 {
lab=Y4}
N 390 21830 390 21840 {
lab=Y4}

N 410 21840 440 21840 {
lab=GND}
N 440 21830 440 21840 {
lab=GND}
N 400 21790 440 21790 {
lab=word363}
N 440 21790 480 21790 {
lab=word363}
N 410 21780 410 21830 {
lab=GND}
N 410 21830 410 21840 {
lab=GND}
N 470 21780 470 21830 {
lab=Y5}
N 470 21830 470 21840 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 21810 1 0 {name=M1601
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 21790 520 21790 {
lab=word363}
N 520 21790 560 21790 {
lab=word363}
N 490 21780 490 21830 {
lab=GND}
N 490 21830 490 21840 {
lab=GND}
N 550 21780 550 21830 {
lab=Y6}
N 550 21830 550 21840 {
lab=Y6}

N 570 21840 600 21840 {
lab=GND}
N 600 21830 600 21840 {
lab=GND}
N 560 21790 600 21790 {
lab=word363}
N 600 21790 640 21790 {
lab=word363}
N 570 21780 570 21830 {
lab=GND}
N 570 21830 570 21840 {
lab=GND}
N 630 21780 630 21830 {
lab=Y7}
N 630 21830 630 21840 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21810 1 0 {name=M1602
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21850 0 0 {name=p387 lab=word364}

N 10 21900 40 21900 {
lab=GND}
N 40 21890 40 21900 {
lab=GND}
N 0 21850 40 21850 {
lab=word364}
N 40 21850 80 21850 {
lab=word364}
N 10 21840 10 21890 {
lab=GND}
N 10 21890 10 21900 {
lab=GND}
N 70 21840 70 21890 {
lab=Y0}
N 70 21890 70 21900 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21870 1 0 {name=M1603
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21900 120 21900 {
lab=GND}
N 120 21890 120 21900 {
lab=GND}
N 80 21850 120 21850 {
lab=word364}
N 120 21850 160 21850 {
lab=word364}
N 90 21840 90 21890 {
lab=GND}
N 90 21890 90 21900 {
lab=GND}
N 150 21840 150 21890 {
lab=Y1}
N 150 21890 150 21900 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21870 1 0 {name=M1604
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21850 200 21850 {
lab=word364}
N 200 21850 240 21850 {
lab=word364}
N 170 21840 170 21890 {
lab=GND}
N 170 21890 170 21900 {
lab=GND}
N 230 21840 230 21890 {
lab=Y2}
N 230 21890 230 21900 {
lab=Y2}

N 250 21900 280 21900 {
lab=GND}
N 280 21890 280 21900 {
lab=GND}
N 240 21850 280 21850 {
lab=word364}
N 280 21850 320 21850 {
lab=word364}
N 250 21840 250 21890 {
lab=GND}
N 250 21890 250 21900 {
lab=GND}
N 310 21840 310 21890 {
lab=Y3}
N 310 21890 310 21900 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 21870 1 0 {name=M1605
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 21850 360 21850 {
lab=word364}
N 360 21850 400 21850 {
lab=word364}
N 330 21840 330 21890 {
lab=GND}
N 330 21890 330 21900 {
lab=GND}
N 390 21840 390 21890 {
lab=Y4}
N 390 21890 390 21900 {
lab=Y4}

N 410 21900 440 21900 {
lab=GND}
N 440 21890 440 21900 {
lab=GND}
N 400 21850 440 21850 {
lab=word364}
N 440 21850 480 21850 {
lab=word364}
N 410 21840 410 21890 {
lab=GND}
N 410 21890 410 21900 {
lab=GND}
N 470 21840 470 21890 {
lab=Y5}
N 470 21890 470 21900 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 21870 1 0 {name=M1606
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 21900 520 21900 {
lab=GND}
N 520 21890 520 21900 {
lab=GND}
N 480 21850 520 21850 {
lab=word364}
N 520 21850 560 21850 {
lab=word364}
N 490 21840 490 21890 {
lab=GND}
N 490 21890 490 21900 {
lab=GND}
N 550 21840 550 21890 {
lab=Y6}
N 550 21890 550 21900 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 21870 1 0 {name=M1607
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 21900 600 21900 {
lab=GND}
N 600 21890 600 21900 {
lab=GND}
N 560 21850 600 21850 {
lab=word364}
N 600 21850 640 21850 {
lab=word364}
N 570 21840 570 21890 {
lab=GND}
N 570 21890 570 21900 {
lab=GND}
N 630 21840 630 21890 {
lab=Y7}
N 630 21890 630 21900 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21870 1 0 {name=M1608
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 21910 0 0 {name=p388 lab=word365}

N 10 21960 40 21960 {
lab=GND}
N 40 21950 40 21960 {
lab=GND}
N 0 21910 40 21910 {
lab=word365}
N 40 21910 80 21910 {
lab=word365}
N 10 21900 10 21950 {
lab=GND}
N 10 21950 10 21960 {
lab=GND}
N 70 21900 70 21950 {
lab=Y0}
N 70 21950 70 21960 {
lab=Y0}
C {sky130_fd_pr/nfet_01v8.sym} 40 21930 1 0 {name=M1609
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 90 21960 120 21960 {
lab=GND}
N 120 21950 120 21960 {
lab=GND}
N 80 21910 120 21910 {
lab=word365}
N 120 21910 160 21910 {
lab=word365}
N 90 21900 90 21950 {
lab=GND}
N 90 21950 90 21960 {
lab=GND}
N 150 21900 150 21950 {
lab=Y1}
N 150 21950 150 21960 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 21930 1 0 {name=M1610
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 21910 200 21910 {
lab=word365}
N 200 21910 240 21910 {
lab=word365}
N 170 21900 170 21950 {
lab=GND}
N 170 21950 170 21960 {
lab=GND}
N 230 21900 230 21950 {
lab=Y2}
N 230 21950 230 21960 {
lab=Y2}

N 250 21960 280 21960 {
lab=GND}
N 280 21950 280 21960 {
lab=GND}
N 240 21910 280 21910 {
lab=word365}
N 280 21910 320 21910 {
lab=word365}
N 250 21900 250 21950 {
lab=GND}
N 250 21950 250 21960 {
lab=GND}
N 310 21900 310 21950 {
lab=Y3}
N 310 21950 310 21960 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 21930 1 0 {name=M1611
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 21960 360 21960 {
lab=GND}
N 360 21950 360 21960 {
lab=GND}
N 320 21910 360 21910 {
lab=word365}
N 360 21910 400 21910 {
lab=word365}
N 330 21900 330 21950 {
lab=GND}
N 330 21950 330 21960 {
lab=GND}
N 390 21900 390 21950 {
lab=Y4}
N 390 21950 390 21960 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 21930 1 0 {name=M1612
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 21910 440 21910 {
lab=word365}
N 440 21910 480 21910 {
lab=word365}
N 410 21900 410 21950 {
lab=GND}
N 410 21950 410 21960 {
lab=GND}
N 470 21900 470 21950 {
lab=Y5}
N 470 21950 470 21960 {
lab=Y5}
N 480 21910 520 21910 {
lab=word365}
N 520 21910 560 21910 {
lab=word365}
N 490 21900 490 21950 {
lab=GND}
N 490 21950 490 21960 {
lab=GND}
N 550 21900 550 21950 {
lab=Y6}
N 550 21950 550 21960 {
lab=Y6}

N 570 21960 600 21960 {
lab=GND}
N 600 21950 600 21960 {
lab=GND}
N 560 21910 600 21910 {
lab=word365}
N 600 21910 640 21910 {
lab=word365}
N 570 21900 570 21950 {
lab=GND}
N 570 21950 570 21960 {
lab=GND}
N 630 21900 630 21950 {
lab=Y7}
N 630 21950 630 21960 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 21930 1 0 {name=M1613
L=0.15
W=1
nf=1 
mult=1
