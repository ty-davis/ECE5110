N 280 29050 320 29050 {
lab=word484}
N 250 29040 250 29090 {
lab=GND}
N 250 29090 250 29100 {
lab=GND}
N 310 29040 310 29090 {
lab=Y3}
N 310 29090 310 29100 {
lab=Y3}
N 320 29050 360 29050 {
lab=word484}
N 360 29050 400 29050 {
lab=word484}
N 330 29040 330 29090 {
lab=GND}
N 330 29090 330 29100 {
lab=GND}
N 390 29040 390 29090 {
lab=Y4}
N 390 29090 390 29100 {
lab=Y4}

N 410 29100 440 29100 {
lab=GND}
N 440 29090 440 29100 {
lab=GND}
N 400 29050 440 29050 {
lab=word484}
N 440 29050 480 29050 {
lab=word484}
N 410 29040 410 29090 {
lab=GND}
N 410 29090 410 29100 {
lab=GND}
N 470 29040 470 29090 {
lab=Y5}
N 470 29090 470 29100 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 29070 1 0 {name=M2148
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 29100 520 29100 {
lab=GND}
N 520 29090 520 29100 {
lab=GND}
N 480 29050 520 29050 {
lab=word484}
N 520 29050 560 29050 {
lab=word484}
N 490 29040 490 29090 {
lab=GND}
N 490 29090 490 29100 {
lab=GND}
N 550 29040 550 29090 {
lab=Y6}
N 550 29090 550 29100 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 29070 1 0 {name=M2149
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 29100 600 29100 {
lab=GND}
N 600 29090 600 29100 {
lab=GND}
N 560 29050 600 29050 {
lab=word484}
N 600 29050 640 29050 {
lab=word484}
N 570 29040 570 29090 {
lab=GND}
N 570 29090 570 29100 {
lab=GND}
N 630 29040 630 29090 {
lab=Y7}
N 630 29090 630 29100 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29070 1 0 {name=M2150
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 29110 0 0 {name=p508 lab=word485}
N 0 29110 40 29110 {
lab=word485}
N 40 29110 80 29110 {
lab=word485}
N 10 29100 10 29150 {
lab=GND}
N 10 29150 10 29160 {
lab=GND}
N 70 29100 70 29150 {
lab=Y0}
N 70 29150 70 29160 {
lab=Y0}

N 90 29160 120 29160 {
lab=GND}
N 120 29150 120 29160 {
lab=GND}
N 80 29110 120 29110 {
lab=word485}
N 120 29110 160 29110 {
lab=word485}
N 90 29100 90 29150 {
lab=GND}
N 90 29150 90 29160 {
lab=GND}
N 150 29100 150 29150 {
lab=Y1}
N 150 29150 150 29160 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 29130 1 0 {name=M2151
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 170 29160 200 29160 {
lab=GND}
N 200 29150 200 29160 {
lab=GND}
N 160 29110 200 29110 {
lab=word485}
N 200 29110 240 29110 {
lab=word485}
N 170 29100 170 29150 {
lab=GND}
N 170 29150 170 29160 {
lab=GND}
N 230 29100 230 29150 {
lab=Y2}
N 230 29150 230 29160 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 29130 1 0 {name=M2152
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 29110 280 29110 {
lab=word485}
N 280 29110 320 29110 {
lab=word485}
N 250 29100 250 29150 {
lab=GND}
N 250 29150 250 29160 {
lab=GND}
N 310 29100 310 29150 {
lab=Y3}
N 310 29150 310 29160 {
lab=Y3}
N 320 29110 360 29110 {
lab=word485}
N 360 29110 400 29110 {
lab=word485}
N 330 29100 330 29150 {
lab=GND}
N 330 29150 330 29160 {
lab=GND}
N 390 29100 390 29150 {
lab=Y4}
N 390 29150 390 29160 {
lab=Y4}
N 400 29110 440 29110 {
lab=word485}
N 440 29110 480 29110 {
lab=word485}
N 410 29100 410 29150 {
lab=GND}
N 410 29150 410 29160 {
lab=GND}
N 470 29100 470 29150 {
lab=Y5}
N 470 29150 470 29160 {
lab=Y5}
N 480 29110 520 29110 {
lab=word485}
N 520 29110 560 29110 {
lab=word485}
N 490 29100 490 29150 {
lab=GND}
N 490 29150 490 29160 {
lab=GND}
N 550 29100 550 29150 {
lab=Y6}
N 550 29150 550 29160 {
lab=Y6}

N 570 29160 600 29160 {
lab=GND}
N 600 29150 600 29160 {
lab=GND}
N 560 29110 600 29110 {
lab=word485}
N 600 29110 640 29110 {
lab=word485}
N 570 29100 570 29150 {
lab=GND}
N 570 29150 570 29160 {
lab=GND}
N 630 29100 630 29150 {
lab=Y7}
N 630 29150 630 29160 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29130 1 0 {name=M2153
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 29170 0 0 {name=p509 lab=word486}
N 0 29170 40 29170 {
lab=word486}
N 40 29170 80 29170 {
lab=word486}
N 10 29160 10 29210 {
lab=GND}
N 10 29210 10 29220 {
lab=GND}
N 70 29160 70 29210 {
lab=Y0}
N 70 29210 70 29220 {
lab=Y0}

N 90 29220 120 29220 {
lab=GND}
N 120 29210 120 29220 {
lab=GND}
N 80 29170 120 29170 {
lab=word486}
N 120 29170 160 29170 {
lab=word486}
N 90 29160 90 29210 {
lab=GND}
N 90 29210 90 29220 {
lab=GND}
N 150 29160 150 29210 {
lab=Y1}
N 150 29210 150 29220 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 29190 1 0 {name=M2154
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 29170 200 29170 {
lab=word486}
N 200 29170 240 29170 {
lab=word486}
N 170 29160 170 29210 {
lab=GND}
N 170 29210 170 29220 {
lab=GND}
N 230 29160 230 29210 {
lab=Y2}
N 230 29210 230 29220 {
lab=Y2}

N 250 29220 280 29220 {
lab=GND}
N 280 29210 280 29220 {
lab=GND}
N 240 29170 280 29170 {
lab=word486}
N 280 29170 320 29170 {
lab=word486}
N 250 29160 250 29210 {
lab=GND}
N 250 29210 250 29220 {
lab=GND}
N 310 29160 310 29210 {
lab=Y3}
N 310 29210 310 29220 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 29190 1 0 {name=M2155
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 29220 360 29220 {
lab=GND}
N 360 29210 360 29220 {
lab=GND}
N 320 29170 360 29170 {
lab=word486}
N 360 29170 400 29170 {
lab=word486}
N 330 29160 330 29210 {
lab=GND}
N 330 29210 330 29220 {
lab=GND}
N 390 29160 390 29210 {
lab=Y4}
N 390 29210 390 29220 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 29190 1 0 {name=M2156
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 29170 440 29170 {
lab=word486}
N 440 29170 480 29170 {
lab=word486}
N 410 29160 410 29210 {
lab=GND}
N 410 29210 410 29220 {
lab=GND}
N 470 29160 470 29210 {
lab=Y5}
N 470 29210 470 29220 {
lab=Y5}

N 490 29220 520 29220 {
lab=GND}
N 520 29210 520 29220 {
lab=GND}
N 480 29170 520 29170 {
lab=word486}
N 520 29170 560 29170 {
lab=word486}
N 490 29160 490 29210 {
lab=GND}
N 490 29210 490 29220 {
lab=GND}
N 550 29160 550 29210 {
lab=Y6}
N 550 29210 550 29220 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 29190 1 0 {name=M2157
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 29170 600 29170 {
lab=word486}
N 600 29170 640 29170 {
lab=word486}
N 570 29160 570 29210 {
lab=GND}
N 570 29210 570 29220 {
lab=GND}
N 630 29160 630 29210 {
lab=Y7}
N 630 29210 630 29220 {
lab=Y7}
C {devices/ipin.sym} 0 29230 0 0 {name=p510 lab=word487}
N 0 29230 40 29230 {
lab=word487}
N 40 29230 80 29230 {
lab=word487}
N 10 29220 10 29270 {
lab=GND}
N 10 29270 10 29280 {
lab=GND}
N 70 29220 70 29270 {
lab=Y0}
N 70 29270 70 29280 {
lab=Y0}

N 90 29280 120 29280 {
lab=GND}
N 120 29270 120 29280 {
lab=GND}
N 80 29230 120 29230 {
lab=word487}
N 120 29230 160 29230 {
lab=word487}
N 90 29220 90 29270 {
lab=GND}
N 90 29270 90 29280 {
lab=GND}
N 150 29220 150 29270 {
lab=Y1}
N 150 29270 150 29280 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 29250 1 0 {name=M2158
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 29230 200 29230 {
lab=word487}
N 200 29230 240 29230 {
lab=word487}
N 170 29220 170 29270 {
lab=GND}
N 170 29270 170 29280 {
lab=GND}
N 230 29220 230 29270 {
lab=Y2}
N 230 29270 230 29280 {
lab=Y2}

N 250 29280 280 29280 {
lab=GND}
N 280 29270 280 29280 {
lab=GND}
N 240 29230 280 29230 {
lab=word487}
N 280 29230 320 29230 {
lab=word487}
N 250 29220 250 29270 {
lab=GND}
N 250 29270 250 29280 {
lab=GND}
N 310 29220 310 29270 {
lab=Y3}
N 310 29270 310 29280 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 29250 1 0 {name=M2159
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 29230 360 29230 {
lab=word487}
N 360 29230 400 29230 {
lab=word487}
N 330 29220 330 29270 {
lab=GND}
N 330 29270 330 29280 {
lab=GND}
N 390 29220 390 29270 {
lab=Y4}
N 390 29270 390 29280 {
lab=Y4}

N 410 29280 440 29280 {
lab=GND}
N 440 29270 440 29280 {
lab=GND}
N 400 29230 440 29230 {
lab=word487}
N 440 29230 480 29230 {
lab=word487}
N 410 29220 410 29270 {
lab=GND}
N 410 29270 410 29280 {
lab=GND}
N 470 29220 470 29270 {
lab=Y5}
N 470 29270 470 29280 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 29250 1 0 {name=M2160
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 29230 520 29230 {
lab=word487}
N 520 29230 560 29230 {
lab=word487}
N 490 29220 490 29270 {
lab=GND}
N 490 29270 490 29280 {
lab=GND}
N 550 29220 550 29270 {
lab=Y6}
N 550 29270 550 29280 {
lab=Y6}

N 570 29280 600 29280 {
lab=GND}
N 600 29270 600 29280 {
lab=GND}
N 560 29230 600 29230 {
lab=word487}
N 600 29230 640 29230 {
lab=word487}
N 570 29220 570 29270 {
lab=GND}
N 570 29270 570 29280 {
lab=GND}
N 630 29220 630 29270 {
lab=Y7}
N 630 29270 630 29280 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29250 1 0 {name=M2161
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 29290 0 0 {name=p511 lab=word488}
N 0 29290 40 29290 {
lab=word488}
N 40 29290 80 29290 {
lab=word488}
N 10 29280 10 29330 {
lab=GND}
N 10 29330 10 29340 {
lab=GND}
N 70 29280 70 29330 {
lab=Y0}
N 70 29330 70 29340 {
lab=Y0}

N 90 29340 120 29340 {
lab=GND}
N 120 29330 120 29340 {
lab=GND}
N 80 29290 120 29290 {
lab=word488}
N 120 29290 160 29290 {
lab=word488}
N 90 29280 90 29330 {
lab=GND}
N 90 29330 90 29340 {
lab=GND}
N 150 29280 150 29330 {
lab=Y1}
N 150 29330 150 29340 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 29310 1 0 {name=M2162
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 29290 200 29290 {
lab=word488}
N 200 29290 240 29290 {
lab=word488}
N 170 29280 170 29330 {
lab=GND}
N 170 29330 170 29340 {
lab=GND}
N 230 29280 230 29330 {
lab=Y2}
N 230 29330 230 29340 {
lab=Y2}
N 240 29290 280 29290 {
lab=word488}
N 280 29290 320 29290 {
lab=word488}
N 250 29280 250 29330 {
lab=GND}
N 250 29330 250 29340 {
lab=GND}
N 310 29280 310 29330 {
lab=Y3}
N 310 29330 310 29340 {
lab=Y3}

N 330 29340 360 29340 {
lab=GND}
N 360 29330 360 29340 {
lab=GND}
N 320 29290 360 29290 {
lab=word488}
N 360 29290 400 29290 {
lab=word488}
N 330 29280 330 29330 {
lab=GND}
N 330 29330 330 29340 {
lab=GND}
N 390 29280 390 29330 {
lab=Y4}
N 390 29330 390 29340 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 29310 1 0 {name=M2163
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 29340 440 29340 {
lab=GND}
N 440 29330 440 29340 {
lab=GND}
N 400 29290 440 29290 {
lab=word488}
N 440 29290 480 29290 {
lab=word488}
N 410 29280 410 29330 {
lab=GND}
N 410 29330 410 29340 {
lab=GND}
N 470 29280 470 29330 {
lab=Y5}
N 470 29330 470 29340 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 29310 1 0 {name=M2164
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 29340 520 29340 {
lab=GND}
N 520 29330 520 29340 {
lab=GND}
N 480 29290 520 29290 {
lab=word488}
N 520 29290 560 29290 {
lab=word488}
N 490 29280 490 29330 {
lab=GND}
N 490 29330 490 29340 {
lab=GND}
N 550 29280 550 29330 {
lab=Y6}
N 550 29330 550 29340 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 29310 1 0 {name=M2165
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 29340 600 29340 {
lab=GND}
N 600 29330 600 29340 {
lab=GND}
N 560 29290 600 29290 {
lab=word488}
N 600 29290 640 29290 {
lab=word488}
N 570 29280 570 29330 {
lab=GND}
N 570 29330 570 29340 {
lab=GND}
N 630 29280 630 29330 {
lab=Y7}
N 630 29330 630 29340 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29310 1 0 {name=M2166
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 29350 0 0 {name=p512 lab=word489}
N 0 29350 40 29350 {
lab=word489}
N 40 29350 80 29350 {
lab=word489}
N 10 29340 10 29390 {
lab=GND}
N 10 29390 10 29400 {
lab=GND}
N 70 29340 70 29390 {
lab=Y0}
N 70 29390 70 29400 {
lab=Y0}

N 90 29400 120 29400 {
lab=GND}
N 120 29390 120 29400 {
lab=GND}
N 80 29350 120 29350 {
lab=word489}
N 120 29350 160 29350 {
lab=word489}
N 90 29340 90 29390 {
lab=GND}
N 90 29390 90 29400 {
lab=GND}
N 150 29340 150 29390 {
lab=Y1}
N 150 29390 150 29400 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 29370 1 0 {name=M2167
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 29350 200 29350 {
lab=word489}
N 200 29350 240 29350 {
lab=word489}
N 170 29340 170 29390 {
lab=GND}
N 170 29390 170 29400 {
lab=GND}
N 230 29340 230 29390 {
lab=Y2}
N 230 29390 230 29400 {
lab=Y2}
N 240 29350 280 29350 {
lab=word489}
N 280 29350 320 29350 {
lab=word489}
N 250 29340 250 29390 {
lab=GND}
N 250 29390 250 29400 {
lab=GND}
N 310 29340 310 29390 {
lab=Y3}
N 310 29390 310 29400 {
lab=Y3}

N 330 29400 360 29400 {
lab=GND}
N 360 29390 360 29400 {
lab=GND}
N 320 29350 360 29350 {
lab=word489}
N 360 29350 400 29350 {
lab=word489}
N 330 29340 330 29390 {
lab=GND}
N 330 29390 330 29400 {
lab=GND}
N 390 29340 390 29390 {
lab=Y4}
N 390 29390 390 29400 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 29370 1 0 {name=M2168
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 29350 440 29350 {
lab=word489}
N 440 29350 480 29350 {
lab=word489}
N 410 29340 410 29390 {
lab=GND}
N 410 29390 410 29400 {
lab=GND}
N 470 29340 470 29390 {
lab=Y5}
N 470 29390 470 29400 {
lab=Y5}
N 480 29350 520 29350 {
lab=word489}
N 520 29350 560 29350 {
lab=word489}
N 490 29340 490 29390 {
lab=GND}
N 490 29390 490 29400 {
lab=GND}
N 550 29340 550 29390 {
lab=Y6}
N 550 29390 550 29400 {
lab=Y6}

N 570 29400 600 29400 {
lab=GND}
N 600 29390 600 29400 {
lab=GND}
N 560 29350 600 29350 {
lab=word489}
N 600 29350 640 29350 {
lab=word489}
N 570 29340 570 29390 {
lab=GND}
N 570 29390 570 29400 {
lab=GND}
N 630 29340 630 29390 {
lab=Y7}
N 630 29390 630 29400 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29370 1 0 {name=M2169
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 29410 0 0 {name=p513 lab=word490}
N 0 29410 40 29410 {
lab=word490}
N 40 29410 80 29410 {
lab=word490}
N 10 29400 10 29450 {
lab=GND}
N 10 29450 10 29460 {
lab=GND}
N 70 29400 70 29450 {
lab=Y0}
N 70 29450 70 29460 {
lab=Y0}

N 90 29460 120 29460 {
lab=GND}
N 120 29450 120 29460 {
lab=GND}
N 80 29410 120 29410 {
lab=word490}
N 120 29410 160 29410 {
lab=word490}
N 90 29400 90 29450 {
lab=GND}
N 90 29450 90 29460 {
lab=GND}
N 150 29400 150 29450 {
lab=Y1}
N 150 29450 150 29460 {
lab=Y1}
C {sky130_fd_pr/nfet_01v8.sym} 120 29430 1 0 {name=M2170
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 160 29410 200 29410 {
lab=word490}
N 200 29410 240 29410 {
lab=word490}
N 170 29400 170 29450 {
lab=GND}
N 170 29450 170 29460 {
lab=GND}
N 230 29400 230 29450 {
lab=Y2}
N 230 29450 230 29460 {
lab=Y2}
N 240 29410 280 29410 {
lab=word490}
N 280 29410 320 29410 {
lab=word490}
N 250 29400 250 29450 {
lab=GND}
N 250 29450 250 29460 {
lab=GND}
N 310 29400 310 29450 {
lab=Y3}
N 310 29450 310 29460 {
lab=Y3}
N 320 29410 360 29410 {
lab=word490}
N 360 29410 400 29410 {
lab=word490}
N 330 29400 330 29450 {
lab=GND}
N 330 29450 330 29460 {
lab=GND}
N 390 29400 390 29450 {
lab=Y4}
N 390 29450 390 29460 {
lab=Y4}
N 400 29410 440 29410 {
lab=word490}
N 440 29410 480 29410 {
lab=word490}
N 410 29400 410 29450 {
lab=GND}
N 410 29450 410 29460 {
lab=GND}
N 470 29400 470 29450 {
lab=Y5}
N 470 29450 470 29460 {
lab=Y5}

N 490 29460 520 29460 {
lab=GND}
N 520 29450 520 29460 {
lab=GND}
N 480 29410 520 29410 {
lab=word490}
N 520 29410 560 29410 {
lab=word490}
N 490 29400 490 29450 {
lab=GND}
N 490 29450 490 29460 {
lab=GND}
N 550 29400 550 29450 {
lab=Y6}
N 550 29450 550 29460 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 29430 1 0 {name=M2171
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 29460 600 29460 {
lab=GND}
N 600 29450 600 29460 {
lab=GND}
N 560 29410 600 29410 {
lab=word490}
N 600 29410 640 29410 {
lab=word490}
N 570 29400 570 29450 {
lab=GND}
N 570 29450 570 29460 {
lab=GND}
N 630 29400 630 29450 {
lab=Y7}
N 630 29450 630 29460 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29430 1 0 {name=M2172
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 29470 0 0 {name=p514 lab=word491}
N 0 29470 40 29470 {
lab=word491}
N 40 29470 80 29470 {
lab=word491}
N 10 29460 10 29510 {
lab=GND}
N 10 29510 10 29520 {
lab=GND}
N 70 29460 70 29510 {
lab=Y0}
N 70 29510 70 29520 {
lab=Y0}
N 80 29470 120 29470 {
lab=word491}
N 120 29470 160 29470 {
lab=word491}
N 90 29460 90 29510 {
lab=GND}
N 90 29510 90 29520 {
lab=GND}
N 150 29460 150 29510 {
lab=Y1}
N 150 29510 150 29520 {
lab=Y1}

N 170 29520 200 29520 {
lab=GND}
N 200 29510 200 29520 {
lab=GND}
N 160 29470 200 29470 {
lab=word491}
N 200 29470 240 29470 {
lab=word491}
N 170 29460 170 29510 {
lab=GND}
N 170 29510 170 29520 {
lab=GND}
N 230 29460 230 29510 {
lab=Y2}
N 230 29510 230 29520 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 29490 1 0 {name=M2173
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 29520 280 29520 {
lab=GND}
N 280 29510 280 29520 {
lab=GND}
N 240 29470 280 29470 {
lab=word491}
N 280 29470 320 29470 {
lab=word491}
N 250 29460 250 29510 {
lab=GND}
N 250 29510 250 29520 {
lab=GND}
N 310 29460 310 29510 {
lab=Y3}
N 310 29510 310 29520 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 29490 1 0 {name=M2174
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 29520 360 29520 {
lab=GND}
N 360 29510 360 29520 {
lab=GND}
N 320 29470 360 29470 {
lab=word491}
N 360 29470 400 29470 {
lab=word491}
N 330 29460 330 29510 {
lab=GND}
N 330 29510 330 29520 {
lab=GND}
N 390 29460 390 29510 {
lab=Y4}
N 390 29510 390 29520 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 29490 1 0 {name=M2175
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 29520 440 29520 {
lab=GND}
N 440 29510 440 29520 {
lab=GND}
N 400 29470 440 29470 {
lab=word491}
N 440 29470 480 29470 {
lab=word491}
N 410 29460 410 29510 {
lab=GND}
N 410 29510 410 29520 {
lab=GND}
N 470 29460 470 29510 {
lab=Y5}
N 470 29510 470 29520 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 29490 1 0 {name=M2176
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 29520 520 29520 {
lab=GND}
N 520 29510 520 29520 {
lab=GND}
N 480 29470 520 29470 {
lab=word491}
N 520 29470 560 29470 {
lab=word491}
N 490 29460 490 29510 {
lab=GND}
N 490 29510 490 29520 {
lab=GND}
N 550 29460 550 29510 {
lab=Y6}
N 550 29510 550 29520 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 29490 1 0 {name=M2177
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 29470 600 29470 {
lab=word491}
N 600 29470 640 29470 {
lab=word491}
N 570 29460 570 29510 {
lab=GND}
N 570 29510 570 29520 {
lab=GND}
N 630 29460 630 29510 {
lab=Y7}
N 630 29510 630 29520 {
lab=Y7}
C {devices/ipin.sym} 0 29530 0 0 {name=p515 lab=word492}
N 0 29530 40 29530 {
lab=word492}
N 40 29530 80 29530 {
lab=word492}
N 10 29520 10 29570 {
lab=GND}
N 10 29570 10 29580 {
lab=GND}
N 70 29520 70 29570 {
lab=Y0}
N 70 29570 70 29580 {
lab=Y0}
N 80 29530 120 29530 {
lab=word492}
N 120 29530 160 29530 {
lab=word492}
N 90 29520 90 29570 {
lab=GND}
N 90 29570 90 29580 {
lab=GND}
N 150 29520 150 29570 {
lab=Y1}
N 150 29570 150 29580 {
lab=Y1}

N 170 29580 200 29580 {
lab=GND}
N 200 29570 200 29580 {
lab=GND}
N 160 29530 200 29530 {
lab=word492}
N 200 29530 240 29530 {
lab=word492}
N 170 29520 170 29570 {
lab=GND}
N 170 29570 170 29580 {
lab=GND}
N 230 29520 230 29570 {
lab=Y2}
N 230 29570 230 29580 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 29550 1 0 {name=M2178
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 29580 280 29580 {
lab=GND}
N 280 29570 280 29580 {
lab=GND}
N 240 29530 280 29530 {
lab=word492}
N 280 29530 320 29530 {
lab=word492}
N 250 29520 250 29570 {
lab=GND}
N 250 29570 250 29580 {
lab=GND}
N 310 29520 310 29570 {
lab=Y3}
N 310 29570 310 29580 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 29550 1 0 {name=M2179
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 29580 360 29580 {
lab=GND}
N 360 29570 360 29580 {
lab=GND}
N 320 29530 360 29530 {
lab=word492}
N 360 29530 400 29530 {
lab=word492}
N 330 29520 330 29570 {
lab=GND}
N 330 29570 330 29580 {
lab=GND}
N 390 29520 390 29570 {
lab=Y4}
N 390 29570 390 29580 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 29550 1 0 {name=M2180
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 29530 440 29530 {
lab=word492}
N 440 29530 480 29530 {
lab=word492}
N 410 29520 410 29570 {
lab=GND}
N 410 29570 410 29580 {
lab=GND}
N 470 29520 470 29570 {
lab=Y5}
N 470 29570 470 29580 {
lab=Y5}
N 480 29530 520 29530 {
lab=word492}
N 520 29530 560 29530 {
lab=word492}
N 490 29520 490 29570 {
lab=GND}
N 490 29570 490 29580 {
lab=GND}
N 550 29520 550 29570 {
lab=Y6}
N 550 29570 550 29580 {
lab=Y6}

N 570 29580 600 29580 {
lab=GND}
N 600 29570 600 29580 {
lab=GND}
N 560 29530 600 29530 {
lab=word492}
N 600 29530 640 29530 {
lab=word492}
N 570 29520 570 29570 {
lab=GND}
N 570 29570 570 29580 {
lab=GND}
N 630 29520 630 29570 {
lab=Y7}
N 630 29570 630 29580 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29550 1 0 {name=M2181
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 29590 0 0 {name=p516 lab=word493}
N 0 29590 40 29590 {
lab=word493}
N 40 29590 80 29590 {
lab=word493}
N 10 29580 10 29630 {
lab=GND}
N 10 29630 10 29640 {
lab=GND}
N 70 29580 70 29630 {
lab=Y0}
N 70 29630 70 29640 {
lab=Y0}
N 80 29590 120 29590 {
lab=word493}
N 120 29590 160 29590 {
lab=word493}
N 90 29580 90 29630 {
lab=GND}
N 90 29630 90 29640 {
lab=GND}
N 150 29580 150 29630 {
lab=Y1}
N 150 29630 150 29640 {
lab=Y1}

N 170 29640 200 29640 {
lab=GND}
N 200 29630 200 29640 {
lab=GND}
N 160 29590 200 29590 {
lab=word493}
N 200 29590 240 29590 {
lab=word493}
N 170 29580 170 29630 {
lab=GND}
N 170 29630 170 29640 {
lab=GND}
N 230 29580 230 29630 {
lab=Y2}
N 230 29630 230 29640 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 29610 1 0 {name=M2182
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 250 29640 280 29640 {
lab=GND}
N 280 29630 280 29640 {
lab=GND}
N 240 29590 280 29590 {
lab=word493}
N 280 29590 320 29590 {
lab=word493}
N 250 29580 250 29630 {
lab=GND}
N 250 29630 250 29640 {
lab=GND}
N 310 29580 310 29630 {
lab=Y3}
N 310 29630 310 29640 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 29610 1 0 {name=M2183
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 29590 360 29590 {
lab=word493}
N 360 29590 400 29590 {
lab=word493}
N 330 29580 330 29630 {
lab=GND}
N 330 29630 330 29640 {
lab=GND}
N 390 29580 390 29630 {
lab=Y4}
N 390 29630 390 29640 {
lab=Y4}

N 410 29640 440 29640 {
lab=GND}
N 440 29630 440 29640 {
lab=GND}
N 400 29590 440 29590 {
lab=word493}
N 440 29590 480 29590 {
lab=word493}
N 410 29580 410 29630 {
lab=GND}
N 410 29630 410 29640 {
lab=GND}
N 470 29580 470 29630 {
lab=Y5}
N 470 29630 470 29640 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 29610 1 0 {name=M2184
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 29590 520 29590 {
lab=word493}
N 520 29590 560 29590 {
lab=word493}
N 490 29580 490 29630 {
lab=GND}
N 490 29630 490 29640 {
lab=GND}
N 550 29580 550 29630 {
lab=Y6}
N 550 29630 550 29640 {
lab=Y6}
N 560 29590 600 29590 {
lab=word493}
N 600 29590 640 29590 {
lab=word493}
N 570 29580 570 29630 {
lab=GND}
N 570 29630 570 29640 {
lab=GND}
N 630 29580 630 29630 {
lab=Y7}
N 630 29630 630 29640 {
lab=Y7}
C {devices/ipin.sym} 0 29650 0 0 {name=p517 lab=word494}
N 0 29650 40 29650 {
lab=word494}
N 40 29650 80 29650 {
lab=word494}
N 10 29640 10 29690 {
lab=GND}
N 10 29690 10 29700 {
lab=GND}
N 70 29640 70 29690 {
lab=Y0}
N 70 29690 70 29700 {
lab=Y0}
N 80 29650 120 29650 {
lab=word494}
N 120 29650 160 29650 {
lab=word494}
N 90 29640 90 29690 {
lab=GND}
N 90 29690 90 29700 {
lab=GND}
N 150 29640 150 29690 {
lab=Y1}
N 150 29690 150 29700 {
lab=Y1}

N 170 29700 200 29700 {
lab=GND}
N 200 29690 200 29700 {
lab=GND}
N 160 29650 200 29650 {
lab=word494}
N 200 29650 240 29650 {
lab=word494}
N 170 29640 170 29690 {
lab=GND}
N 170 29690 170 29700 {
lab=GND}
N 230 29640 230 29690 {
lab=Y2}
N 230 29690 230 29700 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 29670 1 0 {name=M2185
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 29650 280 29650 {
lab=word494}
N 280 29650 320 29650 {
lab=word494}
N 250 29640 250 29690 {
lab=GND}
N 250 29690 250 29700 {
lab=GND}
N 310 29640 310 29690 {
lab=Y3}
N 310 29690 310 29700 {
lab=Y3}

N 330 29700 360 29700 {
lab=GND}
N 360 29690 360 29700 {
lab=GND}
N 320 29650 360 29650 {
lab=word494}
N 360 29650 400 29650 {
lab=word494}
N 330 29640 330 29690 {
lab=GND}
N 330 29690 330 29700 {
lab=GND}
N 390 29640 390 29690 {
lab=Y4}
N 390 29690 390 29700 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 29670 1 0 {name=M2186
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 29700 440 29700 {
lab=GND}
N 440 29690 440 29700 {
lab=GND}
N 400 29650 440 29650 {
lab=word494}
N 440 29650 480 29650 {
lab=word494}
N 410 29640 410 29690 {
lab=GND}
N 410 29690 410 29700 {
lab=GND}
N 470 29640 470 29690 {
lab=Y5}
N 470 29690 470 29700 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 29670 1 0 {name=M2187
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 29700 520 29700 {
lab=GND}
N 520 29690 520 29700 {
lab=GND}
N 480 29650 520 29650 {
lab=word494}
N 520 29650 560 29650 {
lab=word494}
N 490 29640 490 29690 {
lab=GND}
N 490 29690 490 29700 {
lab=GND}
N 550 29640 550 29690 {
lab=Y6}
N 550 29690 550 29700 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 29670 1 0 {name=M2188
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 29700 600 29700 {
lab=GND}
N 600 29690 600 29700 {
lab=GND}
N 560 29650 600 29650 {
lab=word494}
N 600 29650 640 29650 {
lab=word494}
N 570 29640 570 29690 {
lab=GND}
N 570 29690 570 29700 {
lab=GND}
N 630 29640 630 29690 {
lab=Y7}
N 630 29690 630 29700 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29670 1 0 {name=M2189
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 29710 0 0 {name=p518 lab=word495}
N 0 29710 40 29710 {
lab=word495}
N 40 29710 80 29710 {
lab=word495}
N 10 29700 10 29750 {
lab=GND}
N 10 29750 10 29760 {
lab=GND}
N 70 29700 70 29750 {
lab=Y0}
N 70 29750 70 29760 {
lab=Y0}
N 80 29710 120 29710 {
lab=word495}
N 120 29710 160 29710 {
lab=word495}
N 90 29700 90 29750 {
lab=GND}
N 90 29750 90 29760 {
lab=GND}
N 150 29700 150 29750 {
lab=Y1}
N 150 29750 150 29760 {
lab=Y1}

N 170 29760 200 29760 {
lab=GND}
N 200 29750 200 29760 {
lab=GND}
N 160 29710 200 29710 {
lab=word495}
N 200 29710 240 29710 {
lab=word495}
N 170 29700 170 29750 {
lab=GND}
N 170 29750 170 29760 {
lab=GND}
N 230 29700 230 29750 {
lab=Y2}
N 230 29750 230 29760 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 29730 1 0 {name=M2190
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 29710 280 29710 {
lab=word495}
N 280 29710 320 29710 {
lab=word495}
N 250 29700 250 29750 {
lab=GND}
N 250 29750 250 29760 {
lab=GND}
N 310 29700 310 29750 {
lab=Y3}
N 310 29750 310 29760 {
lab=Y3}

N 330 29760 360 29760 {
lab=GND}
N 360 29750 360 29760 {
lab=GND}
N 320 29710 360 29710 {
lab=word495}
N 360 29710 400 29710 {
lab=word495}
N 330 29700 330 29750 {
lab=GND}
N 330 29750 330 29760 {
lab=GND}
N 390 29700 390 29750 {
lab=Y4}
N 390 29750 390 29760 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 29730 1 0 {name=M2191
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 29710 440 29710 {
lab=word495}
N 440 29710 480 29710 {
lab=word495}
N 410 29700 410 29750 {
lab=GND}
N 410 29750 410 29760 {
lab=GND}
N 470 29700 470 29750 {
lab=Y5}
N 470 29750 470 29760 {
lab=Y5}

N 490 29760 520 29760 {
lab=GND}
N 520 29750 520 29760 {
lab=GND}
N 480 29710 520 29710 {
lab=word495}
N 520 29710 560 29710 {
lab=word495}
N 490 29700 490 29750 {
lab=GND}
N 490 29750 490 29760 {
lab=GND}
N 550 29700 550 29750 {
lab=Y6}
N 550 29750 550 29760 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 29730 1 0 {name=M2192
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 29710 600 29710 {
lab=word495}
N 600 29710 640 29710 {
lab=word495}
N 570 29700 570 29750 {
lab=GND}
N 570 29750 570 29760 {
lab=GND}
N 630 29700 630 29750 {
lab=Y7}
N 630 29750 630 29760 {
lab=Y7}
C {devices/ipin.sym} 0 29770 0 0 {name=p519 lab=word496}
N 0 29770 40 29770 {
lab=word496}
N 40 29770 80 29770 {
lab=word496}
N 10 29760 10 29810 {
lab=GND}
N 10 29810 10 29820 {
lab=GND}
N 70 29760 70 29810 {
lab=Y0}
N 70 29810 70 29820 {
lab=Y0}
N 80 29770 120 29770 {
lab=word496}
N 120 29770 160 29770 {
lab=word496}
N 90 29760 90 29810 {
lab=GND}
N 90 29810 90 29820 {
lab=GND}
N 150 29760 150 29810 {
lab=Y1}
N 150 29810 150 29820 {
lab=Y1}

N 170 29820 200 29820 {
lab=GND}
N 200 29810 200 29820 {
lab=GND}
N 160 29770 200 29770 {
lab=word496}
N 200 29770 240 29770 {
lab=word496}
N 170 29760 170 29810 {
lab=GND}
N 170 29810 170 29820 {
lab=GND}
N 230 29760 230 29810 {
lab=Y2}
N 230 29810 230 29820 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 29790 1 0 {name=M2193
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 29770 280 29770 {
lab=word496}
N 280 29770 320 29770 {
lab=word496}
N 250 29760 250 29810 {
lab=GND}
N 250 29810 250 29820 {
lab=GND}
N 310 29760 310 29810 {
lab=Y3}
N 310 29810 310 29820 {
lab=Y3}
N 320 29770 360 29770 {
lab=word496}
N 360 29770 400 29770 {
lab=word496}
N 330 29760 330 29810 {
lab=GND}
N 330 29810 330 29820 {
lab=GND}
N 390 29760 390 29810 {
lab=Y4}
N 390 29810 390 29820 {
lab=Y4}

N 410 29820 440 29820 {
lab=GND}
N 440 29810 440 29820 {
lab=GND}
N 400 29770 440 29770 {
lab=word496}
N 440 29770 480 29770 {
lab=word496}
N 410 29760 410 29810 {
lab=GND}
N 410 29810 410 29820 {
lab=GND}
N 470 29760 470 29810 {
lab=Y5}
N 470 29810 470 29820 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 29790 1 0 {name=M2194
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 29770 520 29770 {
lab=word496}
N 520 29770 560 29770 {
lab=word496}
N 490 29760 490 29810 {
lab=GND}
N 490 29810 490 29820 {
lab=GND}
N 550 29760 550 29810 {
lab=Y6}
N 550 29810 550 29820 {
lab=Y6}

N 570 29820 600 29820 {
lab=GND}
N 600 29810 600 29820 {
lab=GND}
N 560 29770 600 29770 {
lab=word496}
N 600 29770 640 29770 {
lab=word496}
N 570 29760 570 29810 {
lab=GND}
N 570 29810 570 29820 {
lab=GND}
N 630 29760 630 29810 {
lab=Y7}
N 630 29810 630 29820 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29790 1 0 {name=M2195
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 29830 0 0 {name=p520 lab=word497}
N 0 29830 40 29830 {
lab=word497}
N 40 29830 80 29830 {
lab=word497}
N 10 29820 10 29870 {
lab=GND}
N 10 29870 10 29880 {
lab=GND}
N 70 29820 70 29870 {
lab=Y0}
N 70 29870 70 29880 {
lab=Y0}
N 80 29830 120 29830 {
lab=word497}
N 120 29830 160 29830 {
lab=word497}
N 90 29820 90 29870 {
lab=GND}
N 90 29870 90 29880 {
lab=GND}
N 150 29820 150 29870 {
lab=Y1}
N 150 29870 150 29880 {
lab=Y1}

N 170 29880 200 29880 {
lab=GND}
N 200 29870 200 29880 {
lab=GND}
N 160 29830 200 29830 {
lab=word497}
N 200 29830 240 29830 {
lab=word497}
N 170 29820 170 29870 {
lab=GND}
N 170 29870 170 29880 {
lab=GND}
N 230 29820 230 29870 {
lab=Y2}
N 230 29870 230 29880 {
lab=Y2}
C {sky130_fd_pr/nfet_01v8.sym} 200 29850 1 0 {name=M2196
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 240 29830 280 29830 {
lab=word497}
N 280 29830 320 29830 {
lab=word497}
N 250 29820 250 29870 {
lab=GND}
N 250 29870 250 29880 {
lab=GND}
N 310 29820 310 29870 {
lab=Y3}
N 310 29870 310 29880 {
lab=Y3}
N 320 29830 360 29830 {
lab=word497}
N 360 29830 400 29830 {
lab=word497}
N 330 29820 330 29870 {
lab=GND}
N 330 29870 330 29880 {
lab=GND}
N 390 29820 390 29870 {
lab=Y4}
N 390 29870 390 29880 {
lab=Y4}
N 400 29830 440 29830 {
lab=word497}
N 440 29830 480 29830 {
lab=word497}
N 410 29820 410 29870 {
lab=GND}
N 410 29870 410 29880 {
lab=GND}
N 470 29820 470 29870 {
lab=Y5}
N 470 29870 470 29880 {
lab=Y5}
N 480 29830 520 29830 {
lab=word497}
N 520 29830 560 29830 {
lab=word497}
N 490 29820 490 29870 {
lab=GND}
N 490 29870 490 29880 {
lab=GND}
N 550 29820 550 29870 {
lab=Y6}
N 550 29870 550 29880 {
lab=Y6}

N 570 29880 600 29880 {
lab=GND}
N 600 29870 600 29880 {
lab=GND}
N 560 29830 600 29830 {
lab=word497}
N 600 29830 640 29830 {
lab=word497}
N 570 29820 570 29870 {
lab=GND}
N 570 29870 570 29880 {
lab=GND}
N 630 29820 630 29870 {
lab=Y7}
N 630 29870 630 29880 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29850 1 0 {name=M2197
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 29890 0 0 {name=p521 lab=word498}
N 0 29890 40 29890 {
lab=word498}
N 40 29890 80 29890 {
lab=word498}
N 10 29880 10 29930 {
lab=GND}
N 10 29930 10 29940 {
lab=GND}
N 70 29880 70 29930 {
lab=Y0}
N 70 29930 70 29940 {
lab=Y0}
N 80 29890 120 29890 {
lab=word498}
N 120 29890 160 29890 {
lab=word498}
N 90 29880 90 29930 {
lab=GND}
N 90 29930 90 29940 {
lab=GND}
N 150 29880 150 29930 {
lab=Y1}
N 150 29930 150 29940 {
lab=Y1}
N 160 29890 200 29890 {
lab=word498}
N 200 29890 240 29890 {
lab=word498}
N 170 29880 170 29930 {
lab=GND}
N 170 29930 170 29940 {
lab=GND}
N 230 29880 230 29930 {
lab=Y2}
N 230 29930 230 29940 {
lab=Y2}

N 250 29940 280 29940 {
lab=GND}
N 280 29930 280 29940 {
lab=GND}
N 240 29890 280 29890 {
lab=word498}
N 280 29890 320 29890 {
lab=word498}
N 250 29880 250 29930 {
lab=GND}
N 250 29930 250 29940 {
lab=GND}
N 310 29880 310 29930 {
lab=Y3}
N 310 29930 310 29940 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 29910 1 0 {name=M2198
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 29940 360 29940 {
lab=GND}
N 360 29930 360 29940 {
lab=GND}
N 320 29890 360 29890 {
lab=word498}
N 360 29890 400 29890 {
lab=word498}
N 330 29880 330 29930 {
lab=GND}
N 330 29930 330 29940 {
lab=GND}
N 390 29880 390 29930 {
lab=Y4}
N 390 29930 390 29940 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 29910 1 0 {name=M2199
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 29940 440 29940 {
lab=GND}
N 440 29930 440 29940 {
lab=GND}
N 400 29890 440 29890 {
lab=word498}
N 440 29890 480 29890 {
lab=word498}
N 410 29880 410 29930 {
lab=GND}
N 410 29930 410 29940 {
lab=GND}
N 470 29880 470 29930 {
lab=Y5}
N 470 29930 470 29940 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 29910 1 0 {name=M2200
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 29890 520 29890 {
lab=word498}
N 520 29890 560 29890 {
lab=word498}
N 490 29880 490 29930 {
lab=GND}
N 490 29930 490 29940 {
lab=GND}
N 550 29880 550 29930 {
lab=Y6}
N 550 29930 550 29940 {
lab=Y6}

N 570 29940 600 29940 {
lab=GND}
N 600 29930 600 29940 {
lab=GND}
N 560 29890 600 29890 {
lab=word498}
N 600 29890 640 29890 {
lab=word498}
N 570 29880 570 29930 {
lab=GND}
N 570 29930 570 29940 {
lab=GND}
N 630 29880 630 29930 {
lab=Y7}
N 630 29930 630 29940 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29910 1 0 {name=M2201
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 29950 0 0 {name=p522 lab=word499}
N 0 29950 40 29950 {
lab=word499}
N 40 29950 80 29950 {
lab=word499}
N 10 29940 10 29990 {
lab=GND}
N 10 29990 10 30000 {
lab=GND}
N 70 29940 70 29990 {
lab=Y0}
N 70 29990 70 30000 {
lab=Y0}
N 80 29950 120 29950 {
lab=word499}
N 120 29950 160 29950 {
lab=word499}
N 90 29940 90 29990 {
lab=GND}
N 90 29990 90 30000 {
lab=GND}
N 150 29940 150 29990 {
lab=Y1}
N 150 29990 150 30000 {
lab=Y1}
N 160 29950 200 29950 {
lab=word499}
N 200 29950 240 29950 {
lab=word499}
N 170 29940 170 29990 {
lab=GND}
N 170 29990 170 30000 {
lab=GND}
N 230 29940 230 29990 {
lab=Y2}
N 230 29990 230 30000 {
lab=Y2}

N 250 30000 280 30000 {
lab=GND}
N 280 29990 280 30000 {
lab=GND}
N 240 29950 280 29950 {
lab=word499}
N 280 29950 320 29950 {
lab=word499}
N 250 29940 250 29990 {
lab=GND}
N 250 29990 250 30000 {
lab=GND}
N 310 29940 310 29990 {
lab=Y3}
N 310 29990 310 30000 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 29970 1 0 {name=M2202
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 330 30000 360 30000 {
lab=GND}
N 360 29990 360 30000 {
lab=GND}
N 320 29950 360 29950 {
lab=word499}
N 360 29950 400 29950 {
lab=word499}
N 330 29940 330 29990 {
lab=GND}
N 330 29990 330 30000 {
lab=GND}
N 390 29940 390 29990 {
lab=Y4}
N 390 29990 390 30000 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 29970 1 0 {name=M2203
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 29950 440 29950 {
lab=word499}
N 440 29950 480 29950 {
lab=word499}
N 410 29940 410 29990 {
lab=GND}
N 410 29990 410 30000 {
lab=GND}
N 470 29940 470 29990 {
lab=Y5}
N 470 29990 470 30000 {
lab=Y5}
N 480 29950 520 29950 {
lab=word499}
N 520 29950 560 29950 {
lab=word499}
N 490 29940 490 29990 {
lab=GND}
N 490 29990 490 30000 {
lab=GND}
N 550 29940 550 29990 {
lab=Y6}
N 550 29990 550 30000 {
lab=Y6}

N 570 30000 600 30000 {
lab=GND}
N 600 29990 600 30000 {
lab=GND}
N 560 29950 600 29950 {
lab=word499}
N 600 29950 640 29950 {
lab=word499}
N 570 29940 570 29990 {
lab=GND}
N 570 29990 570 30000 {
lab=GND}
N 630 29940 630 29990 {
lab=Y7}
N 630 29990 630 30000 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 29970 1 0 {name=M2204
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 30010 0 0 {name=p523 lab=word500}
N 0 30010 40 30010 {
lab=word500}
N 40 30010 80 30010 {
lab=word500}
N 10 30000 10 30050 {
lab=GND}
N 10 30050 10 30060 {
lab=GND}
N 70 30000 70 30050 {
lab=Y0}
N 70 30050 70 30060 {
lab=Y0}
N 80 30010 120 30010 {
lab=word500}
N 120 30010 160 30010 {
lab=word500}
N 90 30000 90 30050 {
lab=GND}
N 90 30050 90 30060 {
lab=GND}
N 150 30000 150 30050 {
lab=Y1}
N 150 30050 150 30060 {
lab=Y1}
N 160 30010 200 30010 {
lab=word500}
N 200 30010 240 30010 {
lab=word500}
N 170 30000 170 30050 {
lab=GND}
N 170 30050 170 30060 {
lab=GND}
N 230 30000 230 30050 {
lab=Y2}
N 230 30050 230 30060 {
lab=Y2}

N 250 30060 280 30060 {
lab=GND}
N 280 30050 280 30060 {
lab=GND}
N 240 30010 280 30010 {
lab=word500}
N 280 30010 320 30010 {
lab=word500}
N 250 30000 250 30050 {
lab=GND}
N 250 30050 250 30060 {
lab=GND}
N 310 30000 310 30050 {
lab=Y3}
N 310 30050 310 30060 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 30030 1 0 {name=M2205
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 30010 360 30010 {
lab=word500}
N 360 30010 400 30010 {
lab=word500}
N 330 30000 330 30050 {
lab=GND}
N 330 30050 330 30060 {
lab=GND}
N 390 30000 390 30050 {
lab=Y4}
N 390 30050 390 30060 {
lab=Y4}

N 410 30060 440 30060 {
lab=GND}
N 440 30050 440 30060 {
lab=GND}
N 400 30010 440 30010 {
lab=word500}
N 440 30010 480 30010 {
lab=word500}
N 410 30000 410 30050 {
lab=GND}
N 410 30050 410 30060 {
lab=GND}
N 470 30000 470 30050 {
lab=Y5}
N 470 30050 470 30060 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 30030 1 0 {name=M2206
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 30010 520 30010 {
lab=word500}
N 520 30010 560 30010 {
lab=word500}
N 490 30000 490 30050 {
lab=GND}
N 490 30050 490 30060 {
lab=GND}
N 550 30000 550 30050 {
lab=Y6}
N 550 30050 550 30060 {
lab=Y6}

N 570 30060 600 30060 {
lab=GND}
N 600 30050 600 30060 {
lab=GND}
N 560 30010 600 30010 {
lab=word500}
N 600 30010 640 30010 {
lab=word500}
N 570 30000 570 30050 {
lab=GND}
N 570 30050 570 30060 {
lab=GND}
N 630 30000 630 30050 {
lab=Y7}
N 630 30050 630 30060 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 30030 1 0 {name=M2207
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 30070 0 0 {name=p524 lab=word501}
N 0 30070 40 30070 {
lab=word501}
N 40 30070 80 30070 {
lab=word501}
N 10 30060 10 30110 {
lab=GND}
N 10 30110 10 30120 {
lab=GND}
N 70 30060 70 30110 {
lab=Y0}
N 70 30110 70 30120 {
lab=Y0}
N 80 30070 120 30070 {
lab=word501}
N 120 30070 160 30070 {
lab=word501}
N 90 30060 90 30110 {
lab=GND}
N 90 30110 90 30120 {
lab=GND}
N 150 30060 150 30110 {
lab=Y1}
N 150 30110 150 30120 {
lab=Y1}
N 160 30070 200 30070 {
lab=word501}
N 200 30070 240 30070 {
lab=word501}
N 170 30060 170 30110 {
lab=GND}
N 170 30110 170 30120 {
lab=GND}
N 230 30060 230 30110 {
lab=Y2}
N 230 30110 230 30120 {
lab=Y2}

N 250 30120 280 30120 {
lab=GND}
N 280 30110 280 30120 {
lab=GND}
N 240 30070 280 30070 {
lab=word501}
N 280 30070 320 30070 {
lab=word501}
N 250 30060 250 30110 {
lab=GND}
N 250 30110 250 30120 {
lab=GND}
N 310 30060 310 30110 {
lab=Y3}
N 310 30110 310 30120 {
lab=Y3}
C {sky130_fd_pr/nfet_01v8.sym} 280 30090 1 0 {name=M2208
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 320 30070 360 30070 {
lab=word501}
N 360 30070 400 30070 {
lab=word501}
N 330 30060 330 30110 {
lab=GND}
N 330 30110 330 30120 {
lab=GND}
N 390 30060 390 30110 {
lab=Y4}
N 390 30110 390 30120 {
lab=Y4}
N 400 30070 440 30070 {
lab=word501}
N 440 30070 480 30070 {
lab=word501}
N 410 30060 410 30110 {
lab=GND}
N 410 30110 410 30120 {
lab=GND}
N 470 30060 470 30110 {
lab=Y5}
N 470 30110 470 30120 {
lab=Y5}

N 490 30120 520 30120 {
lab=GND}
N 520 30110 520 30120 {
lab=GND}
N 480 30070 520 30070 {
lab=word501}
N 520 30070 560 30070 {
lab=word501}
N 490 30060 490 30110 {
lab=GND}
N 490 30110 490 30120 {
lab=GND}
N 550 30060 550 30110 {
lab=Y6}
N 550 30110 550 30120 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 30090 1 0 {name=M2209
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 30070 600 30070 {
lab=word501}
N 600 30070 640 30070 {
lab=word501}
N 570 30060 570 30110 {
lab=GND}
N 570 30110 570 30120 {
lab=GND}
N 630 30060 630 30110 {
lab=Y7}
N 630 30110 630 30120 {
lab=Y7}
C {devices/ipin.sym} 0 30130 0 0 {name=p525 lab=word502}
N 0 30130 40 30130 {
lab=word502}
N 40 30130 80 30130 {
lab=word502}
N 10 30120 10 30170 {
lab=GND}
N 10 30170 10 30180 {
lab=GND}
N 70 30120 70 30170 {
lab=Y0}
N 70 30170 70 30180 {
lab=Y0}
N 80 30130 120 30130 {
lab=word502}
N 120 30130 160 30130 {
lab=word502}
N 90 30120 90 30170 {
lab=GND}
N 90 30170 90 30180 {
lab=GND}
N 150 30120 150 30170 {
lab=Y1}
N 150 30170 150 30180 {
lab=Y1}
N 160 30130 200 30130 {
lab=word502}
N 200 30130 240 30130 {
lab=word502}
N 170 30120 170 30170 {
lab=GND}
N 170 30170 170 30180 {
lab=GND}
N 230 30120 230 30170 {
lab=Y2}
N 230 30170 230 30180 {
lab=Y2}
N 240 30130 280 30130 {
lab=word502}
N 280 30130 320 30130 {
lab=word502}
N 250 30120 250 30170 {
lab=GND}
N 250 30170 250 30180 {
lab=GND}
N 310 30120 310 30170 {
lab=Y3}
N 310 30170 310 30180 {
lab=Y3}

N 330 30180 360 30180 {
lab=GND}
N 360 30170 360 30180 {
lab=GND}
N 320 30130 360 30130 {
lab=word502}
N 360 30130 400 30130 {
lab=word502}
N 330 30120 330 30170 {
lab=GND}
N 330 30170 330 30180 {
lab=GND}
N 390 30120 390 30170 {
lab=Y4}
N 390 30170 390 30180 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 30150 1 0 {name=M2210
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 30180 440 30180 {
lab=GND}
N 440 30170 440 30180 {
lab=GND}
N 400 30130 440 30130 {
lab=word502}
N 440 30130 480 30130 {
lab=word502}
N 410 30120 410 30170 {
lab=GND}
N 410 30170 410 30180 {
lab=GND}
N 470 30120 470 30170 {
lab=Y5}
N 470 30170 470 30180 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 30150 1 0 {name=M2211
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 30180 520 30180 {
lab=GND}
N 520 30170 520 30180 {
lab=GND}
N 480 30130 520 30130 {
lab=word502}
N 520 30130 560 30130 {
lab=word502}
N 490 30120 490 30170 {
lab=GND}
N 490 30170 490 30180 {
lab=GND}
N 550 30120 550 30170 {
lab=Y6}
N 550 30170 550 30180 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 30150 1 0 {name=M2212
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 30180 600 30180 {
lab=GND}
N 600 30170 600 30180 {
lab=GND}
N 560 30130 600 30130 {
lab=word502}
N 600 30130 640 30130 {
lab=word502}
N 570 30120 570 30170 {
lab=GND}
N 570 30170 570 30180 {
lab=GND}
N 630 30120 630 30170 {
lab=Y7}
N 630 30170 630 30180 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 30150 1 0 {name=M2213
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 30190 0 0 {name=p526 lab=word503}
N 0 30190 40 30190 {
lab=word503}
N 40 30190 80 30190 {
lab=word503}
N 10 30180 10 30230 {
lab=GND}
N 10 30230 10 30240 {
lab=GND}
N 70 30180 70 30230 {
lab=Y0}
N 70 30230 70 30240 {
lab=Y0}
N 80 30190 120 30190 {
lab=word503}
N 120 30190 160 30190 {
lab=word503}
N 90 30180 90 30230 {
lab=GND}
N 90 30230 90 30240 {
lab=GND}
N 150 30180 150 30230 {
lab=Y1}
N 150 30230 150 30240 {
lab=Y1}
N 160 30190 200 30190 {
lab=word503}
N 200 30190 240 30190 {
lab=word503}
N 170 30180 170 30230 {
lab=GND}
N 170 30230 170 30240 {
lab=GND}
N 230 30180 230 30230 {
lab=Y2}
N 230 30230 230 30240 {
lab=Y2}
N 240 30190 280 30190 {
lab=word503}
N 280 30190 320 30190 {
lab=word503}
N 250 30180 250 30230 {
lab=GND}
N 250 30230 250 30240 {
lab=GND}
N 310 30180 310 30230 {
lab=Y3}
N 310 30230 310 30240 {
lab=Y3}

N 330 30240 360 30240 {
lab=GND}
N 360 30230 360 30240 {
lab=GND}
N 320 30190 360 30190 {
lab=word503}
N 360 30190 400 30190 {
lab=word503}
N 330 30180 330 30230 {
lab=GND}
N 330 30230 330 30240 {
lab=GND}
N 390 30180 390 30230 {
lab=Y4}
N 390 30230 390 30240 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 30210 1 0 {name=M2214
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 410 30240 440 30240 {
lab=GND}
N 440 30230 440 30240 {
lab=GND}
N 400 30190 440 30190 {
lab=word503}
N 440 30190 480 30190 {
lab=word503}
N 410 30180 410 30230 {
lab=GND}
N 410 30230 410 30240 {
lab=GND}
N 470 30180 470 30230 {
lab=Y5}
N 470 30230 470 30240 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 30210 1 0 {name=M2215
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 30190 520 30190 {
lab=word503}
N 520 30190 560 30190 {
lab=word503}
N 490 30180 490 30230 {
lab=GND}
N 490 30230 490 30240 {
lab=GND}
N 550 30180 550 30230 {
lab=Y6}
N 550 30230 550 30240 {
lab=Y6}
N 560 30190 600 30190 {
lab=word503}
N 600 30190 640 30190 {
lab=word503}
N 570 30180 570 30230 {
lab=GND}
N 570 30230 570 30240 {
lab=GND}
N 630 30180 630 30230 {
lab=Y7}
N 630 30230 630 30240 {
lab=Y7}
C {devices/ipin.sym} 0 30250 0 0 {name=p527 lab=word504}
N 0 30250 40 30250 {
lab=word504}
N 40 30250 80 30250 {
lab=word504}
N 10 30240 10 30290 {
lab=GND}
N 10 30290 10 30300 {
lab=GND}
N 70 30240 70 30290 {
lab=Y0}
N 70 30290 70 30300 {
lab=Y0}
N 80 30250 120 30250 {
lab=word504}
N 120 30250 160 30250 {
lab=word504}
N 90 30240 90 30290 {
lab=GND}
N 90 30290 90 30300 {
lab=GND}
N 150 30240 150 30290 {
lab=Y1}
N 150 30290 150 30300 {
lab=Y1}
N 160 30250 200 30250 {
lab=word504}
N 200 30250 240 30250 {
lab=word504}
N 170 30240 170 30290 {
lab=GND}
N 170 30290 170 30300 {
lab=GND}
N 230 30240 230 30290 {
lab=Y2}
N 230 30290 230 30300 {
lab=Y2}
N 240 30250 280 30250 {
lab=word504}
N 280 30250 320 30250 {
lab=word504}
N 250 30240 250 30290 {
lab=GND}
N 250 30290 250 30300 {
lab=GND}
N 310 30240 310 30290 {
lab=Y3}
N 310 30290 310 30300 {
lab=Y3}

N 330 30300 360 30300 {
lab=GND}
N 360 30290 360 30300 {
lab=GND}
N 320 30250 360 30250 {
lab=word504}
N 360 30250 400 30250 {
lab=word504}
N 330 30240 330 30290 {
lab=GND}
N 330 30290 330 30300 {
lab=GND}
N 390 30240 390 30290 {
lab=Y4}
N 390 30290 390 30300 {
lab=Y4}
C {sky130_fd_pr/nfet_01v8.sym} 360 30270 1 0 {name=M2216
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 400 30250 440 30250 {
lab=word504}
N 440 30250 480 30250 {
lab=word504}
N 410 30240 410 30290 {
lab=GND}
N 410 30290 410 30300 {
lab=GND}
N 470 30240 470 30290 {
lab=Y5}
N 470 30290 470 30300 {
lab=Y5}

N 490 30300 520 30300 {
lab=GND}
N 520 30290 520 30300 {
lab=GND}
N 480 30250 520 30250 {
lab=word504}
N 520 30250 560 30250 {
lab=word504}
N 490 30240 490 30290 {
lab=GND}
N 490 30290 490 30300 {
lab=GND}
N 550 30240 550 30290 {
lab=Y6}
N 550 30290 550 30300 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 30270 1 0 {name=M2217
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 30250 600 30250 {
lab=word504}
N 600 30250 640 30250 {
lab=word504}
N 570 30240 570 30290 {
lab=GND}
N 570 30290 570 30300 {
lab=GND}
N 630 30240 630 30290 {
lab=Y7}
N 630 30290 630 30300 {
lab=Y7}
C {devices/ipin.sym} 0 30310 0 0 {name=p528 lab=word505}
N 0 30310 40 30310 {
lab=word505}
N 40 30310 80 30310 {
lab=word505}
N 10 30300 10 30350 {
lab=GND}
N 10 30350 10 30360 {
lab=GND}
N 70 30300 70 30350 {
lab=Y0}
N 70 30350 70 30360 {
lab=Y0}
N 80 30310 120 30310 {
lab=word505}
N 120 30310 160 30310 {
lab=word505}
N 90 30300 90 30350 {
lab=GND}
N 90 30350 90 30360 {
lab=GND}
N 150 30300 150 30350 {
lab=Y1}
N 150 30350 150 30360 {
lab=Y1}
N 160 30310 200 30310 {
lab=word505}
N 200 30310 240 30310 {
lab=word505}
N 170 30300 170 30350 {
lab=GND}
N 170 30350 170 30360 {
lab=GND}
N 230 30300 230 30350 {
lab=Y2}
N 230 30350 230 30360 {
lab=Y2}
N 240 30310 280 30310 {
lab=word505}
N 280 30310 320 30310 {
lab=word505}
N 250 30300 250 30350 {
lab=GND}
N 250 30350 250 30360 {
lab=GND}
N 310 30300 310 30350 {
lab=Y3}
N 310 30350 310 30360 {
lab=Y3}
N 320 30310 360 30310 {
lab=word505}
N 360 30310 400 30310 {
lab=word505}
N 330 30300 330 30350 {
lab=GND}
N 330 30350 330 30360 {
lab=GND}
N 390 30300 390 30350 {
lab=Y4}
N 390 30350 390 30360 {
lab=Y4}

N 410 30360 440 30360 {
lab=GND}
N 440 30350 440 30360 {
lab=GND}
N 400 30310 440 30310 {
lab=word505}
N 440 30310 480 30310 {
lab=word505}
N 410 30300 410 30350 {
lab=GND}
N 410 30350 410 30360 {
lab=GND}
N 470 30300 470 30350 {
lab=Y5}
N 470 30350 470 30360 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 30330 1 0 {name=M2218
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 490 30360 520 30360 {
lab=GND}
N 520 30350 520 30360 {
lab=GND}
N 480 30310 520 30310 {
lab=word505}
N 520 30310 560 30310 {
lab=word505}
N 490 30300 490 30350 {
lab=GND}
N 490 30350 490 30360 {
lab=GND}
N 550 30300 550 30350 {
lab=Y6}
N 550 30350 550 30360 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 30330 1 0 {name=M2219
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

N 570 30360 600 30360 {
lab=GND}
N 600 30350 600 30360 {
lab=GND}
N 560 30310 600 30310 {
lab=word505}
N 600 30310 640 30310 {
lab=word505}
N 570 30300 570 30350 {
lab=GND}
N 570 30350 570 30360 {
lab=GND}
N 630 30300 630 30350 {
lab=Y7}
N 630 30350 630 30360 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 30330 1 0 {name=M2220
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 30370 0 0 {name=p529 lab=word506}
N 0 30370 40 30370 {
lab=word506}
N 40 30370 80 30370 {
lab=word506}
N 10 30360 10 30410 {
lab=GND}
N 10 30410 10 30420 {
lab=GND}
N 70 30360 70 30410 {
lab=Y0}
N 70 30410 70 30420 {
lab=Y0}
N 80 30370 120 30370 {
lab=word506}
N 120 30370 160 30370 {
lab=word506}
N 90 30360 90 30410 {
lab=GND}
N 90 30410 90 30420 {
lab=GND}
N 150 30360 150 30410 {
lab=Y1}
N 150 30410 150 30420 {
lab=Y1}
N 160 30370 200 30370 {
lab=word506}
N 200 30370 240 30370 {
lab=word506}
N 170 30360 170 30410 {
lab=GND}
N 170 30410 170 30420 {
lab=GND}
N 230 30360 230 30410 {
lab=Y2}
N 230 30410 230 30420 {
lab=Y2}
N 240 30370 280 30370 {
lab=word506}
N 280 30370 320 30370 {
lab=word506}
N 250 30360 250 30410 {
lab=GND}
N 250 30410 250 30420 {
lab=GND}
N 310 30360 310 30410 {
lab=Y3}
N 310 30410 310 30420 {
lab=Y3}
N 320 30370 360 30370 {
lab=word506}
N 360 30370 400 30370 {
lab=word506}
N 330 30360 330 30410 {
lab=GND}
N 330 30410 330 30420 {
lab=GND}
N 390 30360 390 30410 {
lab=Y4}
N 390 30410 390 30420 {
lab=Y4}

N 410 30420 440 30420 {
lab=GND}
N 440 30410 440 30420 {
lab=GND}
N 400 30370 440 30370 {
lab=word506}
N 440 30370 480 30370 {
lab=word506}
N 410 30360 410 30410 {
lab=GND}
N 410 30410 410 30420 {
lab=GND}
N 470 30360 470 30410 {
lab=Y5}
N 470 30410 470 30420 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 30390 1 0 {name=M2221
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 30370 520 30370 {
lab=word506}
N 520 30370 560 30370 {
lab=word506}
N 490 30360 490 30410 {
lab=GND}
N 490 30410 490 30420 {
lab=GND}
N 550 30360 550 30410 {
lab=Y6}
N 550 30410 550 30420 {
lab=Y6}

N 570 30420 600 30420 {
lab=GND}
N 600 30410 600 30420 {
lab=GND}
N 560 30370 600 30370 {
lab=word506}
N 600 30370 640 30370 {
lab=word506}
N 570 30360 570 30410 {
lab=GND}
N 570 30410 570 30420 {
lab=GND}
N 630 30360 630 30410 {
lab=Y7}
N 630 30410 630 30420 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 30390 1 0 {name=M2222
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 30430 0 0 {name=p530 lab=word507}
N 0 30430 40 30430 {
lab=word507}
N 40 30430 80 30430 {
lab=word507}
N 10 30420 10 30470 {
lab=GND}
N 10 30470 10 30480 {
lab=GND}
N 70 30420 70 30470 {
lab=Y0}
N 70 30470 70 30480 {
lab=Y0}
N 80 30430 120 30430 {
lab=word507}
N 120 30430 160 30430 {
lab=word507}
N 90 30420 90 30470 {
lab=GND}
N 90 30470 90 30480 {
lab=GND}
N 150 30420 150 30470 {
lab=Y1}
N 150 30470 150 30480 {
lab=Y1}
N 160 30430 200 30430 {
lab=word507}
N 200 30430 240 30430 {
lab=word507}
N 170 30420 170 30470 {
lab=GND}
N 170 30470 170 30480 {
lab=GND}
N 230 30420 230 30470 {
lab=Y2}
N 230 30470 230 30480 {
lab=Y2}
N 240 30430 280 30430 {
lab=word507}
N 280 30430 320 30430 {
lab=word507}
N 250 30420 250 30470 {
lab=GND}
N 250 30470 250 30480 {
lab=GND}
N 310 30420 310 30470 {
lab=Y3}
N 310 30470 310 30480 {
lab=Y3}
N 320 30430 360 30430 {
lab=word507}
N 360 30430 400 30430 {
lab=word507}
N 330 30420 330 30470 {
lab=GND}
N 330 30470 330 30480 {
lab=GND}
N 390 30420 390 30470 {
lab=Y4}
N 390 30470 390 30480 {
lab=Y4}

N 410 30480 440 30480 {
lab=GND}
N 440 30470 440 30480 {
lab=GND}
N 400 30430 440 30430 {
lab=word507}
N 440 30430 480 30430 {
lab=word507}
N 410 30420 410 30470 {
lab=GND}
N 410 30470 410 30480 {
lab=GND}
N 470 30420 470 30470 {
lab=Y5}
N 470 30470 470 30480 {
lab=Y5}
C {sky130_fd_pr/nfet_01v8.sym} 440 30450 1 0 {name=M2223
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 480 30430 520 30430 {
lab=word507}
N 520 30430 560 30430 {
lab=word507}
N 490 30420 490 30470 {
lab=GND}
N 490 30470 490 30480 {
lab=GND}
N 550 30420 550 30470 {
lab=Y6}
N 550 30470 550 30480 {
lab=Y6}
N 560 30430 600 30430 {
lab=word507}
N 600 30430 640 30430 {
lab=word507}
N 570 30420 570 30470 {
lab=GND}
N 570 30470 570 30480 {
lab=GND}
N 630 30420 630 30470 {
lab=Y7}
N 630 30470 630 30480 {
lab=Y7}
C {devices/ipin.sym} 0 30490 0 0 {name=p531 lab=word508}
N 0 30490 40 30490 {
lab=word508}
N 40 30490 80 30490 {
lab=word508}
N 10 30480 10 30530 {
lab=GND}
N 10 30530 10 30540 {
lab=GND}
N 70 30480 70 30530 {
lab=Y0}
N 70 30530 70 30540 {
lab=Y0}
N 80 30490 120 30490 {
lab=word508}
N 120 30490 160 30490 {
lab=word508}
N 90 30480 90 30530 {
lab=GND}
N 90 30530 90 30540 {
lab=GND}
N 150 30480 150 30530 {
lab=Y1}
N 150 30530 150 30540 {
lab=Y1}
N 160 30490 200 30490 {
lab=word508}
N 200 30490 240 30490 {
lab=word508}
N 170 30480 170 30530 {
lab=GND}
N 170 30530 170 30540 {
lab=GND}
N 230 30480 230 30530 {
lab=Y2}
N 230 30530 230 30540 {
lab=Y2}
N 240 30490 280 30490 {
lab=word508}
N 280 30490 320 30490 {
lab=word508}
N 250 30480 250 30530 {
lab=GND}
N 250 30530 250 30540 {
lab=GND}
N 310 30480 310 30530 {
lab=Y3}
N 310 30530 310 30540 {
lab=Y3}
N 320 30490 360 30490 {
lab=word508}
N 360 30490 400 30490 {
lab=word508}
N 330 30480 330 30530 {
lab=GND}
N 330 30530 330 30540 {
lab=GND}
N 390 30480 390 30530 {
lab=Y4}
N 390 30530 390 30540 {
lab=Y4}
N 400 30490 440 30490 {
lab=word508}
N 440 30490 480 30490 {
lab=word508}
N 410 30480 410 30530 {
lab=GND}
N 410 30530 410 30540 {
lab=GND}
N 470 30480 470 30530 {
lab=Y5}
N 470 30530 470 30540 {
lab=Y5}

N 490 30540 520 30540 {
lab=GND}
N 520 30530 520 30540 {
lab=GND}
N 480 30490 520 30490 {
lab=word508}
N 520 30490 560 30490 {
lab=word508}
N 490 30480 490 30530 {
lab=GND}
N 490 30530 490 30540 {
lab=GND}
N 550 30480 550 30530 {
lab=Y6}
N 550 30530 550 30540 {
lab=Y6}
C {sky130_fd_pr/nfet_01v8.sym} 520 30510 1 0 {name=M2224
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
N 560 30490 600 30490 {
lab=word508}
N 600 30490 640 30490 {
lab=word508}
N 570 30480 570 30530 {
lab=GND}
N 570 30530 570 30540 {
lab=GND}
N 630 30480 630 30530 {
lab=Y7}
N 630 30530 630 30540 {
lab=Y7}
C {devices/ipin.sym} 0 30550 0 0 {name=p532 lab=word509}
N 0 30550 40 30550 {
lab=word509}
N 40 30550 80 30550 {
lab=word509}
N 10 30540 10 30590 {
lab=GND}
N 10 30590 10 30600 {
lab=GND}
N 70 30540 70 30590 {
lab=Y0}
N 70 30590 70 30600 {
lab=Y0}
N 80 30550 120 30550 {
lab=word509}
N 120 30550 160 30550 {
lab=word509}
N 90 30540 90 30590 {
lab=GND}
N 90 30590 90 30600 {
lab=GND}
N 150 30540 150 30590 {
lab=Y1}
N 150 30590 150 30600 {
lab=Y1}
N 160 30550 200 30550 {
lab=word509}
N 200 30550 240 30550 {
lab=word509}
N 170 30540 170 30590 {
lab=GND}
N 170 30590 170 30600 {
lab=GND}
N 230 30540 230 30590 {
lab=Y2}
N 230 30590 230 30600 {
lab=Y2}
N 240 30550 280 30550 {
lab=word509}
N 280 30550 320 30550 {
lab=word509}
N 250 30540 250 30590 {
lab=GND}
N 250 30590 250 30600 {
lab=GND}
N 310 30540 310 30590 {
lab=Y3}
N 310 30590 310 30600 {
lab=Y3}
N 320 30550 360 30550 {
lab=word509}
N 360 30550 400 30550 {
lab=word509}
N 330 30540 330 30590 {
lab=GND}
N 330 30590 330 30600 {
lab=GND}
N 390 30540 390 30590 {
lab=Y4}
N 390 30590 390 30600 {
lab=Y4}
N 400 30550 440 30550 {
lab=word509}
N 440 30550 480 30550 {
lab=word509}
N 410 30540 410 30590 {
lab=GND}
N 410 30590 410 30600 {
lab=GND}
N 470 30540 470 30590 {
lab=Y5}
N 470 30590 470 30600 {
lab=Y5}
N 480 30550 520 30550 {
lab=word509}
N 520 30550 560 30550 {
lab=word509}
N 490 30540 490 30590 {
lab=GND}
N 490 30590 490 30600 {
lab=GND}
N 550 30540 550 30590 {
lab=Y6}
N 550 30590 550 30600 {
lab=Y6}

N 570 30600 600 30600 {
lab=GND}
N 600 30590 600 30600 {
lab=GND}
N 560 30550 600 30550 {
lab=word509}
N 600 30550 640 30550 {
lab=word509}
N 570 30540 570 30590 {
lab=GND}
N 570 30590 570 30600 {
lab=GND}
N 630 30540 630 30590 {
lab=Y7}
N 630 30590 630 30600 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 30570 1 0 {name=M2225
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 30610 0 0 {name=p533 lab=word510}
N 0 30610 40 30610 {
lab=word510}
N 40 30610 80 30610 {
lab=word510}
N 10 30600 10 30650 {
lab=GND}
N 10 30650 10 30660 {
lab=GND}
N 70 30600 70 30650 {
lab=Y0}
N 70 30650 70 30660 {
lab=Y0}
N 80 30610 120 30610 {
lab=word510}
N 120 30610 160 30610 {
lab=word510}
N 90 30600 90 30650 {
lab=GND}
N 90 30650 90 30660 {
lab=GND}
N 150 30600 150 30650 {
lab=Y1}
N 150 30650 150 30660 {
lab=Y1}
N 160 30610 200 30610 {
lab=word510}
N 200 30610 240 30610 {
lab=word510}
N 170 30600 170 30650 {
lab=GND}
N 170 30650 170 30660 {
lab=GND}
N 230 30600 230 30650 {
lab=Y2}
N 230 30650 230 30660 {
lab=Y2}
N 240 30610 280 30610 {
lab=word510}
N 280 30610 320 30610 {
lab=word510}
N 250 30600 250 30650 {
lab=GND}
N 250 30650 250 30660 {
lab=GND}
N 310 30600 310 30650 {
lab=Y3}
N 310 30650 310 30660 {
lab=Y3}
N 320 30610 360 30610 {
lab=word510}
N 360 30610 400 30610 {
lab=word510}
N 330 30600 330 30650 {
lab=GND}
N 330 30650 330 30660 {
lab=GND}
N 390 30600 390 30650 {
lab=Y4}
N 390 30650 390 30660 {
lab=Y4}
N 400 30610 440 30610 {
lab=word510}
N 440 30610 480 30610 {
lab=word510}
N 410 30600 410 30650 {
lab=GND}
N 410 30650 410 30660 {
lab=GND}
N 470 30600 470 30650 {
lab=Y5}
N 470 30650 470 30660 {
lab=Y5}
N 480 30610 520 30610 {
lab=word510}
N 520 30610 560 30610 {
lab=word510}
N 490 30600 490 30650 {
lab=GND}
N 490 30650 490 30660 {
lab=GND}
N 550 30600 550 30650 {
lab=Y6}
N 550 30650 550 30660 {
lab=Y6}

N 570 30660 600 30660 {
lab=GND}
N 600 30650 600 30660 {
lab=GND}
N 560 30610 600 30610 {
lab=word510}
N 600 30610 640 30610 {
lab=word510}
N 570 30600 570 30650 {
lab=GND}
N 570 30650 570 30660 {
lab=GND}
N 630 30600 630 30650 {
lab=Y7}
N 630 30650 630 30660 {
lab=Y7}
C {sky130_fd_pr/nfet_01v8.sym} 600 30630 1 0 {name=M2226
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 0 30670 0 0 {name=p534 lab=word511}
N 0 30670 40 30670 {
lab=word511}
N 40 30670 80 30670 {
lab=word511}
N 10 30660 10 30710 {
lab=GND}
N 10 30710 10 30720 {
lab=GND}
N 70 30660 70 30710 {
lab=Y0}
N 70 30710 70 30720 {
lab=Y0}
N 80 30670 120 30670 {
lab=word511}
N 120 30670 160 30670 {
lab=word511}
N 90 30660 90 30710 {
lab=GND}
N 90 30710 90 30720 {
lab=GND}
N 150 30660 150 30710 {
lab=Y1}
N 150 30710 150 30720 {
lab=Y1}
N 160 30670 200 30670 {
lab=word511}
N 200 30670 240 30670 {
lab=word511}
N 170 30660 170 30710 {
lab=GND}
N 170 30710 170 30720 {
lab=GND}
N 230 30660 230 30710 {
lab=Y2}
N 230 30710 230 30720 {
lab=Y2}
N 240 30670 280 30670 {
lab=word511}
N 280 30670 320 30670 {
lab=word511}
N 250 30660 250 30710 {
lab=GND}
N 250 30710 250 30720 {
lab=GND}
N 310 30660 310 30710 {
lab=Y3}
N 310 30710 310 30720 {
lab=Y3}
N 320 30670 360 30670 {
lab=word511}
N 360 30670 400 30670 {
lab=word511}
N 330 30660 330 30710 {
lab=GND}
N 330 30710 330 30720 {
lab=GND}
N 390 30660 390 30710 {
lab=Y4}
N 390 30710 390 30720 {
lab=Y4}
N 400 30670 440 30670 {
lab=word511}
N 440 30670 480 30670 {
lab=word511}
N 410 30660 410 30710 {
lab=GND}
N 410 30710 410 30720 {
lab=GND}
N 470 30660 470 30710 {
lab=Y5}
N 470 30710 470 30720 {
lab=Y5}
N 480 30670 520 30670 {
lab=word511}
N 520 30670 560 30670 {
lab=word511}
N 490 30660 490 30710 {
lab=GND}
N 490 30710 490 30720 {
lab=GND}
N 550 30660 550 30710 {
lab=Y6}
N 550 30710 550 30720 {
lab=Y6}
N 560 30670 600 30670 {
lab=word511}
N 600 30670 640 30670 {
lab=word511}
N 570 30660 570 30710 {
lab=GND}
N 570 30710 570 30720 {
lab=GND}
N 630 30660 630 30710 {
lab=Y7}
N 630 30710 630 30720 {
lab=Y7}
C {devices/opin.sym} 70 30720 1 0 {name=p535 lab=Y7}
C {devices/opin.sym} 150 30720 1 0 {name=p536 lab=Y6}
C {devices/opin.sym} 230 30720 1 0 {name=p537 lab=Y5}
C {devices/opin.sym} 310 30720 1 0 {name=p538 lab=Y4}
C {devices/opin.sym} 390 30720 1 0 {name=p539 lab=Y3}
C {devices/opin.sym} 470 30720 1 0 {name=p540 lab=Y2}
C {devices/opin.sym} 550 30720 1 0 {name=p541 lab=Y1}
C {devices/opin.sym} 630 30720 1 0 {name=p542 lab=Y0}
